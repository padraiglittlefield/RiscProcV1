.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_0ck50 FIND v(dout1_0) AT=30.025n

.meas tran vdout1_1ck50 FIND v(dout1_1) AT=30.025n

.meas tran vdout1_2ck50 FIND v(dout1_2) AT=30.025n

.meas tran vdout1_3ck50 FIND v(dout1_3) AT=30.025n

.meas tran vdout1_4ck50 FIND v(dout1_4) AT=30.025n

.meas tran vdout1_5ck50 FIND v(dout1_5) AT=30.025n

.meas tran vdout1_6ck50 FIND v(dout1_6) AT=30.025n

.meas tran vdout1_7ck50 FIND v(dout1_7) AT=30.025n

.meas tran vdout1_8ck50 FIND v(dout1_8) AT=30.025n

.meas tran vdout1_9ck50 FIND v(dout1_9) AT=30.025n

.meas tran vdout1_10ck50 FIND v(dout1_10) AT=30.025n

.meas tran vdout1_11ck50 FIND v(dout1_11) AT=30.025n

.meas tran vdout1_12ck50 FIND v(dout1_12) AT=30.025n

.meas tran vdout1_13ck50 FIND v(dout1_13) AT=30.025n

.meas tran vdout1_14ck50 FIND v(dout1_14) AT=30.025n

.meas tran vdout1_15ck50 FIND v(dout1_15) AT=30.025n

.meas tran vdout1_16ck50 FIND v(dout1_16) AT=30.025n

.meas tran vdout1_17ck50 FIND v(dout1_17) AT=30.025n

.meas tran vdout1_18ck50 FIND v(dout1_18) AT=30.025n

.meas tran vdout1_0ck90 FIND v(dout1_0) AT=50.025n

.meas tran vdout1_1ck90 FIND v(dout1_1) AT=50.025n

.meas tran vdout1_2ck90 FIND v(dout1_2) AT=50.025n

.meas tran vdout1_3ck90 FIND v(dout1_3) AT=50.025n

.meas tran vdout1_4ck90 FIND v(dout1_4) AT=50.025n

.meas tran vdout1_5ck90 FIND v(dout1_5) AT=50.025n

.meas tran vdout1_6ck90 FIND v(dout1_6) AT=50.025n

.meas tran vdout1_7ck90 FIND v(dout1_7) AT=50.025n

.meas tran vdout1_8ck90 FIND v(dout1_8) AT=50.025n

.meas tran vdout1_9ck90 FIND v(dout1_9) AT=50.025n

.meas tran vdout1_10ck90 FIND v(dout1_10) AT=50.025n

.meas tran vdout1_11ck90 FIND v(dout1_11) AT=50.025n

.meas tran vdout1_12ck90 FIND v(dout1_12) AT=50.025n

.meas tran vdout1_13ck90 FIND v(dout1_13) AT=50.025n

.meas tran vdout1_14ck90 FIND v(dout1_14) AT=50.025n

.meas tran vdout1_15ck90 FIND v(dout1_15) AT=50.025n

.meas tran vdout1_16ck90 FIND v(dout1_16) AT=50.025n

.meas tran vdout1_17ck90 FIND v(dout1_17) AT=50.025n

.meas tran vdout1_18ck90 FIND v(dout1_18) AT=50.025n

.meas tran vdout1_0ck100 FIND v(dout1_0) AT=55.025n

.meas tran vdout1_1ck100 FIND v(dout1_1) AT=55.025n

.meas tran vdout1_2ck100 FIND v(dout1_2) AT=55.025n

.meas tran vdout1_3ck100 FIND v(dout1_3) AT=55.025n

.meas tran vdout1_4ck100 FIND v(dout1_4) AT=55.025n

.meas tran vdout1_5ck100 FIND v(dout1_5) AT=55.025n

.meas tran vdout1_6ck100 FIND v(dout1_6) AT=55.025n

.meas tran vdout1_7ck100 FIND v(dout1_7) AT=55.025n

.meas tran vdout1_8ck100 FIND v(dout1_8) AT=55.025n

.meas tran vdout1_9ck100 FIND v(dout1_9) AT=55.025n

.meas tran vdout1_10ck100 FIND v(dout1_10) AT=55.025n

.meas tran vdout1_11ck100 FIND v(dout1_11) AT=55.025n

.meas tran vdout1_12ck100 FIND v(dout1_12) AT=55.025n

.meas tran vdout1_13ck100 FIND v(dout1_13) AT=55.025n

.meas tran vdout1_14ck100 FIND v(dout1_14) AT=55.025n

.meas tran vdout1_15ck100 FIND v(dout1_15) AT=55.025n

.meas tran vdout1_16ck100 FIND v(dout1_16) AT=55.025n

.meas tran vdout1_17ck100 FIND v(dout1_17) AT=55.025n

.meas tran vdout1_18ck100 FIND v(dout1_18) AT=55.025n

.meas tran vdout1_0ck150 FIND v(dout1_0) AT=80.025n

.meas tran vdout1_1ck150 FIND v(dout1_1) AT=80.025n

.meas tran vdout1_2ck150 FIND v(dout1_2) AT=80.025n

.meas tran vdout1_3ck150 FIND v(dout1_3) AT=80.025n

.meas tran vdout1_4ck150 FIND v(dout1_4) AT=80.025n

.meas tran vdout1_5ck150 FIND v(dout1_5) AT=80.025n

.meas tran vdout1_6ck150 FIND v(dout1_6) AT=80.025n

.meas tran vdout1_7ck150 FIND v(dout1_7) AT=80.025n

.meas tran vdout1_8ck150 FIND v(dout1_8) AT=80.025n

.meas tran vdout1_9ck150 FIND v(dout1_9) AT=80.025n

.meas tran vdout1_10ck150 FIND v(dout1_10) AT=80.025n

.meas tran vdout1_11ck150 FIND v(dout1_11) AT=80.025n

.meas tran vdout1_12ck150 FIND v(dout1_12) AT=80.025n

.meas tran vdout1_13ck150 FIND v(dout1_13) AT=80.025n

.meas tran vdout1_14ck150 FIND v(dout1_14) AT=80.025n

.meas tran vdout1_15ck150 FIND v(dout1_15) AT=80.025n

.meas tran vdout1_16ck150 FIND v(dout1_16) AT=80.025n

.meas tran vdout1_17ck150 FIND v(dout1_17) AT=80.025n

.meas tran vdout1_18ck150 FIND v(dout1_18) AT=80.025n

.meas tran vdout1_0ck160 FIND v(dout1_0) AT=85.025n

.meas tran vdout1_1ck160 FIND v(dout1_1) AT=85.025n

.meas tran vdout1_2ck160 FIND v(dout1_2) AT=85.025n

.meas tran vdout1_3ck160 FIND v(dout1_3) AT=85.025n

.meas tran vdout1_4ck160 FIND v(dout1_4) AT=85.025n

.meas tran vdout1_5ck160 FIND v(dout1_5) AT=85.025n

.meas tran vdout1_6ck160 FIND v(dout1_6) AT=85.025n

.meas tran vdout1_7ck160 FIND v(dout1_7) AT=85.025n

.meas tran vdout1_8ck160 FIND v(dout1_8) AT=85.025n

.meas tran vdout1_9ck160 FIND v(dout1_9) AT=85.025n

.meas tran vdout1_10ck160 FIND v(dout1_10) AT=85.025n

.meas tran vdout1_11ck160 FIND v(dout1_11) AT=85.025n

.meas tran vdout1_12ck160 FIND v(dout1_12) AT=85.025n

.meas tran vdout1_13ck160 FIND v(dout1_13) AT=85.025n

.meas tran vdout1_14ck160 FIND v(dout1_14) AT=85.025n

.meas tran vdout1_15ck160 FIND v(dout1_15) AT=85.025n

.meas tran vdout1_16ck160 FIND v(dout1_16) AT=85.025n

.meas tran vdout1_17ck160 FIND v(dout1_17) AT=85.025n

.meas tran vdout1_18ck160 FIND v(dout1_18) AT=85.025n

.meas tran vdout1_0ck170 FIND v(dout1_0) AT=90.025n

.meas tran vdout1_1ck170 FIND v(dout1_1) AT=90.025n

.meas tran vdout1_2ck170 FIND v(dout1_2) AT=90.025n

.meas tran vdout1_3ck170 FIND v(dout1_3) AT=90.025n

.meas tran vdout1_4ck170 FIND v(dout1_4) AT=90.025n

.meas tran vdout1_5ck170 FIND v(dout1_5) AT=90.025n

.meas tran vdout1_6ck170 FIND v(dout1_6) AT=90.025n

.meas tran vdout1_7ck170 FIND v(dout1_7) AT=90.025n

.meas tran vdout1_8ck170 FIND v(dout1_8) AT=90.025n

.meas tran vdout1_9ck170 FIND v(dout1_9) AT=90.025n

.meas tran vdout1_10ck170 FIND v(dout1_10) AT=90.025n

.meas tran vdout1_11ck170 FIND v(dout1_11) AT=90.025n

.meas tran vdout1_12ck170 FIND v(dout1_12) AT=90.025n

.meas tran vdout1_13ck170 FIND v(dout1_13) AT=90.025n

.meas tran vdout1_14ck170 FIND v(dout1_14) AT=90.025n

.meas tran vdout1_15ck170 FIND v(dout1_15) AT=90.025n

.meas tran vdout1_16ck170 FIND v(dout1_16) AT=90.025n

.meas tran vdout1_17ck170 FIND v(dout1_17) AT=90.025n

.meas tran vdout1_18ck170 FIND v(dout1_18) AT=90.025n

.meas tran vdout1_0ck220 FIND v(dout1_0) AT=115.025n

.meas tran vdout1_1ck220 FIND v(dout1_1) AT=115.025n

.meas tran vdout1_2ck220 FIND v(dout1_2) AT=115.025n

.meas tran vdout1_3ck220 FIND v(dout1_3) AT=115.025n

.meas tran vdout1_4ck220 FIND v(dout1_4) AT=115.025n

.meas tran vdout1_5ck220 FIND v(dout1_5) AT=115.025n

.meas tran vdout1_6ck220 FIND v(dout1_6) AT=115.025n

.meas tran vdout1_7ck220 FIND v(dout1_7) AT=115.025n

.meas tran vdout1_8ck220 FIND v(dout1_8) AT=115.025n

.meas tran vdout1_9ck220 FIND v(dout1_9) AT=115.025n

.meas tran vdout1_10ck220 FIND v(dout1_10) AT=115.025n

.meas tran vdout1_11ck220 FIND v(dout1_11) AT=115.025n

.meas tran vdout1_12ck220 FIND v(dout1_12) AT=115.025n

.meas tran vdout1_13ck220 FIND v(dout1_13) AT=115.025n

.meas tran vdout1_14ck220 FIND v(dout1_14) AT=115.025n

.meas tran vdout1_15ck220 FIND v(dout1_15) AT=115.025n

.meas tran vdout1_16ck220 FIND v(dout1_16) AT=115.025n

.meas tran vdout1_17ck220 FIND v(dout1_17) AT=115.025n

.meas tran vdout1_18ck220 FIND v(dout1_18) AT=115.025n

.meas tran vdout1_0ck260 FIND v(dout1_0) AT=135.025n

.meas tran vdout1_1ck260 FIND v(dout1_1) AT=135.025n

.meas tran vdout1_2ck260 FIND v(dout1_2) AT=135.025n

.meas tran vdout1_3ck260 FIND v(dout1_3) AT=135.025n

.meas tran vdout1_4ck260 FIND v(dout1_4) AT=135.025n

.meas tran vdout1_5ck260 FIND v(dout1_5) AT=135.025n

.meas tran vdout1_6ck260 FIND v(dout1_6) AT=135.025n

.meas tran vdout1_7ck260 FIND v(dout1_7) AT=135.025n

.meas tran vdout1_8ck260 FIND v(dout1_8) AT=135.025n

.meas tran vdout1_9ck260 FIND v(dout1_9) AT=135.025n

.meas tran vdout1_10ck260 FIND v(dout1_10) AT=135.025n

.meas tran vdout1_11ck260 FIND v(dout1_11) AT=135.025n

.meas tran vdout1_12ck260 FIND v(dout1_12) AT=135.025n

.meas tran vdout1_13ck260 FIND v(dout1_13) AT=135.025n

.meas tran vdout1_14ck260 FIND v(dout1_14) AT=135.025n

.meas tran vdout1_15ck260 FIND v(dout1_15) AT=135.025n

.meas tran vdout1_16ck260 FIND v(dout1_16) AT=135.025n

.meas tran vdout1_17ck260 FIND v(dout1_17) AT=135.025n

.meas tran vdout1_18ck260 FIND v(dout1_18) AT=135.025n

.meas tran vdout1_0ck290 FIND v(dout1_0) AT=150.025n

.meas tran vdout1_1ck290 FIND v(dout1_1) AT=150.025n

.meas tran vdout1_2ck290 FIND v(dout1_2) AT=150.025n

.meas tran vdout1_3ck290 FIND v(dout1_3) AT=150.025n

.meas tran vdout1_4ck290 FIND v(dout1_4) AT=150.025n

.meas tran vdout1_5ck290 FIND v(dout1_5) AT=150.025n

.meas tran vdout1_6ck290 FIND v(dout1_6) AT=150.025n

.meas tran vdout1_7ck290 FIND v(dout1_7) AT=150.025n

.meas tran vdout1_8ck290 FIND v(dout1_8) AT=150.025n

.meas tran vdout1_9ck290 FIND v(dout1_9) AT=150.025n

.meas tran vdout1_10ck290 FIND v(dout1_10) AT=150.025n

.meas tran vdout1_11ck290 FIND v(dout1_11) AT=150.025n

.meas tran vdout1_12ck290 FIND v(dout1_12) AT=150.025n

.meas tran vdout1_13ck290 FIND v(dout1_13) AT=150.025n

.meas tran vdout1_14ck290 FIND v(dout1_14) AT=150.025n

.meas tran vdout1_15ck290 FIND v(dout1_15) AT=150.025n

.meas tran vdout1_16ck290 FIND v(dout1_16) AT=150.025n

.meas tran vdout1_17ck290 FIND v(dout1_17) AT=150.025n

.meas tran vdout1_18ck290 FIND v(dout1_18) AT=150.025n

.meas tran vdout1_0ck330 FIND v(dout1_0) AT=170.025n

.meas tran vdout1_1ck330 FIND v(dout1_1) AT=170.025n

.meas tran vdout1_2ck330 FIND v(dout1_2) AT=170.025n

.meas tran vdout1_3ck330 FIND v(dout1_3) AT=170.025n

.meas tran vdout1_4ck330 FIND v(dout1_4) AT=170.025n

.meas tran vdout1_5ck330 FIND v(dout1_5) AT=170.025n

.meas tran vdout1_6ck330 FIND v(dout1_6) AT=170.025n

.meas tran vdout1_7ck330 FIND v(dout1_7) AT=170.025n

.meas tran vdout1_8ck330 FIND v(dout1_8) AT=170.025n

.meas tran vdout1_9ck330 FIND v(dout1_9) AT=170.025n

.meas tran vdout1_10ck330 FIND v(dout1_10) AT=170.025n

.meas tran vdout1_11ck330 FIND v(dout1_11) AT=170.025n

.meas tran vdout1_12ck330 FIND v(dout1_12) AT=170.025n

.meas tran vdout1_13ck330 FIND v(dout1_13) AT=170.025n

.meas tran vdout1_14ck330 FIND v(dout1_14) AT=170.025n

.meas tran vdout1_15ck330 FIND v(dout1_15) AT=170.025n

.meas tran vdout1_16ck330 FIND v(dout1_16) AT=170.025n

.meas tran vdout1_17ck330 FIND v(dout1_17) AT=170.025n

.meas tran vdout1_18ck330 FIND v(dout1_18) AT=170.025n

.meas tran vdout1_0ck360 FIND v(dout1_0) AT=185.025n

.meas tran vdout1_1ck360 FIND v(dout1_1) AT=185.025n

.meas tran vdout1_2ck360 FIND v(dout1_2) AT=185.025n

.meas tran vdout1_3ck360 FIND v(dout1_3) AT=185.025n

.meas tran vdout1_4ck360 FIND v(dout1_4) AT=185.025n

.meas tran vdout1_5ck360 FIND v(dout1_5) AT=185.025n

.meas tran vdout1_6ck360 FIND v(dout1_6) AT=185.025n

.meas tran vdout1_7ck360 FIND v(dout1_7) AT=185.025n

.meas tran vdout1_8ck360 FIND v(dout1_8) AT=185.025n

.meas tran vdout1_9ck360 FIND v(dout1_9) AT=185.025n

.meas tran vdout1_10ck360 FIND v(dout1_10) AT=185.025n

.meas tran vdout1_11ck360 FIND v(dout1_11) AT=185.025n

.meas tran vdout1_12ck360 FIND v(dout1_12) AT=185.025n

.meas tran vdout1_13ck360 FIND v(dout1_13) AT=185.025n

.meas tran vdout1_14ck360 FIND v(dout1_14) AT=185.025n

.meas tran vdout1_15ck360 FIND v(dout1_15) AT=185.025n

.meas tran vdout1_16ck360 FIND v(dout1_16) AT=185.025n

.meas tran vdout1_17ck360 FIND v(dout1_17) AT=185.025n

.meas tran vdout1_18ck360 FIND v(dout1_18) AT=185.025n

.meas tran vdout1_0ck380 FIND v(dout1_0) AT=195.025n

.meas tran vdout1_1ck380 FIND v(dout1_1) AT=195.025n

.meas tran vdout1_2ck380 FIND v(dout1_2) AT=195.025n

.meas tran vdout1_3ck380 FIND v(dout1_3) AT=195.025n

.meas tran vdout1_4ck380 FIND v(dout1_4) AT=195.025n

.meas tran vdout1_5ck380 FIND v(dout1_5) AT=195.025n

.meas tran vdout1_6ck380 FIND v(dout1_6) AT=195.025n

.meas tran vdout1_7ck380 FIND v(dout1_7) AT=195.025n

.meas tran vdout1_8ck380 FIND v(dout1_8) AT=195.025n

.meas tran vdout1_9ck380 FIND v(dout1_9) AT=195.025n

.meas tran vdout1_10ck380 FIND v(dout1_10) AT=195.025n

.meas tran vdout1_11ck380 FIND v(dout1_11) AT=195.025n

.meas tran vdout1_12ck380 FIND v(dout1_12) AT=195.025n

.meas tran vdout1_13ck380 FIND v(dout1_13) AT=195.025n

.meas tran vdout1_14ck380 FIND v(dout1_14) AT=195.025n

.meas tran vdout1_15ck380 FIND v(dout1_15) AT=195.025n

.meas tran vdout1_16ck380 FIND v(dout1_16) AT=195.025n

.meas tran vdout1_17ck380 FIND v(dout1_17) AT=195.025n

.meas tran vdout1_18ck380 FIND v(dout1_18) AT=195.025n

.meas tran vdout1_0ck390 FIND v(dout1_0) AT=200.025n

.meas tran vdout1_1ck390 FIND v(dout1_1) AT=200.025n

.meas tran vdout1_2ck390 FIND v(dout1_2) AT=200.025n

.meas tran vdout1_3ck390 FIND v(dout1_3) AT=200.025n

.meas tran vdout1_4ck390 FIND v(dout1_4) AT=200.025n

.meas tran vdout1_5ck390 FIND v(dout1_5) AT=200.025n

.meas tran vdout1_6ck390 FIND v(dout1_6) AT=200.025n

.meas tran vdout1_7ck390 FIND v(dout1_7) AT=200.025n

.meas tran vdout1_8ck390 FIND v(dout1_8) AT=200.025n

.meas tran vdout1_9ck390 FIND v(dout1_9) AT=200.025n

.meas tran vdout1_10ck390 FIND v(dout1_10) AT=200.025n

.meas tran vdout1_11ck390 FIND v(dout1_11) AT=200.025n

.meas tran vdout1_12ck390 FIND v(dout1_12) AT=200.025n

.meas tran vdout1_13ck390 FIND v(dout1_13) AT=200.025n

.meas tran vdout1_14ck390 FIND v(dout1_14) AT=200.025n

.meas tran vdout1_15ck390 FIND v(dout1_15) AT=200.025n

.meas tran vdout1_16ck390 FIND v(dout1_16) AT=200.025n

.meas tran vdout1_17ck390 FIND v(dout1_17) AT=200.025n

.meas tran vdout1_18ck390 FIND v(dout1_18) AT=200.025n

.meas tran vdout1_0ck400 FIND v(dout1_0) AT=205.025n

.meas tran vdout1_1ck400 FIND v(dout1_1) AT=205.025n

.meas tran vdout1_2ck400 FIND v(dout1_2) AT=205.025n

.meas tran vdout1_3ck400 FIND v(dout1_3) AT=205.025n

.meas tran vdout1_4ck400 FIND v(dout1_4) AT=205.025n

.meas tran vdout1_5ck400 FIND v(dout1_5) AT=205.025n

.meas tran vdout1_6ck400 FIND v(dout1_6) AT=205.025n

.meas tran vdout1_7ck400 FIND v(dout1_7) AT=205.025n

.meas tran vdout1_8ck400 FIND v(dout1_8) AT=205.025n

.meas tran vdout1_9ck400 FIND v(dout1_9) AT=205.025n

.meas tran vdout1_10ck400 FIND v(dout1_10) AT=205.025n

.meas tran vdout1_11ck400 FIND v(dout1_11) AT=205.025n

.meas tran vdout1_12ck400 FIND v(dout1_12) AT=205.025n

.meas tran vdout1_13ck400 FIND v(dout1_13) AT=205.025n

.meas tran vdout1_14ck400 FIND v(dout1_14) AT=205.025n

.meas tran vdout1_15ck400 FIND v(dout1_15) AT=205.025n

.meas tran vdout1_16ck400 FIND v(dout1_16) AT=205.025n

.meas tran vdout1_17ck400 FIND v(dout1_17) AT=205.025n

.meas tran vdout1_18ck400 FIND v(dout1_18) AT=205.025n

.meas tran vdout1_0ck420 FIND v(dout1_0) AT=215.025n

.meas tran vdout1_1ck420 FIND v(dout1_1) AT=215.025n

.meas tran vdout1_2ck420 FIND v(dout1_2) AT=215.025n

.meas tran vdout1_3ck420 FIND v(dout1_3) AT=215.025n

.meas tran vdout1_4ck420 FIND v(dout1_4) AT=215.025n

.meas tran vdout1_5ck420 FIND v(dout1_5) AT=215.025n

.meas tran vdout1_6ck420 FIND v(dout1_6) AT=215.025n

.meas tran vdout1_7ck420 FIND v(dout1_7) AT=215.025n

.meas tran vdout1_8ck420 FIND v(dout1_8) AT=215.025n

.meas tran vdout1_9ck420 FIND v(dout1_9) AT=215.025n

.meas tran vdout1_10ck420 FIND v(dout1_10) AT=215.025n

.meas tran vdout1_11ck420 FIND v(dout1_11) AT=215.025n

.meas tran vdout1_12ck420 FIND v(dout1_12) AT=215.025n

.meas tran vdout1_13ck420 FIND v(dout1_13) AT=215.025n

.meas tran vdout1_14ck420 FIND v(dout1_14) AT=215.025n

.meas tran vdout1_15ck420 FIND v(dout1_15) AT=215.025n

.meas tran vdout1_16ck420 FIND v(dout1_16) AT=215.025n

.meas tran vdout1_17ck420 FIND v(dout1_17) AT=215.025n

.meas tran vdout1_18ck420 FIND v(dout1_18) AT=215.025n

.meas tran vdout1_0ck450 FIND v(dout1_0) AT=230.025n

.meas tran vdout1_1ck450 FIND v(dout1_1) AT=230.025n

.meas tran vdout1_2ck450 FIND v(dout1_2) AT=230.025n

.meas tran vdout1_3ck450 FIND v(dout1_3) AT=230.025n

.meas tran vdout1_4ck450 FIND v(dout1_4) AT=230.025n

.meas tran vdout1_5ck450 FIND v(dout1_5) AT=230.025n

.meas tran vdout1_6ck450 FIND v(dout1_6) AT=230.025n

.meas tran vdout1_7ck450 FIND v(dout1_7) AT=230.025n

.meas tran vdout1_8ck450 FIND v(dout1_8) AT=230.025n

.meas tran vdout1_9ck450 FIND v(dout1_9) AT=230.025n

.meas tran vdout1_10ck450 FIND v(dout1_10) AT=230.025n

.meas tran vdout1_11ck450 FIND v(dout1_11) AT=230.025n

.meas tran vdout1_12ck450 FIND v(dout1_12) AT=230.025n

.meas tran vdout1_13ck450 FIND v(dout1_13) AT=230.025n

.meas tran vdout1_14ck450 FIND v(dout1_14) AT=230.025n

.meas tran vdout1_15ck450 FIND v(dout1_15) AT=230.025n

.meas tran vdout1_16ck450 FIND v(dout1_16) AT=230.025n

.meas tran vdout1_17ck450 FIND v(dout1_17) AT=230.025n

.meas tran vdout1_18ck450 FIND v(dout1_18) AT=230.025n

.meas tran vdout1_0ck470 FIND v(dout1_0) AT=240.025n

.meas tran vdout1_1ck470 FIND v(dout1_1) AT=240.025n

.meas tran vdout1_2ck470 FIND v(dout1_2) AT=240.025n

.meas tran vdout1_3ck470 FIND v(dout1_3) AT=240.025n

.meas tran vdout1_4ck470 FIND v(dout1_4) AT=240.025n

.meas tran vdout1_5ck470 FIND v(dout1_5) AT=240.025n

.meas tran vdout1_6ck470 FIND v(dout1_6) AT=240.025n

.meas tran vdout1_7ck470 FIND v(dout1_7) AT=240.025n

.meas tran vdout1_8ck470 FIND v(dout1_8) AT=240.025n

.meas tran vdout1_9ck470 FIND v(dout1_9) AT=240.025n

.meas tran vdout1_10ck470 FIND v(dout1_10) AT=240.025n

.meas tran vdout1_11ck470 FIND v(dout1_11) AT=240.025n

.meas tran vdout1_12ck470 FIND v(dout1_12) AT=240.025n

.meas tran vdout1_13ck470 FIND v(dout1_13) AT=240.025n

.meas tran vdout1_14ck470 FIND v(dout1_14) AT=240.025n

.meas tran vdout1_15ck470 FIND v(dout1_15) AT=240.025n

.meas tran vdout1_16ck470 FIND v(dout1_16) AT=240.025n

.meas tran vdout1_17ck470 FIND v(dout1_17) AT=240.025n

.meas tran vdout1_18ck470 FIND v(dout1_18) AT=240.025n

.meas tran vdout1_0ck480 FIND v(dout1_0) AT=245.025n

.meas tran vdout1_1ck480 FIND v(dout1_1) AT=245.025n

.meas tran vdout1_2ck480 FIND v(dout1_2) AT=245.025n

.meas tran vdout1_3ck480 FIND v(dout1_3) AT=245.025n

.meas tran vdout1_4ck480 FIND v(dout1_4) AT=245.025n

.meas tran vdout1_5ck480 FIND v(dout1_5) AT=245.025n

.meas tran vdout1_6ck480 FIND v(dout1_6) AT=245.025n

.meas tran vdout1_7ck480 FIND v(dout1_7) AT=245.025n

.meas tran vdout1_8ck480 FIND v(dout1_8) AT=245.025n

.meas tran vdout1_9ck480 FIND v(dout1_9) AT=245.025n

.meas tran vdout1_10ck480 FIND v(dout1_10) AT=245.025n

.meas tran vdout1_11ck480 FIND v(dout1_11) AT=245.025n

.meas tran vdout1_12ck480 FIND v(dout1_12) AT=245.025n

.meas tran vdout1_13ck480 FIND v(dout1_13) AT=245.025n

.meas tran vdout1_14ck480 FIND v(dout1_14) AT=245.025n

.meas tran vdout1_15ck480 FIND v(dout1_15) AT=245.025n

.meas tran vdout1_16ck480 FIND v(dout1_16) AT=245.025n

.meas tran vdout1_17ck480 FIND v(dout1_17) AT=245.025n

.meas tran vdout1_18ck480 FIND v(dout1_18) AT=245.025n

.meas tran vdout1_0ck490 FIND v(dout1_0) AT=250.025n

.meas tran vdout1_1ck490 FIND v(dout1_1) AT=250.025n

.meas tran vdout1_2ck490 FIND v(dout1_2) AT=250.025n

.meas tran vdout1_3ck490 FIND v(dout1_3) AT=250.025n

.meas tran vdout1_4ck490 FIND v(dout1_4) AT=250.025n

.meas tran vdout1_5ck490 FIND v(dout1_5) AT=250.025n

.meas tran vdout1_6ck490 FIND v(dout1_6) AT=250.025n

.meas tran vdout1_7ck490 FIND v(dout1_7) AT=250.025n

.meas tran vdout1_8ck490 FIND v(dout1_8) AT=250.025n

.meas tran vdout1_9ck490 FIND v(dout1_9) AT=250.025n

.meas tran vdout1_10ck490 FIND v(dout1_10) AT=250.025n

.meas tran vdout1_11ck490 FIND v(dout1_11) AT=250.025n

.meas tran vdout1_12ck490 FIND v(dout1_12) AT=250.025n

.meas tran vdout1_13ck490 FIND v(dout1_13) AT=250.025n

.meas tran vdout1_14ck490 FIND v(dout1_14) AT=250.025n

.meas tran vdout1_15ck490 FIND v(dout1_15) AT=250.025n

.meas tran vdout1_16ck490 FIND v(dout1_16) AT=250.025n

.meas tran vdout1_17ck490 FIND v(dout1_17) AT=250.025n

.meas tran vdout1_18ck490 FIND v(dout1_18) AT=250.025n

.meas tran vdout1_0ck570 FIND v(dout1_0) AT=290.025n

.meas tran vdout1_1ck570 FIND v(dout1_1) AT=290.025n

.meas tran vdout1_2ck570 FIND v(dout1_2) AT=290.025n

.meas tran vdout1_3ck570 FIND v(dout1_3) AT=290.025n

.meas tran vdout1_4ck570 FIND v(dout1_4) AT=290.025n

.meas tran vdout1_5ck570 FIND v(dout1_5) AT=290.025n

.meas tran vdout1_6ck570 FIND v(dout1_6) AT=290.025n

.meas tran vdout1_7ck570 FIND v(dout1_7) AT=290.025n

.meas tran vdout1_8ck570 FIND v(dout1_8) AT=290.025n

.meas tran vdout1_9ck570 FIND v(dout1_9) AT=290.025n

.meas tran vdout1_10ck570 FIND v(dout1_10) AT=290.025n

.meas tran vdout1_11ck570 FIND v(dout1_11) AT=290.025n

.meas tran vdout1_12ck570 FIND v(dout1_12) AT=290.025n

.meas tran vdout1_13ck570 FIND v(dout1_13) AT=290.025n

.meas tran vdout1_14ck570 FIND v(dout1_14) AT=290.025n

.meas tran vdout1_15ck570 FIND v(dout1_15) AT=290.025n

.meas tran vdout1_16ck570 FIND v(dout1_16) AT=290.025n

.meas tran vdout1_17ck570 FIND v(dout1_17) AT=290.025n

.meas tran vdout1_18ck570 FIND v(dout1_18) AT=290.025n

.meas tran vdout1_0ck580 FIND v(dout1_0) AT=295.025n

.meas tran vdout1_1ck580 FIND v(dout1_1) AT=295.025n

.meas tran vdout1_2ck580 FIND v(dout1_2) AT=295.025n

.meas tran vdout1_3ck580 FIND v(dout1_3) AT=295.025n

.meas tran vdout1_4ck580 FIND v(dout1_4) AT=295.025n

.meas tran vdout1_5ck580 FIND v(dout1_5) AT=295.025n

.meas tran vdout1_6ck580 FIND v(dout1_6) AT=295.025n

.meas tran vdout1_7ck580 FIND v(dout1_7) AT=295.025n

.meas tran vdout1_8ck580 FIND v(dout1_8) AT=295.025n

.meas tran vdout1_9ck580 FIND v(dout1_9) AT=295.025n

.meas tran vdout1_10ck580 FIND v(dout1_10) AT=295.025n

.meas tran vdout1_11ck580 FIND v(dout1_11) AT=295.025n

.meas tran vdout1_12ck580 FIND v(dout1_12) AT=295.025n

.meas tran vdout1_13ck580 FIND v(dout1_13) AT=295.025n

.meas tran vdout1_14ck580 FIND v(dout1_14) AT=295.025n

.meas tran vdout1_15ck580 FIND v(dout1_15) AT=295.025n

.meas tran vdout1_16ck580 FIND v(dout1_16) AT=295.025n

.meas tran vdout1_17ck580 FIND v(dout1_17) AT=295.025n

.meas tran vdout1_18ck580 FIND v(dout1_18) AT=295.025n

.meas tran vdout1_0ck590 FIND v(dout1_0) AT=300.025n

.meas tran vdout1_1ck590 FIND v(dout1_1) AT=300.025n

.meas tran vdout1_2ck590 FIND v(dout1_2) AT=300.025n

.meas tran vdout1_3ck590 FIND v(dout1_3) AT=300.025n

.meas tran vdout1_4ck590 FIND v(dout1_4) AT=300.025n

.meas tran vdout1_5ck590 FIND v(dout1_5) AT=300.025n

.meas tran vdout1_6ck590 FIND v(dout1_6) AT=300.025n

.meas tran vdout1_7ck590 FIND v(dout1_7) AT=300.025n

.meas tran vdout1_8ck590 FIND v(dout1_8) AT=300.025n

.meas tran vdout1_9ck590 FIND v(dout1_9) AT=300.025n

.meas tran vdout1_10ck590 FIND v(dout1_10) AT=300.025n

.meas tran vdout1_11ck590 FIND v(dout1_11) AT=300.025n

.meas tran vdout1_12ck590 FIND v(dout1_12) AT=300.025n

.meas tran vdout1_13ck590 FIND v(dout1_13) AT=300.025n

.meas tran vdout1_14ck590 FIND v(dout1_14) AT=300.025n

.meas tran vdout1_15ck590 FIND v(dout1_15) AT=300.025n

.meas tran vdout1_16ck590 FIND v(dout1_16) AT=300.025n

.meas tran vdout1_17ck590 FIND v(dout1_17) AT=300.025n

.meas tran vdout1_18ck590 FIND v(dout1_18) AT=300.025n

.meas tran vdout1_0ck620 FIND v(dout1_0) AT=315.025n

.meas tran vdout1_1ck620 FIND v(dout1_1) AT=315.025n

.meas tran vdout1_2ck620 FIND v(dout1_2) AT=315.025n

.meas tran vdout1_3ck620 FIND v(dout1_3) AT=315.025n

.meas tran vdout1_4ck620 FIND v(dout1_4) AT=315.025n

.meas tran vdout1_5ck620 FIND v(dout1_5) AT=315.025n

.meas tran vdout1_6ck620 FIND v(dout1_6) AT=315.025n

.meas tran vdout1_7ck620 FIND v(dout1_7) AT=315.025n

.meas tran vdout1_8ck620 FIND v(dout1_8) AT=315.025n

.meas tran vdout1_9ck620 FIND v(dout1_9) AT=315.025n

.meas tran vdout1_10ck620 FIND v(dout1_10) AT=315.025n

.meas tran vdout1_11ck620 FIND v(dout1_11) AT=315.025n

.meas tran vdout1_12ck620 FIND v(dout1_12) AT=315.025n

.meas tran vdout1_13ck620 FIND v(dout1_13) AT=315.025n

.meas tran vdout1_14ck620 FIND v(dout1_14) AT=315.025n

.meas tran vdout1_15ck620 FIND v(dout1_15) AT=315.025n

.meas tran vdout1_16ck620 FIND v(dout1_16) AT=315.025n

.meas tran vdout1_17ck620 FIND v(dout1_17) AT=315.025n

.meas tran vdout1_18ck620 FIND v(dout1_18) AT=315.025n

.meas tran vdout1_0ck640 FIND v(dout1_0) AT=325.025n

.meas tran vdout1_1ck640 FIND v(dout1_1) AT=325.025n

.meas tran vdout1_2ck640 FIND v(dout1_2) AT=325.025n

.meas tran vdout1_3ck640 FIND v(dout1_3) AT=325.025n

.meas tran vdout1_4ck640 FIND v(dout1_4) AT=325.025n

.meas tran vdout1_5ck640 FIND v(dout1_5) AT=325.025n

.meas tran vdout1_6ck640 FIND v(dout1_6) AT=325.025n

.meas tran vdout1_7ck640 FIND v(dout1_7) AT=325.025n

.meas tran vdout1_8ck640 FIND v(dout1_8) AT=325.025n

.meas tran vdout1_9ck640 FIND v(dout1_9) AT=325.025n

.meas tran vdout1_10ck640 FIND v(dout1_10) AT=325.025n

.meas tran vdout1_11ck640 FIND v(dout1_11) AT=325.025n

.meas tran vdout1_12ck640 FIND v(dout1_12) AT=325.025n

.meas tran vdout1_13ck640 FIND v(dout1_13) AT=325.025n

.meas tran vdout1_14ck640 FIND v(dout1_14) AT=325.025n

.meas tran vdout1_15ck640 FIND v(dout1_15) AT=325.025n

.meas tran vdout1_16ck640 FIND v(dout1_16) AT=325.025n

.meas tran vdout1_17ck640 FIND v(dout1_17) AT=325.025n

.meas tran vdout1_18ck640 FIND v(dout1_18) AT=325.025n

.meas tran vdout1_0ck650 FIND v(dout1_0) AT=330.025n

.meas tran vdout1_1ck650 FIND v(dout1_1) AT=330.025n

.meas tran vdout1_2ck650 FIND v(dout1_2) AT=330.025n

.meas tran vdout1_3ck650 FIND v(dout1_3) AT=330.025n

.meas tran vdout1_4ck650 FIND v(dout1_4) AT=330.025n

.meas tran vdout1_5ck650 FIND v(dout1_5) AT=330.025n

.meas tran vdout1_6ck650 FIND v(dout1_6) AT=330.025n

.meas tran vdout1_7ck650 FIND v(dout1_7) AT=330.025n

.meas tran vdout1_8ck650 FIND v(dout1_8) AT=330.025n

.meas tran vdout1_9ck650 FIND v(dout1_9) AT=330.025n

.meas tran vdout1_10ck650 FIND v(dout1_10) AT=330.025n

.meas tran vdout1_11ck650 FIND v(dout1_11) AT=330.025n

.meas tran vdout1_12ck650 FIND v(dout1_12) AT=330.025n

.meas tran vdout1_13ck650 FIND v(dout1_13) AT=330.025n

.meas tran vdout1_14ck650 FIND v(dout1_14) AT=330.025n

.meas tran vdout1_15ck650 FIND v(dout1_15) AT=330.025n

.meas tran vdout1_16ck650 FIND v(dout1_16) AT=330.025n

.meas tran vdout1_17ck650 FIND v(dout1_17) AT=330.025n

.meas tran vdout1_18ck650 FIND v(dout1_18) AT=330.025n

.meas tran vdout1_0ck660 FIND v(dout1_0) AT=335.025n

.meas tran vdout1_1ck660 FIND v(dout1_1) AT=335.025n

.meas tran vdout1_2ck660 FIND v(dout1_2) AT=335.025n

.meas tran vdout1_3ck660 FIND v(dout1_3) AT=335.025n

.meas tran vdout1_4ck660 FIND v(dout1_4) AT=335.025n

.meas tran vdout1_5ck660 FIND v(dout1_5) AT=335.025n

.meas tran vdout1_6ck660 FIND v(dout1_6) AT=335.025n

.meas tran vdout1_7ck660 FIND v(dout1_7) AT=335.025n

.meas tran vdout1_8ck660 FIND v(dout1_8) AT=335.025n

.meas tran vdout1_9ck660 FIND v(dout1_9) AT=335.025n

.meas tran vdout1_10ck660 FIND v(dout1_10) AT=335.025n

.meas tran vdout1_11ck660 FIND v(dout1_11) AT=335.025n

.meas tran vdout1_12ck660 FIND v(dout1_12) AT=335.025n

.meas tran vdout1_13ck660 FIND v(dout1_13) AT=335.025n

.meas tran vdout1_14ck660 FIND v(dout1_14) AT=335.025n

.meas tran vdout1_15ck660 FIND v(dout1_15) AT=335.025n

.meas tran vdout1_16ck660 FIND v(dout1_16) AT=335.025n

.meas tran vdout1_17ck660 FIND v(dout1_17) AT=335.025n

.meas tran vdout1_18ck660 FIND v(dout1_18) AT=335.025n

.meas tran vdout1_0ck670 FIND v(dout1_0) AT=340.025n

.meas tran vdout1_1ck670 FIND v(dout1_1) AT=340.025n

.meas tran vdout1_2ck670 FIND v(dout1_2) AT=340.025n

.meas tran vdout1_3ck670 FIND v(dout1_3) AT=340.025n

.meas tran vdout1_4ck670 FIND v(dout1_4) AT=340.025n

.meas tran vdout1_5ck670 FIND v(dout1_5) AT=340.025n

.meas tran vdout1_6ck670 FIND v(dout1_6) AT=340.025n

.meas tran vdout1_7ck670 FIND v(dout1_7) AT=340.025n

.meas tran vdout1_8ck670 FIND v(dout1_8) AT=340.025n

.meas tran vdout1_9ck670 FIND v(dout1_9) AT=340.025n

.meas tran vdout1_10ck670 FIND v(dout1_10) AT=340.025n

.meas tran vdout1_11ck670 FIND v(dout1_11) AT=340.025n

.meas tran vdout1_12ck670 FIND v(dout1_12) AT=340.025n

.meas tran vdout1_13ck670 FIND v(dout1_13) AT=340.025n

.meas tran vdout1_14ck670 FIND v(dout1_14) AT=340.025n

.meas tran vdout1_15ck670 FIND v(dout1_15) AT=340.025n

.meas tran vdout1_16ck670 FIND v(dout1_16) AT=340.025n

.meas tran vdout1_17ck670 FIND v(dout1_17) AT=340.025n

.meas tran vdout1_18ck670 FIND v(dout1_18) AT=340.025n

.meas tran vdout1_0ck680 FIND v(dout1_0) AT=345.025n

.meas tran vdout1_1ck680 FIND v(dout1_1) AT=345.025n

.meas tran vdout1_2ck680 FIND v(dout1_2) AT=345.025n

.meas tran vdout1_3ck680 FIND v(dout1_3) AT=345.025n

.meas tran vdout1_4ck680 FIND v(dout1_4) AT=345.025n

.meas tran vdout1_5ck680 FIND v(dout1_5) AT=345.025n

.meas tran vdout1_6ck680 FIND v(dout1_6) AT=345.025n

.meas tran vdout1_7ck680 FIND v(dout1_7) AT=345.025n

.meas tran vdout1_8ck680 FIND v(dout1_8) AT=345.025n

.meas tran vdout1_9ck680 FIND v(dout1_9) AT=345.025n

.meas tran vdout1_10ck680 FIND v(dout1_10) AT=345.025n

.meas tran vdout1_11ck680 FIND v(dout1_11) AT=345.025n

.meas tran vdout1_12ck680 FIND v(dout1_12) AT=345.025n

.meas tran vdout1_13ck680 FIND v(dout1_13) AT=345.025n

.meas tran vdout1_14ck680 FIND v(dout1_14) AT=345.025n

.meas tran vdout1_15ck680 FIND v(dout1_15) AT=345.025n

.meas tran vdout1_16ck680 FIND v(dout1_16) AT=345.025n

.meas tran vdout1_17ck680 FIND v(dout1_17) AT=345.025n

.meas tran vdout1_18ck680 FIND v(dout1_18) AT=345.025n

.meas tran vdout1_0ck710 FIND v(dout1_0) AT=360.025n

.meas tran vdout1_1ck710 FIND v(dout1_1) AT=360.025n

.meas tran vdout1_2ck710 FIND v(dout1_2) AT=360.025n

.meas tran vdout1_3ck710 FIND v(dout1_3) AT=360.025n

.meas tran vdout1_4ck710 FIND v(dout1_4) AT=360.025n

.meas tran vdout1_5ck710 FIND v(dout1_5) AT=360.025n

.meas tran vdout1_6ck710 FIND v(dout1_6) AT=360.025n

.meas tran vdout1_7ck710 FIND v(dout1_7) AT=360.025n

.meas tran vdout1_8ck710 FIND v(dout1_8) AT=360.025n

.meas tran vdout1_9ck710 FIND v(dout1_9) AT=360.025n

.meas tran vdout1_10ck710 FIND v(dout1_10) AT=360.025n

.meas tran vdout1_11ck710 FIND v(dout1_11) AT=360.025n

.meas tran vdout1_12ck710 FIND v(dout1_12) AT=360.025n

.meas tran vdout1_13ck710 FIND v(dout1_13) AT=360.025n

.meas tran vdout1_14ck710 FIND v(dout1_14) AT=360.025n

.meas tran vdout1_15ck710 FIND v(dout1_15) AT=360.025n

.meas tran vdout1_16ck710 FIND v(dout1_16) AT=360.025n

.meas tran vdout1_17ck710 FIND v(dout1_17) AT=360.025n

.meas tran vdout1_18ck710 FIND v(dout1_18) AT=360.025n

.meas tran vdout1_0ck720 FIND v(dout1_0) AT=365.025n

.meas tran vdout1_1ck720 FIND v(dout1_1) AT=365.025n

.meas tran vdout1_2ck720 FIND v(dout1_2) AT=365.025n

.meas tran vdout1_3ck720 FIND v(dout1_3) AT=365.025n

.meas tran vdout1_4ck720 FIND v(dout1_4) AT=365.025n

.meas tran vdout1_5ck720 FIND v(dout1_5) AT=365.025n

.meas tran vdout1_6ck720 FIND v(dout1_6) AT=365.025n

.meas tran vdout1_7ck720 FIND v(dout1_7) AT=365.025n

.meas tran vdout1_8ck720 FIND v(dout1_8) AT=365.025n

.meas tran vdout1_9ck720 FIND v(dout1_9) AT=365.025n

.meas tran vdout1_10ck720 FIND v(dout1_10) AT=365.025n

.meas tran vdout1_11ck720 FIND v(dout1_11) AT=365.025n

.meas tran vdout1_12ck720 FIND v(dout1_12) AT=365.025n

.meas tran vdout1_13ck720 FIND v(dout1_13) AT=365.025n

.meas tran vdout1_14ck720 FIND v(dout1_14) AT=365.025n

.meas tran vdout1_15ck720 FIND v(dout1_15) AT=365.025n

.meas tran vdout1_16ck720 FIND v(dout1_16) AT=365.025n

.meas tran vdout1_17ck720 FIND v(dout1_17) AT=365.025n

.meas tran vdout1_18ck720 FIND v(dout1_18) AT=365.025n

.meas tran vdout1_0ck740 FIND v(dout1_0) AT=375.025n

.meas tran vdout1_1ck740 FIND v(dout1_1) AT=375.025n

.meas tran vdout1_2ck740 FIND v(dout1_2) AT=375.025n

.meas tran vdout1_3ck740 FIND v(dout1_3) AT=375.025n

.meas tran vdout1_4ck740 FIND v(dout1_4) AT=375.025n

.meas tran vdout1_5ck740 FIND v(dout1_5) AT=375.025n

.meas tran vdout1_6ck740 FIND v(dout1_6) AT=375.025n

.meas tran vdout1_7ck740 FIND v(dout1_7) AT=375.025n

.meas tran vdout1_8ck740 FIND v(dout1_8) AT=375.025n

.meas tran vdout1_9ck740 FIND v(dout1_9) AT=375.025n

.meas tran vdout1_10ck740 FIND v(dout1_10) AT=375.025n

.meas tran vdout1_11ck740 FIND v(dout1_11) AT=375.025n

.meas tran vdout1_12ck740 FIND v(dout1_12) AT=375.025n

.meas tran vdout1_13ck740 FIND v(dout1_13) AT=375.025n

.meas tran vdout1_14ck740 FIND v(dout1_14) AT=375.025n

.meas tran vdout1_15ck740 FIND v(dout1_15) AT=375.025n

.meas tran vdout1_16ck740 FIND v(dout1_16) AT=375.025n

.meas tran vdout1_17ck740 FIND v(dout1_17) AT=375.025n

.meas tran vdout1_18ck740 FIND v(dout1_18) AT=375.025n

.meas tran vdout1_0ck760 FIND v(dout1_0) AT=385.025n

.meas tran vdout1_1ck760 FIND v(dout1_1) AT=385.025n

.meas tran vdout1_2ck760 FIND v(dout1_2) AT=385.025n

.meas tran vdout1_3ck760 FIND v(dout1_3) AT=385.025n

.meas tran vdout1_4ck760 FIND v(dout1_4) AT=385.025n

.meas tran vdout1_5ck760 FIND v(dout1_5) AT=385.025n

.meas tran vdout1_6ck760 FIND v(dout1_6) AT=385.025n

.meas tran vdout1_7ck760 FIND v(dout1_7) AT=385.025n

.meas tran vdout1_8ck760 FIND v(dout1_8) AT=385.025n

.meas tran vdout1_9ck760 FIND v(dout1_9) AT=385.025n

.meas tran vdout1_10ck760 FIND v(dout1_10) AT=385.025n

.meas tran vdout1_11ck760 FIND v(dout1_11) AT=385.025n

.meas tran vdout1_12ck760 FIND v(dout1_12) AT=385.025n

.meas tran vdout1_13ck760 FIND v(dout1_13) AT=385.025n

.meas tran vdout1_14ck760 FIND v(dout1_14) AT=385.025n

.meas tran vdout1_15ck760 FIND v(dout1_15) AT=385.025n

.meas tran vdout1_16ck760 FIND v(dout1_16) AT=385.025n

.meas tran vdout1_17ck760 FIND v(dout1_17) AT=385.025n

.meas tran vdout1_18ck760 FIND v(dout1_18) AT=385.025n

.meas tran vdout1_0ck800 FIND v(dout1_0) AT=405.025n

.meas tran vdout1_1ck800 FIND v(dout1_1) AT=405.025n

.meas tran vdout1_2ck800 FIND v(dout1_2) AT=405.025n

.meas tran vdout1_3ck800 FIND v(dout1_3) AT=405.025n

.meas tran vdout1_4ck800 FIND v(dout1_4) AT=405.025n

.meas tran vdout1_5ck800 FIND v(dout1_5) AT=405.025n

.meas tran vdout1_6ck800 FIND v(dout1_6) AT=405.025n

.meas tran vdout1_7ck800 FIND v(dout1_7) AT=405.025n

.meas tran vdout1_8ck800 FIND v(dout1_8) AT=405.025n

.meas tran vdout1_9ck800 FIND v(dout1_9) AT=405.025n

.meas tran vdout1_10ck800 FIND v(dout1_10) AT=405.025n

.meas tran vdout1_11ck800 FIND v(dout1_11) AT=405.025n

.meas tran vdout1_12ck800 FIND v(dout1_12) AT=405.025n

.meas tran vdout1_13ck800 FIND v(dout1_13) AT=405.025n

.meas tran vdout1_14ck800 FIND v(dout1_14) AT=405.025n

.meas tran vdout1_15ck800 FIND v(dout1_15) AT=405.025n

.meas tran vdout1_16ck800 FIND v(dout1_16) AT=405.025n

.meas tran vdout1_17ck800 FIND v(dout1_17) AT=405.025n

.meas tran vdout1_18ck800 FIND v(dout1_18) AT=405.025n

.meas tran vdout1_0ck850 FIND v(dout1_0) AT=430.025n

.meas tran vdout1_1ck850 FIND v(dout1_1) AT=430.025n

.meas tran vdout1_2ck850 FIND v(dout1_2) AT=430.025n

.meas tran vdout1_3ck850 FIND v(dout1_3) AT=430.025n

.meas tran vdout1_4ck850 FIND v(dout1_4) AT=430.025n

.meas tran vdout1_5ck850 FIND v(dout1_5) AT=430.025n

.meas tran vdout1_6ck850 FIND v(dout1_6) AT=430.025n

.meas tran vdout1_7ck850 FIND v(dout1_7) AT=430.025n

.meas tran vdout1_8ck850 FIND v(dout1_8) AT=430.025n

.meas tran vdout1_9ck850 FIND v(dout1_9) AT=430.025n

.meas tran vdout1_10ck850 FIND v(dout1_10) AT=430.025n

.meas tran vdout1_11ck850 FIND v(dout1_11) AT=430.025n

.meas tran vdout1_12ck850 FIND v(dout1_12) AT=430.025n

.meas tran vdout1_13ck850 FIND v(dout1_13) AT=430.025n

.meas tran vdout1_14ck850 FIND v(dout1_14) AT=430.025n

.meas tran vdout1_15ck850 FIND v(dout1_15) AT=430.025n

.meas tran vdout1_16ck850 FIND v(dout1_16) AT=430.025n

.meas tran vdout1_17ck850 FIND v(dout1_17) AT=430.025n

.meas tran vdout1_18ck850 FIND v(dout1_18) AT=430.025n

.meas tran vdout1_0ck890 FIND v(dout1_0) AT=450.025n

.meas tran vdout1_1ck890 FIND v(dout1_1) AT=450.025n

.meas tran vdout1_2ck890 FIND v(dout1_2) AT=450.025n

.meas tran vdout1_3ck890 FIND v(dout1_3) AT=450.025n

.meas tran vdout1_4ck890 FIND v(dout1_4) AT=450.025n

.meas tran vdout1_5ck890 FIND v(dout1_5) AT=450.025n

.meas tran vdout1_6ck890 FIND v(dout1_6) AT=450.025n

.meas tran vdout1_7ck890 FIND v(dout1_7) AT=450.025n

.meas tran vdout1_8ck890 FIND v(dout1_8) AT=450.025n

.meas tran vdout1_9ck890 FIND v(dout1_9) AT=450.025n

.meas tran vdout1_10ck890 FIND v(dout1_10) AT=450.025n

.meas tran vdout1_11ck890 FIND v(dout1_11) AT=450.025n

.meas tran vdout1_12ck890 FIND v(dout1_12) AT=450.025n

.meas tran vdout1_13ck890 FIND v(dout1_13) AT=450.025n

.meas tran vdout1_14ck890 FIND v(dout1_14) AT=450.025n

.meas tran vdout1_15ck890 FIND v(dout1_15) AT=450.025n

.meas tran vdout1_16ck890 FIND v(dout1_16) AT=450.025n

.meas tran vdout1_17ck890 FIND v(dout1_17) AT=450.025n

.meas tran vdout1_18ck890 FIND v(dout1_18) AT=450.025n

.meas tran vdout1_0ck900 FIND v(dout1_0) AT=455.025n

.meas tran vdout1_1ck900 FIND v(dout1_1) AT=455.025n

.meas tran vdout1_2ck900 FIND v(dout1_2) AT=455.025n

.meas tran vdout1_3ck900 FIND v(dout1_3) AT=455.025n

.meas tran vdout1_4ck900 FIND v(dout1_4) AT=455.025n

.meas tran vdout1_5ck900 FIND v(dout1_5) AT=455.025n

.meas tran vdout1_6ck900 FIND v(dout1_6) AT=455.025n

.meas tran vdout1_7ck900 FIND v(dout1_7) AT=455.025n

.meas tran vdout1_8ck900 FIND v(dout1_8) AT=455.025n

.meas tran vdout1_9ck900 FIND v(dout1_9) AT=455.025n

.meas tran vdout1_10ck900 FIND v(dout1_10) AT=455.025n

.meas tran vdout1_11ck900 FIND v(dout1_11) AT=455.025n

.meas tran vdout1_12ck900 FIND v(dout1_12) AT=455.025n

.meas tran vdout1_13ck900 FIND v(dout1_13) AT=455.025n

.meas tran vdout1_14ck900 FIND v(dout1_14) AT=455.025n

.meas tran vdout1_15ck900 FIND v(dout1_15) AT=455.025n

.meas tran vdout1_16ck900 FIND v(dout1_16) AT=455.025n

.meas tran vdout1_17ck900 FIND v(dout1_17) AT=455.025n

.meas tran vdout1_18ck900 FIND v(dout1_18) AT=455.025n

.meas tran vdout1_0ck920 FIND v(dout1_0) AT=465.025n

.meas tran vdout1_1ck920 FIND v(dout1_1) AT=465.025n

.meas tran vdout1_2ck920 FIND v(dout1_2) AT=465.025n

.meas tran vdout1_3ck920 FIND v(dout1_3) AT=465.025n

.meas tran vdout1_4ck920 FIND v(dout1_4) AT=465.025n

.meas tran vdout1_5ck920 FIND v(dout1_5) AT=465.025n

.meas tran vdout1_6ck920 FIND v(dout1_6) AT=465.025n

.meas tran vdout1_7ck920 FIND v(dout1_7) AT=465.025n

.meas tran vdout1_8ck920 FIND v(dout1_8) AT=465.025n

.meas tran vdout1_9ck920 FIND v(dout1_9) AT=465.025n

.meas tran vdout1_10ck920 FIND v(dout1_10) AT=465.025n

.meas tran vdout1_11ck920 FIND v(dout1_11) AT=465.025n

.meas tran vdout1_12ck920 FIND v(dout1_12) AT=465.025n

.meas tran vdout1_13ck920 FIND v(dout1_13) AT=465.025n

.meas tran vdout1_14ck920 FIND v(dout1_14) AT=465.025n

.meas tran vdout1_15ck920 FIND v(dout1_15) AT=465.025n

.meas tran vdout1_16ck920 FIND v(dout1_16) AT=465.025n

.meas tran vdout1_17ck920 FIND v(dout1_17) AT=465.025n

.meas tran vdout1_18ck920 FIND v(dout1_18) AT=465.025n

.meas tran vdout1_0ck960 FIND v(dout1_0) AT=485.025n

.meas tran vdout1_1ck960 FIND v(dout1_1) AT=485.025n

.meas tran vdout1_2ck960 FIND v(dout1_2) AT=485.025n

.meas tran vdout1_3ck960 FIND v(dout1_3) AT=485.025n

.meas tran vdout1_4ck960 FIND v(dout1_4) AT=485.025n

.meas tran vdout1_5ck960 FIND v(dout1_5) AT=485.025n

.meas tran vdout1_6ck960 FIND v(dout1_6) AT=485.025n

.meas tran vdout1_7ck960 FIND v(dout1_7) AT=485.025n

.meas tran vdout1_8ck960 FIND v(dout1_8) AT=485.025n

.meas tran vdout1_9ck960 FIND v(dout1_9) AT=485.025n

.meas tran vdout1_10ck960 FIND v(dout1_10) AT=485.025n

.meas tran vdout1_11ck960 FIND v(dout1_11) AT=485.025n

.meas tran vdout1_12ck960 FIND v(dout1_12) AT=485.025n

.meas tran vdout1_13ck960 FIND v(dout1_13) AT=485.025n

.meas tran vdout1_14ck960 FIND v(dout1_14) AT=485.025n

.meas tran vdout1_15ck960 FIND v(dout1_15) AT=485.025n

.meas tran vdout1_16ck960 FIND v(dout1_16) AT=485.025n

.meas tran vdout1_17ck960 FIND v(dout1_17) AT=485.025n

.meas tran vdout1_18ck960 FIND v(dout1_18) AT=485.025n

.meas tran vdout1_0ck990 FIND v(dout1_0) AT=500.025n

.meas tran vdout1_1ck990 FIND v(dout1_1) AT=500.025n

.meas tran vdout1_2ck990 FIND v(dout1_2) AT=500.025n

.meas tran vdout1_3ck990 FIND v(dout1_3) AT=500.025n

.meas tran vdout1_4ck990 FIND v(dout1_4) AT=500.025n

.meas tran vdout1_5ck990 FIND v(dout1_5) AT=500.025n

.meas tran vdout1_6ck990 FIND v(dout1_6) AT=500.025n

.meas tran vdout1_7ck990 FIND v(dout1_7) AT=500.025n

.meas tran vdout1_8ck990 FIND v(dout1_8) AT=500.025n

.meas tran vdout1_9ck990 FIND v(dout1_9) AT=500.025n

.meas tran vdout1_10ck990 FIND v(dout1_10) AT=500.025n

.meas tran vdout1_11ck990 FIND v(dout1_11) AT=500.025n

.meas tran vdout1_12ck990 FIND v(dout1_12) AT=500.025n

.meas tran vdout1_13ck990 FIND v(dout1_13) AT=500.025n

.meas tran vdout1_14ck990 FIND v(dout1_14) AT=500.025n

.meas tran vdout1_15ck990 FIND v(dout1_15) AT=500.025n

.meas tran vdout1_16ck990 FIND v(dout1_16) AT=500.025n

.meas tran vdout1_17ck990 FIND v(dout1_17) AT=500.025n

.meas tran vdout1_18ck990 FIND v(dout1_18) AT=500.025n

.meas tran vdout1_0ck1010 FIND v(dout1_0) AT=510.025n

.meas tran vdout1_1ck1010 FIND v(dout1_1) AT=510.025n

.meas tran vdout1_2ck1010 FIND v(dout1_2) AT=510.025n

.meas tran vdout1_3ck1010 FIND v(dout1_3) AT=510.025n

.meas tran vdout1_4ck1010 FIND v(dout1_4) AT=510.025n

.meas tran vdout1_5ck1010 FIND v(dout1_5) AT=510.025n

.meas tran vdout1_6ck1010 FIND v(dout1_6) AT=510.025n

.meas tran vdout1_7ck1010 FIND v(dout1_7) AT=510.025n

.meas tran vdout1_8ck1010 FIND v(dout1_8) AT=510.025n

.meas tran vdout1_9ck1010 FIND v(dout1_9) AT=510.025n

.meas tran vdout1_10ck1010 FIND v(dout1_10) AT=510.025n

.meas tran vdout1_11ck1010 FIND v(dout1_11) AT=510.025n

.meas tran vdout1_12ck1010 FIND v(dout1_12) AT=510.025n

.meas tran vdout1_13ck1010 FIND v(dout1_13) AT=510.025n

.meas tran vdout1_14ck1010 FIND v(dout1_14) AT=510.025n

.meas tran vdout1_15ck1010 FIND v(dout1_15) AT=510.025n

.meas tran vdout1_16ck1010 FIND v(dout1_16) AT=510.025n

.meas tran vdout1_17ck1010 FIND v(dout1_17) AT=510.025n

.meas tran vdout1_18ck1010 FIND v(dout1_18) AT=510.025n

.meas tran vdout1_0ck1030 FIND v(dout1_0) AT=520.025n

.meas tran vdout1_1ck1030 FIND v(dout1_1) AT=520.025n

.meas tran vdout1_2ck1030 FIND v(dout1_2) AT=520.025n

.meas tran vdout1_3ck1030 FIND v(dout1_3) AT=520.025n

.meas tran vdout1_4ck1030 FIND v(dout1_4) AT=520.025n

.meas tran vdout1_5ck1030 FIND v(dout1_5) AT=520.025n

.meas tran vdout1_6ck1030 FIND v(dout1_6) AT=520.025n

.meas tran vdout1_7ck1030 FIND v(dout1_7) AT=520.025n

.meas tran vdout1_8ck1030 FIND v(dout1_8) AT=520.025n

.meas tran vdout1_9ck1030 FIND v(dout1_9) AT=520.025n

.meas tran vdout1_10ck1030 FIND v(dout1_10) AT=520.025n

.meas tran vdout1_11ck1030 FIND v(dout1_11) AT=520.025n

.meas tran vdout1_12ck1030 FIND v(dout1_12) AT=520.025n

.meas tran vdout1_13ck1030 FIND v(dout1_13) AT=520.025n

.meas tran vdout1_14ck1030 FIND v(dout1_14) AT=520.025n

.meas tran vdout1_15ck1030 FIND v(dout1_15) AT=520.025n

.meas tran vdout1_16ck1030 FIND v(dout1_16) AT=520.025n

.meas tran vdout1_17ck1030 FIND v(dout1_17) AT=520.025n

.meas tran vdout1_18ck1030 FIND v(dout1_18) AT=520.025n

.meas tran vdout1_0ck1040 FIND v(dout1_0) AT=525.025n

.meas tran vdout1_1ck1040 FIND v(dout1_1) AT=525.025n

.meas tran vdout1_2ck1040 FIND v(dout1_2) AT=525.025n

.meas tran vdout1_3ck1040 FIND v(dout1_3) AT=525.025n

.meas tran vdout1_4ck1040 FIND v(dout1_4) AT=525.025n

.meas tran vdout1_5ck1040 FIND v(dout1_5) AT=525.025n

.meas tran vdout1_6ck1040 FIND v(dout1_6) AT=525.025n

.meas tran vdout1_7ck1040 FIND v(dout1_7) AT=525.025n

.meas tran vdout1_8ck1040 FIND v(dout1_8) AT=525.025n

.meas tran vdout1_9ck1040 FIND v(dout1_9) AT=525.025n

.meas tran vdout1_10ck1040 FIND v(dout1_10) AT=525.025n

.meas tran vdout1_11ck1040 FIND v(dout1_11) AT=525.025n

.meas tran vdout1_12ck1040 FIND v(dout1_12) AT=525.025n

.meas tran vdout1_13ck1040 FIND v(dout1_13) AT=525.025n

.meas tran vdout1_14ck1040 FIND v(dout1_14) AT=525.025n

.meas tran vdout1_15ck1040 FIND v(dout1_15) AT=525.025n

.meas tran vdout1_16ck1040 FIND v(dout1_16) AT=525.025n

.meas tran vdout1_17ck1040 FIND v(dout1_17) AT=525.025n

.meas tran vdout1_18ck1040 FIND v(dout1_18) AT=525.025n

.meas tran vdout1_0ck1080 FIND v(dout1_0) AT=545.025n

.meas tran vdout1_1ck1080 FIND v(dout1_1) AT=545.025n

.meas tran vdout1_2ck1080 FIND v(dout1_2) AT=545.025n

.meas tran vdout1_3ck1080 FIND v(dout1_3) AT=545.025n

.meas tran vdout1_4ck1080 FIND v(dout1_4) AT=545.025n

.meas tran vdout1_5ck1080 FIND v(dout1_5) AT=545.025n

.meas tran vdout1_6ck1080 FIND v(dout1_6) AT=545.025n

.meas tran vdout1_7ck1080 FIND v(dout1_7) AT=545.025n

.meas tran vdout1_8ck1080 FIND v(dout1_8) AT=545.025n

.meas tran vdout1_9ck1080 FIND v(dout1_9) AT=545.025n

.meas tran vdout1_10ck1080 FIND v(dout1_10) AT=545.025n

.meas tran vdout1_11ck1080 FIND v(dout1_11) AT=545.025n

.meas tran vdout1_12ck1080 FIND v(dout1_12) AT=545.025n

.meas tran vdout1_13ck1080 FIND v(dout1_13) AT=545.025n

.meas tran vdout1_14ck1080 FIND v(dout1_14) AT=545.025n

.meas tran vdout1_15ck1080 FIND v(dout1_15) AT=545.025n

.meas tran vdout1_16ck1080 FIND v(dout1_16) AT=545.025n

.meas tran vdout1_17ck1080 FIND v(dout1_17) AT=545.025n

.meas tran vdout1_18ck1080 FIND v(dout1_18) AT=545.025n

.meas tran vdout1_0ck1110 FIND v(dout1_0) AT=560.025n

.meas tran vdout1_1ck1110 FIND v(dout1_1) AT=560.025n

.meas tran vdout1_2ck1110 FIND v(dout1_2) AT=560.025n

.meas tran vdout1_3ck1110 FIND v(dout1_3) AT=560.025n

.meas tran vdout1_4ck1110 FIND v(dout1_4) AT=560.025n

.meas tran vdout1_5ck1110 FIND v(dout1_5) AT=560.025n

.meas tran vdout1_6ck1110 FIND v(dout1_6) AT=560.025n

.meas tran vdout1_7ck1110 FIND v(dout1_7) AT=560.025n

.meas tran vdout1_8ck1110 FIND v(dout1_8) AT=560.025n

.meas tran vdout1_9ck1110 FIND v(dout1_9) AT=560.025n

.meas tran vdout1_10ck1110 FIND v(dout1_10) AT=560.025n

.meas tran vdout1_11ck1110 FIND v(dout1_11) AT=560.025n

.meas tran vdout1_12ck1110 FIND v(dout1_12) AT=560.025n

.meas tran vdout1_13ck1110 FIND v(dout1_13) AT=560.025n

.meas tran vdout1_14ck1110 FIND v(dout1_14) AT=560.025n

.meas tran vdout1_15ck1110 FIND v(dout1_15) AT=560.025n

.meas tran vdout1_16ck1110 FIND v(dout1_16) AT=560.025n

.meas tran vdout1_17ck1110 FIND v(dout1_17) AT=560.025n

.meas tran vdout1_18ck1110 FIND v(dout1_18) AT=560.025n

.meas tran vdout1_0ck1150 FIND v(dout1_0) AT=580.025n

.meas tran vdout1_1ck1150 FIND v(dout1_1) AT=580.025n

.meas tran vdout1_2ck1150 FIND v(dout1_2) AT=580.025n

.meas tran vdout1_3ck1150 FIND v(dout1_3) AT=580.025n

.meas tran vdout1_4ck1150 FIND v(dout1_4) AT=580.025n

.meas tran vdout1_5ck1150 FIND v(dout1_5) AT=580.025n

.meas tran vdout1_6ck1150 FIND v(dout1_6) AT=580.025n

.meas tran vdout1_7ck1150 FIND v(dout1_7) AT=580.025n

.meas tran vdout1_8ck1150 FIND v(dout1_8) AT=580.025n

.meas tran vdout1_9ck1150 FIND v(dout1_9) AT=580.025n

.meas tran vdout1_10ck1150 FIND v(dout1_10) AT=580.025n

.meas tran vdout1_11ck1150 FIND v(dout1_11) AT=580.025n

.meas tran vdout1_12ck1150 FIND v(dout1_12) AT=580.025n

.meas tran vdout1_13ck1150 FIND v(dout1_13) AT=580.025n

.meas tran vdout1_14ck1150 FIND v(dout1_14) AT=580.025n

.meas tran vdout1_15ck1150 FIND v(dout1_15) AT=580.025n

.meas tran vdout1_16ck1150 FIND v(dout1_16) AT=580.025n

.meas tran vdout1_17ck1150 FIND v(dout1_17) AT=580.025n

.meas tran vdout1_18ck1150 FIND v(dout1_18) AT=580.025n

.meas tran vdout1_0ck1180 FIND v(dout1_0) AT=595.025n

.meas tran vdout1_1ck1180 FIND v(dout1_1) AT=595.025n

.meas tran vdout1_2ck1180 FIND v(dout1_2) AT=595.025n

.meas tran vdout1_3ck1180 FIND v(dout1_3) AT=595.025n

.meas tran vdout1_4ck1180 FIND v(dout1_4) AT=595.025n

.meas tran vdout1_5ck1180 FIND v(dout1_5) AT=595.025n

.meas tran vdout1_6ck1180 FIND v(dout1_6) AT=595.025n

.meas tran vdout1_7ck1180 FIND v(dout1_7) AT=595.025n

.meas tran vdout1_8ck1180 FIND v(dout1_8) AT=595.025n

.meas tran vdout1_9ck1180 FIND v(dout1_9) AT=595.025n

.meas tran vdout1_10ck1180 FIND v(dout1_10) AT=595.025n

.meas tran vdout1_11ck1180 FIND v(dout1_11) AT=595.025n

.meas tran vdout1_12ck1180 FIND v(dout1_12) AT=595.025n

.meas tran vdout1_13ck1180 FIND v(dout1_13) AT=595.025n

.meas tran vdout1_14ck1180 FIND v(dout1_14) AT=595.025n

.meas tran vdout1_15ck1180 FIND v(dout1_15) AT=595.025n

.meas tran vdout1_16ck1180 FIND v(dout1_16) AT=595.025n

.meas tran vdout1_17ck1180 FIND v(dout1_17) AT=595.025n

.meas tran vdout1_18ck1180 FIND v(dout1_18) AT=595.025n

.meas tran vdout1_0ck1190 FIND v(dout1_0) AT=600.025n

.meas tran vdout1_1ck1190 FIND v(dout1_1) AT=600.025n

.meas tran vdout1_2ck1190 FIND v(dout1_2) AT=600.025n

.meas tran vdout1_3ck1190 FIND v(dout1_3) AT=600.025n

.meas tran vdout1_4ck1190 FIND v(dout1_4) AT=600.025n

.meas tran vdout1_5ck1190 FIND v(dout1_5) AT=600.025n

.meas tran vdout1_6ck1190 FIND v(dout1_6) AT=600.025n

.meas tran vdout1_7ck1190 FIND v(dout1_7) AT=600.025n

.meas tran vdout1_8ck1190 FIND v(dout1_8) AT=600.025n

.meas tran vdout1_9ck1190 FIND v(dout1_9) AT=600.025n

.meas tran vdout1_10ck1190 FIND v(dout1_10) AT=600.025n

.meas tran vdout1_11ck1190 FIND v(dout1_11) AT=600.025n

.meas tran vdout1_12ck1190 FIND v(dout1_12) AT=600.025n

.meas tran vdout1_13ck1190 FIND v(dout1_13) AT=600.025n

.meas tran vdout1_14ck1190 FIND v(dout1_14) AT=600.025n

.meas tran vdout1_15ck1190 FIND v(dout1_15) AT=600.025n

.meas tran vdout1_16ck1190 FIND v(dout1_16) AT=600.025n

.meas tran vdout1_17ck1190 FIND v(dout1_17) AT=600.025n

.meas tran vdout1_18ck1190 FIND v(dout1_18) AT=600.025n

.meas tran vdout1_0ck1210 FIND v(dout1_0) AT=610.025n

.meas tran vdout1_1ck1210 FIND v(dout1_1) AT=610.025n

.meas tran vdout1_2ck1210 FIND v(dout1_2) AT=610.025n

.meas tran vdout1_3ck1210 FIND v(dout1_3) AT=610.025n

.meas tran vdout1_4ck1210 FIND v(dout1_4) AT=610.025n

.meas tran vdout1_5ck1210 FIND v(dout1_5) AT=610.025n

.meas tran vdout1_6ck1210 FIND v(dout1_6) AT=610.025n

.meas tran vdout1_7ck1210 FIND v(dout1_7) AT=610.025n

.meas tran vdout1_8ck1210 FIND v(dout1_8) AT=610.025n

.meas tran vdout1_9ck1210 FIND v(dout1_9) AT=610.025n

.meas tran vdout1_10ck1210 FIND v(dout1_10) AT=610.025n

.meas tran vdout1_11ck1210 FIND v(dout1_11) AT=610.025n

.meas tran vdout1_12ck1210 FIND v(dout1_12) AT=610.025n

.meas tran vdout1_13ck1210 FIND v(dout1_13) AT=610.025n

.meas tran vdout1_14ck1210 FIND v(dout1_14) AT=610.025n

.meas tran vdout1_15ck1210 FIND v(dout1_15) AT=610.025n

.meas tran vdout1_16ck1210 FIND v(dout1_16) AT=610.025n

.meas tran vdout1_17ck1210 FIND v(dout1_17) AT=610.025n

.meas tran vdout1_18ck1210 FIND v(dout1_18) AT=610.025n

.meas tran vdout1_0ck1220 FIND v(dout1_0) AT=615.025n

.meas tran vdout1_1ck1220 FIND v(dout1_1) AT=615.025n

.meas tran vdout1_2ck1220 FIND v(dout1_2) AT=615.025n

.meas tran vdout1_3ck1220 FIND v(dout1_3) AT=615.025n

.meas tran vdout1_4ck1220 FIND v(dout1_4) AT=615.025n

.meas tran vdout1_5ck1220 FIND v(dout1_5) AT=615.025n

.meas tran vdout1_6ck1220 FIND v(dout1_6) AT=615.025n

.meas tran vdout1_7ck1220 FIND v(dout1_7) AT=615.025n

.meas tran vdout1_8ck1220 FIND v(dout1_8) AT=615.025n

.meas tran vdout1_9ck1220 FIND v(dout1_9) AT=615.025n

.meas tran vdout1_10ck1220 FIND v(dout1_10) AT=615.025n

.meas tran vdout1_11ck1220 FIND v(dout1_11) AT=615.025n

.meas tran vdout1_12ck1220 FIND v(dout1_12) AT=615.025n

.meas tran vdout1_13ck1220 FIND v(dout1_13) AT=615.025n

.meas tran vdout1_14ck1220 FIND v(dout1_14) AT=615.025n

.meas tran vdout1_15ck1220 FIND v(dout1_15) AT=615.025n

.meas tran vdout1_16ck1220 FIND v(dout1_16) AT=615.025n

.meas tran vdout1_17ck1220 FIND v(dout1_17) AT=615.025n

.meas tran vdout1_18ck1220 FIND v(dout1_18) AT=615.025n

.meas tran vdout1_0ck1230 FIND v(dout1_0) AT=620.025n

.meas tran vdout1_1ck1230 FIND v(dout1_1) AT=620.025n

.meas tran vdout1_2ck1230 FIND v(dout1_2) AT=620.025n

.meas tran vdout1_3ck1230 FIND v(dout1_3) AT=620.025n

.meas tran vdout1_4ck1230 FIND v(dout1_4) AT=620.025n

.meas tran vdout1_5ck1230 FIND v(dout1_5) AT=620.025n

.meas tran vdout1_6ck1230 FIND v(dout1_6) AT=620.025n

.meas tran vdout1_7ck1230 FIND v(dout1_7) AT=620.025n

.meas tran vdout1_8ck1230 FIND v(dout1_8) AT=620.025n

.meas tran vdout1_9ck1230 FIND v(dout1_9) AT=620.025n

.meas tran vdout1_10ck1230 FIND v(dout1_10) AT=620.025n

.meas tran vdout1_11ck1230 FIND v(dout1_11) AT=620.025n

.meas tran vdout1_12ck1230 FIND v(dout1_12) AT=620.025n

.meas tran vdout1_13ck1230 FIND v(dout1_13) AT=620.025n

.meas tran vdout1_14ck1230 FIND v(dout1_14) AT=620.025n

.meas tran vdout1_15ck1230 FIND v(dout1_15) AT=620.025n

.meas tran vdout1_16ck1230 FIND v(dout1_16) AT=620.025n

.meas tran vdout1_17ck1230 FIND v(dout1_17) AT=620.025n

.meas tran vdout1_18ck1230 FIND v(dout1_18) AT=620.025n

.meas tran vdout1_0ck1240 FIND v(dout1_0) AT=625.025n

.meas tran vdout1_1ck1240 FIND v(dout1_1) AT=625.025n

.meas tran vdout1_2ck1240 FIND v(dout1_2) AT=625.025n

.meas tran vdout1_3ck1240 FIND v(dout1_3) AT=625.025n

.meas tran vdout1_4ck1240 FIND v(dout1_4) AT=625.025n

.meas tran vdout1_5ck1240 FIND v(dout1_5) AT=625.025n

.meas tran vdout1_6ck1240 FIND v(dout1_6) AT=625.025n

.meas tran vdout1_7ck1240 FIND v(dout1_7) AT=625.025n

.meas tran vdout1_8ck1240 FIND v(dout1_8) AT=625.025n

.meas tran vdout1_9ck1240 FIND v(dout1_9) AT=625.025n

.meas tran vdout1_10ck1240 FIND v(dout1_10) AT=625.025n

.meas tran vdout1_11ck1240 FIND v(dout1_11) AT=625.025n

.meas tran vdout1_12ck1240 FIND v(dout1_12) AT=625.025n

.meas tran vdout1_13ck1240 FIND v(dout1_13) AT=625.025n

.meas tran vdout1_14ck1240 FIND v(dout1_14) AT=625.025n

.meas tran vdout1_15ck1240 FIND v(dout1_15) AT=625.025n

.meas tran vdout1_16ck1240 FIND v(dout1_16) AT=625.025n

.meas tran vdout1_17ck1240 FIND v(dout1_17) AT=625.025n

.meas tran vdout1_18ck1240 FIND v(dout1_18) AT=625.025n

.meas tran vdout1_0ck1290 FIND v(dout1_0) AT=650.025n

.meas tran vdout1_1ck1290 FIND v(dout1_1) AT=650.025n

.meas tran vdout1_2ck1290 FIND v(dout1_2) AT=650.025n

.meas tran vdout1_3ck1290 FIND v(dout1_3) AT=650.025n

.meas tran vdout1_4ck1290 FIND v(dout1_4) AT=650.025n

.meas tran vdout1_5ck1290 FIND v(dout1_5) AT=650.025n

.meas tran vdout1_6ck1290 FIND v(dout1_6) AT=650.025n

.meas tran vdout1_7ck1290 FIND v(dout1_7) AT=650.025n

.meas tran vdout1_8ck1290 FIND v(dout1_8) AT=650.025n

.meas tran vdout1_9ck1290 FIND v(dout1_9) AT=650.025n

.meas tran vdout1_10ck1290 FIND v(dout1_10) AT=650.025n

.meas tran vdout1_11ck1290 FIND v(dout1_11) AT=650.025n

.meas tran vdout1_12ck1290 FIND v(dout1_12) AT=650.025n

.meas tran vdout1_13ck1290 FIND v(dout1_13) AT=650.025n

.meas tran vdout1_14ck1290 FIND v(dout1_14) AT=650.025n

.meas tran vdout1_15ck1290 FIND v(dout1_15) AT=650.025n

.meas tran vdout1_16ck1290 FIND v(dout1_16) AT=650.025n

.meas tran vdout1_17ck1290 FIND v(dout1_17) AT=650.025n

.meas tran vdout1_18ck1290 FIND v(dout1_18) AT=650.025n

.meas tran vdout1_0ck1310 FIND v(dout1_0) AT=660.025n

.meas tran vdout1_1ck1310 FIND v(dout1_1) AT=660.025n

.meas tran vdout1_2ck1310 FIND v(dout1_2) AT=660.025n

.meas tran vdout1_3ck1310 FIND v(dout1_3) AT=660.025n

.meas tran vdout1_4ck1310 FIND v(dout1_4) AT=660.025n

.meas tran vdout1_5ck1310 FIND v(dout1_5) AT=660.025n

.meas tran vdout1_6ck1310 FIND v(dout1_6) AT=660.025n

.meas tran vdout1_7ck1310 FIND v(dout1_7) AT=660.025n

.meas tran vdout1_8ck1310 FIND v(dout1_8) AT=660.025n

.meas tran vdout1_9ck1310 FIND v(dout1_9) AT=660.025n

.meas tran vdout1_10ck1310 FIND v(dout1_10) AT=660.025n

.meas tran vdout1_11ck1310 FIND v(dout1_11) AT=660.025n

.meas tran vdout1_12ck1310 FIND v(dout1_12) AT=660.025n

.meas tran vdout1_13ck1310 FIND v(dout1_13) AT=660.025n

.meas tran vdout1_14ck1310 FIND v(dout1_14) AT=660.025n

.meas tran vdout1_15ck1310 FIND v(dout1_15) AT=660.025n

.meas tran vdout1_16ck1310 FIND v(dout1_16) AT=660.025n

.meas tran vdout1_17ck1310 FIND v(dout1_17) AT=660.025n

.meas tran vdout1_18ck1310 FIND v(dout1_18) AT=660.025n

.meas tran vdout1_0ck1340 FIND v(dout1_0) AT=675.025n

.meas tran vdout1_1ck1340 FIND v(dout1_1) AT=675.025n

.meas tran vdout1_2ck1340 FIND v(dout1_2) AT=675.025n

.meas tran vdout1_3ck1340 FIND v(dout1_3) AT=675.025n

.meas tran vdout1_4ck1340 FIND v(dout1_4) AT=675.025n

.meas tran vdout1_5ck1340 FIND v(dout1_5) AT=675.025n

.meas tran vdout1_6ck1340 FIND v(dout1_6) AT=675.025n

.meas tran vdout1_7ck1340 FIND v(dout1_7) AT=675.025n

.meas tran vdout1_8ck1340 FIND v(dout1_8) AT=675.025n

.meas tran vdout1_9ck1340 FIND v(dout1_9) AT=675.025n

.meas tran vdout1_10ck1340 FIND v(dout1_10) AT=675.025n

.meas tran vdout1_11ck1340 FIND v(dout1_11) AT=675.025n

.meas tran vdout1_12ck1340 FIND v(dout1_12) AT=675.025n

.meas tran vdout1_13ck1340 FIND v(dout1_13) AT=675.025n

.meas tran vdout1_14ck1340 FIND v(dout1_14) AT=675.025n

.meas tran vdout1_15ck1340 FIND v(dout1_15) AT=675.025n

.meas tran vdout1_16ck1340 FIND v(dout1_16) AT=675.025n

.meas tran vdout1_17ck1340 FIND v(dout1_17) AT=675.025n

.meas tran vdout1_18ck1340 FIND v(dout1_18) AT=675.025n

.meas tran vdout1_0ck1350 FIND v(dout1_0) AT=680.025n

.meas tran vdout1_1ck1350 FIND v(dout1_1) AT=680.025n

.meas tran vdout1_2ck1350 FIND v(dout1_2) AT=680.025n

.meas tran vdout1_3ck1350 FIND v(dout1_3) AT=680.025n

.meas tran vdout1_4ck1350 FIND v(dout1_4) AT=680.025n

.meas tran vdout1_5ck1350 FIND v(dout1_5) AT=680.025n

.meas tran vdout1_6ck1350 FIND v(dout1_6) AT=680.025n

.meas tran vdout1_7ck1350 FIND v(dout1_7) AT=680.025n

.meas tran vdout1_8ck1350 FIND v(dout1_8) AT=680.025n

.meas tran vdout1_9ck1350 FIND v(dout1_9) AT=680.025n

.meas tran vdout1_10ck1350 FIND v(dout1_10) AT=680.025n

.meas tran vdout1_11ck1350 FIND v(dout1_11) AT=680.025n

.meas tran vdout1_12ck1350 FIND v(dout1_12) AT=680.025n

.meas tran vdout1_13ck1350 FIND v(dout1_13) AT=680.025n

.meas tran vdout1_14ck1350 FIND v(dout1_14) AT=680.025n

.meas tran vdout1_15ck1350 FIND v(dout1_15) AT=680.025n

.meas tran vdout1_16ck1350 FIND v(dout1_16) AT=680.025n

.meas tran vdout1_17ck1350 FIND v(dout1_17) AT=680.025n

.meas tran vdout1_18ck1350 FIND v(dout1_18) AT=680.025n

.meas tran vdout1_0ck1370 FIND v(dout1_0) AT=690.025n

.meas tran vdout1_1ck1370 FIND v(dout1_1) AT=690.025n

.meas tran vdout1_2ck1370 FIND v(dout1_2) AT=690.025n

.meas tran vdout1_3ck1370 FIND v(dout1_3) AT=690.025n

.meas tran vdout1_4ck1370 FIND v(dout1_4) AT=690.025n

.meas tran vdout1_5ck1370 FIND v(dout1_5) AT=690.025n

.meas tran vdout1_6ck1370 FIND v(dout1_6) AT=690.025n

.meas tran vdout1_7ck1370 FIND v(dout1_7) AT=690.025n

.meas tran vdout1_8ck1370 FIND v(dout1_8) AT=690.025n

.meas tran vdout1_9ck1370 FIND v(dout1_9) AT=690.025n

.meas tran vdout1_10ck1370 FIND v(dout1_10) AT=690.025n

.meas tran vdout1_11ck1370 FIND v(dout1_11) AT=690.025n

.meas tran vdout1_12ck1370 FIND v(dout1_12) AT=690.025n

.meas tran vdout1_13ck1370 FIND v(dout1_13) AT=690.025n

.meas tran vdout1_14ck1370 FIND v(dout1_14) AT=690.025n

.meas tran vdout1_15ck1370 FIND v(dout1_15) AT=690.025n

.meas tran vdout1_16ck1370 FIND v(dout1_16) AT=690.025n

.meas tran vdout1_17ck1370 FIND v(dout1_17) AT=690.025n

.meas tran vdout1_18ck1370 FIND v(dout1_18) AT=690.025n

.meas tran vdout1_0ck1380 FIND v(dout1_0) AT=695.025n

.meas tran vdout1_1ck1380 FIND v(dout1_1) AT=695.025n

.meas tran vdout1_2ck1380 FIND v(dout1_2) AT=695.025n

.meas tran vdout1_3ck1380 FIND v(dout1_3) AT=695.025n

.meas tran vdout1_4ck1380 FIND v(dout1_4) AT=695.025n

.meas tran vdout1_5ck1380 FIND v(dout1_5) AT=695.025n

.meas tran vdout1_6ck1380 FIND v(dout1_6) AT=695.025n

.meas tran vdout1_7ck1380 FIND v(dout1_7) AT=695.025n

.meas tran vdout1_8ck1380 FIND v(dout1_8) AT=695.025n

.meas tran vdout1_9ck1380 FIND v(dout1_9) AT=695.025n

.meas tran vdout1_10ck1380 FIND v(dout1_10) AT=695.025n

.meas tran vdout1_11ck1380 FIND v(dout1_11) AT=695.025n

.meas tran vdout1_12ck1380 FIND v(dout1_12) AT=695.025n

.meas tran vdout1_13ck1380 FIND v(dout1_13) AT=695.025n

.meas tran vdout1_14ck1380 FIND v(dout1_14) AT=695.025n

.meas tran vdout1_15ck1380 FIND v(dout1_15) AT=695.025n

.meas tran vdout1_16ck1380 FIND v(dout1_16) AT=695.025n

.meas tran vdout1_17ck1380 FIND v(dout1_17) AT=695.025n

.meas tran vdout1_18ck1380 FIND v(dout1_18) AT=695.025n

.meas tran vdout1_0ck1410 FIND v(dout1_0) AT=710.025n

.meas tran vdout1_1ck1410 FIND v(dout1_1) AT=710.025n

.meas tran vdout1_2ck1410 FIND v(dout1_2) AT=710.025n

.meas tran vdout1_3ck1410 FIND v(dout1_3) AT=710.025n

.meas tran vdout1_4ck1410 FIND v(dout1_4) AT=710.025n

.meas tran vdout1_5ck1410 FIND v(dout1_5) AT=710.025n

.meas tran vdout1_6ck1410 FIND v(dout1_6) AT=710.025n

.meas tran vdout1_7ck1410 FIND v(dout1_7) AT=710.025n

.meas tran vdout1_8ck1410 FIND v(dout1_8) AT=710.025n

.meas tran vdout1_9ck1410 FIND v(dout1_9) AT=710.025n

.meas tran vdout1_10ck1410 FIND v(dout1_10) AT=710.025n

.meas tran vdout1_11ck1410 FIND v(dout1_11) AT=710.025n

.meas tran vdout1_12ck1410 FIND v(dout1_12) AT=710.025n

.meas tran vdout1_13ck1410 FIND v(dout1_13) AT=710.025n

.meas tran vdout1_14ck1410 FIND v(dout1_14) AT=710.025n

.meas tran vdout1_15ck1410 FIND v(dout1_15) AT=710.025n

.meas tran vdout1_16ck1410 FIND v(dout1_16) AT=710.025n

.meas tran vdout1_17ck1410 FIND v(dout1_17) AT=710.025n

.meas tran vdout1_18ck1410 FIND v(dout1_18) AT=710.025n

.meas tran vdout1_0ck1430 FIND v(dout1_0) AT=720.025n

.meas tran vdout1_1ck1430 FIND v(dout1_1) AT=720.025n

.meas tran vdout1_2ck1430 FIND v(dout1_2) AT=720.025n

.meas tran vdout1_3ck1430 FIND v(dout1_3) AT=720.025n

.meas tran vdout1_4ck1430 FIND v(dout1_4) AT=720.025n

.meas tran vdout1_5ck1430 FIND v(dout1_5) AT=720.025n

.meas tran vdout1_6ck1430 FIND v(dout1_6) AT=720.025n

.meas tran vdout1_7ck1430 FIND v(dout1_7) AT=720.025n

.meas tran vdout1_8ck1430 FIND v(dout1_8) AT=720.025n

.meas tran vdout1_9ck1430 FIND v(dout1_9) AT=720.025n

.meas tran vdout1_10ck1430 FIND v(dout1_10) AT=720.025n

.meas tran vdout1_11ck1430 FIND v(dout1_11) AT=720.025n

.meas tran vdout1_12ck1430 FIND v(dout1_12) AT=720.025n

.meas tran vdout1_13ck1430 FIND v(dout1_13) AT=720.025n

.meas tran vdout1_14ck1430 FIND v(dout1_14) AT=720.025n

.meas tran vdout1_15ck1430 FIND v(dout1_15) AT=720.025n

.meas tran vdout1_16ck1430 FIND v(dout1_16) AT=720.025n

.meas tran vdout1_17ck1430 FIND v(dout1_17) AT=720.025n

.meas tran vdout1_18ck1430 FIND v(dout1_18) AT=720.025n

.meas tran vdout1_0ck1510 FIND v(dout1_0) AT=760.025n

.meas tran vdout1_1ck1510 FIND v(dout1_1) AT=760.025n

.meas tran vdout1_2ck1510 FIND v(dout1_2) AT=760.025n

.meas tran vdout1_3ck1510 FIND v(dout1_3) AT=760.025n

.meas tran vdout1_4ck1510 FIND v(dout1_4) AT=760.025n

.meas tran vdout1_5ck1510 FIND v(dout1_5) AT=760.025n

.meas tran vdout1_6ck1510 FIND v(dout1_6) AT=760.025n

.meas tran vdout1_7ck1510 FIND v(dout1_7) AT=760.025n

.meas tran vdout1_8ck1510 FIND v(dout1_8) AT=760.025n

.meas tran vdout1_9ck1510 FIND v(dout1_9) AT=760.025n

.meas tran vdout1_10ck1510 FIND v(dout1_10) AT=760.025n

.meas tran vdout1_11ck1510 FIND v(dout1_11) AT=760.025n

.meas tran vdout1_12ck1510 FIND v(dout1_12) AT=760.025n

.meas tran vdout1_13ck1510 FIND v(dout1_13) AT=760.025n

.meas tran vdout1_14ck1510 FIND v(dout1_14) AT=760.025n

.meas tran vdout1_15ck1510 FIND v(dout1_15) AT=760.025n

.meas tran vdout1_16ck1510 FIND v(dout1_16) AT=760.025n

.meas tran vdout1_17ck1510 FIND v(dout1_17) AT=760.025n

.meas tran vdout1_18ck1510 FIND v(dout1_18) AT=760.025n

.meas tran vdout1_0ck1520 FIND v(dout1_0) AT=765.025n

.meas tran vdout1_1ck1520 FIND v(dout1_1) AT=765.025n

.meas tran vdout1_2ck1520 FIND v(dout1_2) AT=765.025n

.meas tran vdout1_3ck1520 FIND v(dout1_3) AT=765.025n

.meas tran vdout1_4ck1520 FIND v(dout1_4) AT=765.025n

.meas tran vdout1_5ck1520 FIND v(dout1_5) AT=765.025n

.meas tran vdout1_6ck1520 FIND v(dout1_6) AT=765.025n

.meas tran vdout1_7ck1520 FIND v(dout1_7) AT=765.025n

.meas tran vdout1_8ck1520 FIND v(dout1_8) AT=765.025n

.meas tran vdout1_9ck1520 FIND v(dout1_9) AT=765.025n

.meas tran vdout1_10ck1520 FIND v(dout1_10) AT=765.025n

.meas tran vdout1_11ck1520 FIND v(dout1_11) AT=765.025n

.meas tran vdout1_12ck1520 FIND v(dout1_12) AT=765.025n

.meas tran vdout1_13ck1520 FIND v(dout1_13) AT=765.025n

.meas tran vdout1_14ck1520 FIND v(dout1_14) AT=765.025n

.meas tran vdout1_15ck1520 FIND v(dout1_15) AT=765.025n

.meas tran vdout1_16ck1520 FIND v(dout1_16) AT=765.025n

.meas tran vdout1_17ck1520 FIND v(dout1_17) AT=765.025n

.meas tran vdout1_18ck1520 FIND v(dout1_18) AT=765.025n

.meas tran vdout1_0ck1540 FIND v(dout1_0) AT=775.025n

.meas tran vdout1_1ck1540 FIND v(dout1_1) AT=775.025n

.meas tran vdout1_2ck1540 FIND v(dout1_2) AT=775.025n

.meas tran vdout1_3ck1540 FIND v(dout1_3) AT=775.025n

.meas tran vdout1_4ck1540 FIND v(dout1_4) AT=775.025n

.meas tran vdout1_5ck1540 FIND v(dout1_5) AT=775.025n

.meas tran vdout1_6ck1540 FIND v(dout1_6) AT=775.025n

.meas tran vdout1_7ck1540 FIND v(dout1_7) AT=775.025n

.meas tran vdout1_8ck1540 FIND v(dout1_8) AT=775.025n

.meas tran vdout1_9ck1540 FIND v(dout1_9) AT=775.025n

.meas tran vdout1_10ck1540 FIND v(dout1_10) AT=775.025n

.meas tran vdout1_11ck1540 FIND v(dout1_11) AT=775.025n

.meas tran vdout1_12ck1540 FIND v(dout1_12) AT=775.025n

.meas tran vdout1_13ck1540 FIND v(dout1_13) AT=775.025n

.meas tran vdout1_14ck1540 FIND v(dout1_14) AT=775.025n

.meas tran vdout1_15ck1540 FIND v(dout1_15) AT=775.025n

.meas tran vdout1_16ck1540 FIND v(dout1_16) AT=775.025n

.meas tran vdout1_17ck1540 FIND v(dout1_17) AT=775.025n

.meas tran vdout1_18ck1540 FIND v(dout1_18) AT=775.025n

.meas tran vdout1_0ck1590 FIND v(dout1_0) AT=800.025n

.meas tran vdout1_1ck1590 FIND v(dout1_1) AT=800.025n

.meas tran vdout1_2ck1590 FIND v(dout1_2) AT=800.025n

.meas tran vdout1_3ck1590 FIND v(dout1_3) AT=800.025n

.meas tran vdout1_4ck1590 FIND v(dout1_4) AT=800.025n

.meas tran vdout1_5ck1590 FIND v(dout1_5) AT=800.025n

.meas tran vdout1_6ck1590 FIND v(dout1_6) AT=800.025n

.meas tran vdout1_7ck1590 FIND v(dout1_7) AT=800.025n

.meas tran vdout1_8ck1590 FIND v(dout1_8) AT=800.025n

.meas tran vdout1_9ck1590 FIND v(dout1_9) AT=800.025n

.meas tran vdout1_10ck1590 FIND v(dout1_10) AT=800.025n

.meas tran vdout1_11ck1590 FIND v(dout1_11) AT=800.025n

.meas tran vdout1_12ck1590 FIND v(dout1_12) AT=800.025n

.meas tran vdout1_13ck1590 FIND v(dout1_13) AT=800.025n

.meas tran vdout1_14ck1590 FIND v(dout1_14) AT=800.025n

.meas tran vdout1_15ck1590 FIND v(dout1_15) AT=800.025n

.meas tran vdout1_16ck1590 FIND v(dout1_16) AT=800.025n

.meas tran vdout1_17ck1590 FIND v(dout1_17) AT=800.025n

.meas tran vdout1_18ck1590 FIND v(dout1_18) AT=800.025n

.meas tran vdout1_0ck1600 FIND v(dout1_0) AT=805.025n

.meas tran vdout1_1ck1600 FIND v(dout1_1) AT=805.025n

.meas tran vdout1_2ck1600 FIND v(dout1_2) AT=805.025n

.meas tran vdout1_3ck1600 FIND v(dout1_3) AT=805.025n

.meas tran vdout1_4ck1600 FIND v(dout1_4) AT=805.025n

.meas tran vdout1_5ck1600 FIND v(dout1_5) AT=805.025n

.meas tran vdout1_6ck1600 FIND v(dout1_6) AT=805.025n

.meas tran vdout1_7ck1600 FIND v(dout1_7) AT=805.025n

.meas tran vdout1_8ck1600 FIND v(dout1_8) AT=805.025n

.meas tran vdout1_9ck1600 FIND v(dout1_9) AT=805.025n

.meas tran vdout1_10ck1600 FIND v(dout1_10) AT=805.025n

.meas tran vdout1_11ck1600 FIND v(dout1_11) AT=805.025n

.meas tran vdout1_12ck1600 FIND v(dout1_12) AT=805.025n

.meas tran vdout1_13ck1600 FIND v(dout1_13) AT=805.025n

.meas tran vdout1_14ck1600 FIND v(dout1_14) AT=805.025n

.meas tran vdout1_15ck1600 FIND v(dout1_15) AT=805.025n

.meas tran vdout1_16ck1600 FIND v(dout1_16) AT=805.025n

.meas tran vdout1_17ck1600 FIND v(dout1_17) AT=805.025n

.meas tran vdout1_18ck1600 FIND v(dout1_18) AT=805.025n

.meas tran vdout1_0ck1610 FIND v(dout1_0) AT=810.025n

.meas tran vdout1_1ck1610 FIND v(dout1_1) AT=810.025n

.meas tran vdout1_2ck1610 FIND v(dout1_2) AT=810.025n

.meas tran vdout1_3ck1610 FIND v(dout1_3) AT=810.025n

.meas tran vdout1_4ck1610 FIND v(dout1_4) AT=810.025n

.meas tran vdout1_5ck1610 FIND v(dout1_5) AT=810.025n

.meas tran vdout1_6ck1610 FIND v(dout1_6) AT=810.025n

.meas tran vdout1_7ck1610 FIND v(dout1_7) AT=810.025n

.meas tran vdout1_8ck1610 FIND v(dout1_8) AT=810.025n

.meas tran vdout1_9ck1610 FIND v(dout1_9) AT=810.025n

.meas tran vdout1_10ck1610 FIND v(dout1_10) AT=810.025n

.meas tran vdout1_11ck1610 FIND v(dout1_11) AT=810.025n

.meas tran vdout1_12ck1610 FIND v(dout1_12) AT=810.025n

.meas tran vdout1_13ck1610 FIND v(dout1_13) AT=810.025n

.meas tran vdout1_14ck1610 FIND v(dout1_14) AT=810.025n

.meas tran vdout1_15ck1610 FIND v(dout1_15) AT=810.025n

.meas tran vdout1_16ck1610 FIND v(dout1_16) AT=810.025n

.meas tran vdout1_17ck1610 FIND v(dout1_17) AT=810.025n

.meas tran vdout1_18ck1610 FIND v(dout1_18) AT=810.025n

.meas tran vdout1_0ck1620 FIND v(dout1_0) AT=815.025n

.meas tran vdout1_1ck1620 FIND v(dout1_1) AT=815.025n

.meas tran vdout1_2ck1620 FIND v(dout1_2) AT=815.025n

.meas tran vdout1_3ck1620 FIND v(dout1_3) AT=815.025n

.meas tran vdout1_4ck1620 FIND v(dout1_4) AT=815.025n

.meas tran vdout1_5ck1620 FIND v(dout1_5) AT=815.025n

.meas tran vdout1_6ck1620 FIND v(dout1_6) AT=815.025n

.meas tran vdout1_7ck1620 FIND v(dout1_7) AT=815.025n

.meas tran vdout1_8ck1620 FIND v(dout1_8) AT=815.025n

.meas tran vdout1_9ck1620 FIND v(dout1_9) AT=815.025n

.meas tran vdout1_10ck1620 FIND v(dout1_10) AT=815.025n

.meas tran vdout1_11ck1620 FIND v(dout1_11) AT=815.025n

.meas tran vdout1_12ck1620 FIND v(dout1_12) AT=815.025n

.meas tran vdout1_13ck1620 FIND v(dout1_13) AT=815.025n

.meas tran vdout1_14ck1620 FIND v(dout1_14) AT=815.025n

.meas tran vdout1_15ck1620 FIND v(dout1_15) AT=815.025n

.meas tran vdout1_16ck1620 FIND v(dout1_16) AT=815.025n

.meas tran vdout1_17ck1620 FIND v(dout1_17) AT=815.025n

.meas tran vdout1_18ck1620 FIND v(dout1_18) AT=815.025n

.meas tran vdout1_0ck1640 FIND v(dout1_0) AT=825.025n

.meas tran vdout1_1ck1640 FIND v(dout1_1) AT=825.025n

.meas tran vdout1_2ck1640 FIND v(dout1_2) AT=825.025n

.meas tran vdout1_3ck1640 FIND v(dout1_3) AT=825.025n

.meas tran vdout1_4ck1640 FIND v(dout1_4) AT=825.025n

.meas tran vdout1_5ck1640 FIND v(dout1_5) AT=825.025n

.meas tran vdout1_6ck1640 FIND v(dout1_6) AT=825.025n

.meas tran vdout1_7ck1640 FIND v(dout1_7) AT=825.025n

.meas tran vdout1_8ck1640 FIND v(dout1_8) AT=825.025n

.meas tran vdout1_9ck1640 FIND v(dout1_9) AT=825.025n

.meas tran vdout1_10ck1640 FIND v(dout1_10) AT=825.025n

.meas tran vdout1_11ck1640 FIND v(dout1_11) AT=825.025n

.meas tran vdout1_12ck1640 FIND v(dout1_12) AT=825.025n

.meas tran vdout1_13ck1640 FIND v(dout1_13) AT=825.025n

.meas tran vdout1_14ck1640 FIND v(dout1_14) AT=825.025n

.meas tran vdout1_15ck1640 FIND v(dout1_15) AT=825.025n

.meas tran vdout1_16ck1640 FIND v(dout1_16) AT=825.025n

.meas tran vdout1_17ck1640 FIND v(dout1_17) AT=825.025n

.meas tran vdout1_18ck1640 FIND v(dout1_18) AT=825.025n

.meas tran vdout1_0ck1650 FIND v(dout1_0) AT=830.025n

.meas tran vdout1_1ck1650 FIND v(dout1_1) AT=830.025n

.meas tran vdout1_2ck1650 FIND v(dout1_2) AT=830.025n

.meas tran vdout1_3ck1650 FIND v(dout1_3) AT=830.025n

.meas tran vdout1_4ck1650 FIND v(dout1_4) AT=830.025n

.meas tran vdout1_5ck1650 FIND v(dout1_5) AT=830.025n

.meas tran vdout1_6ck1650 FIND v(dout1_6) AT=830.025n

.meas tran vdout1_7ck1650 FIND v(dout1_7) AT=830.025n

.meas tran vdout1_8ck1650 FIND v(dout1_8) AT=830.025n

.meas tran vdout1_9ck1650 FIND v(dout1_9) AT=830.025n

.meas tran vdout1_10ck1650 FIND v(dout1_10) AT=830.025n

.meas tran vdout1_11ck1650 FIND v(dout1_11) AT=830.025n

.meas tran vdout1_12ck1650 FIND v(dout1_12) AT=830.025n

.meas tran vdout1_13ck1650 FIND v(dout1_13) AT=830.025n

.meas tran vdout1_14ck1650 FIND v(dout1_14) AT=830.025n

.meas tran vdout1_15ck1650 FIND v(dout1_15) AT=830.025n

.meas tran vdout1_16ck1650 FIND v(dout1_16) AT=830.025n

.meas tran vdout1_17ck1650 FIND v(dout1_17) AT=830.025n

.meas tran vdout1_18ck1650 FIND v(dout1_18) AT=830.025n

.meas tran vdout1_0ck1680 FIND v(dout1_0) AT=845.025n

.meas tran vdout1_1ck1680 FIND v(dout1_1) AT=845.025n

.meas tran vdout1_2ck1680 FIND v(dout1_2) AT=845.025n

.meas tran vdout1_3ck1680 FIND v(dout1_3) AT=845.025n

.meas tran vdout1_4ck1680 FIND v(dout1_4) AT=845.025n

.meas tran vdout1_5ck1680 FIND v(dout1_5) AT=845.025n

.meas tran vdout1_6ck1680 FIND v(dout1_6) AT=845.025n

.meas tran vdout1_7ck1680 FIND v(dout1_7) AT=845.025n

.meas tran vdout1_8ck1680 FIND v(dout1_8) AT=845.025n

.meas tran vdout1_9ck1680 FIND v(dout1_9) AT=845.025n

.meas tran vdout1_10ck1680 FIND v(dout1_10) AT=845.025n

.meas tran vdout1_11ck1680 FIND v(dout1_11) AT=845.025n

.meas tran vdout1_12ck1680 FIND v(dout1_12) AT=845.025n

.meas tran vdout1_13ck1680 FIND v(dout1_13) AT=845.025n

.meas tran vdout1_14ck1680 FIND v(dout1_14) AT=845.025n

.meas tran vdout1_15ck1680 FIND v(dout1_15) AT=845.025n

.meas tran vdout1_16ck1680 FIND v(dout1_16) AT=845.025n

.meas tran vdout1_17ck1680 FIND v(dout1_17) AT=845.025n

.meas tran vdout1_18ck1680 FIND v(dout1_18) AT=845.025n

.meas tran vdout1_0ck1700 FIND v(dout1_0) AT=855.025n

.meas tran vdout1_1ck1700 FIND v(dout1_1) AT=855.025n

.meas tran vdout1_2ck1700 FIND v(dout1_2) AT=855.025n

.meas tran vdout1_3ck1700 FIND v(dout1_3) AT=855.025n

.meas tran vdout1_4ck1700 FIND v(dout1_4) AT=855.025n

.meas tran vdout1_5ck1700 FIND v(dout1_5) AT=855.025n

.meas tran vdout1_6ck1700 FIND v(dout1_6) AT=855.025n

.meas tran vdout1_7ck1700 FIND v(dout1_7) AT=855.025n

.meas tran vdout1_8ck1700 FIND v(dout1_8) AT=855.025n

.meas tran vdout1_9ck1700 FIND v(dout1_9) AT=855.025n

.meas tran vdout1_10ck1700 FIND v(dout1_10) AT=855.025n

.meas tran vdout1_11ck1700 FIND v(dout1_11) AT=855.025n

.meas tran vdout1_12ck1700 FIND v(dout1_12) AT=855.025n

.meas tran vdout1_13ck1700 FIND v(dout1_13) AT=855.025n

.meas tran vdout1_14ck1700 FIND v(dout1_14) AT=855.025n

.meas tran vdout1_15ck1700 FIND v(dout1_15) AT=855.025n

.meas tran vdout1_16ck1700 FIND v(dout1_16) AT=855.025n

.meas tran vdout1_17ck1700 FIND v(dout1_17) AT=855.025n

.meas tran vdout1_18ck1700 FIND v(dout1_18) AT=855.025n

.meas tran vdout1_0ck1710 FIND v(dout1_0) AT=860.025n

.meas tran vdout1_1ck1710 FIND v(dout1_1) AT=860.025n

.meas tran vdout1_2ck1710 FIND v(dout1_2) AT=860.025n

.meas tran vdout1_3ck1710 FIND v(dout1_3) AT=860.025n

.meas tran vdout1_4ck1710 FIND v(dout1_4) AT=860.025n

.meas tran vdout1_5ck1710 FIND v(dout1_5) AT=860.025n

.meas tran vdout1_6ck1710 FIND v(dout1_6) AT=860.025n

.meas tran vdout1_7ck1710 FIND v(dout1_7) AT=860.025n

.meas tran vdout1_8ck1710 FIND v(dout1_8) AT=860.025n

.meas tran vdout1_9ck1710 FIND v(dout1_9) AT=860.025n

.meas tran vdout1_10ck1710 FIND v(dout1_10) AT=860.025n

.meas tran vdout1_11ck1710 FIND v(dout1_11) AT=860.025n

.meas tran vdout1_12ck1710 FIND v(dout1_12) AT=860.025n

.meas tran vdout1_13ck1710 FIND v(dout1_13) AT=860.025n

.meas tran vdout1_14ck1710 FIND v(dout1_14) AT=860.025n

.meas tran vdout1_15ck1710 FIND v(dout1_15) AT=860.025n

.meas tran vdout1_16ck1710 FIND v(dout1_16) AT=860.025n

.meas tran vdout1_17ck1710 FIND v(dout1_17) AT=860.025n

.meas tran vdout1_18ck1710 FIND v(dout1_18) AT=860.025n

.meas tran vdout1_0ck1750 FIND v(dout1_0) AT=880.025n

.meas tran vdout1_1ck1750 FIND v(dout1_1) AT=880.025n

.meas tran vdout1_2ck1750 FIND v(dout1_2) AT=880.025n

.meas tran vdout1_3ck1750 FIND v(dout1_3) AT=880.025n

.meas tran vdout1_4ck1750 FIND v(dout1_4) AT=880.025n

.meas tran vdout1_5ck1750 FIND v(dout1_5) AT=880.025n

.meas tran vdout1_6ck1750 FIND v(dout1_6) AT=880.025n

.meas tran vdout1_7ck1750 FIND v(dout1_7) AT=880.025n

.meas tran vdout1_8ck1750 FIND v(dout1_8) AT=880.025n

.meas tran vdout1_9ck1750 FIND v(dout1_9) AT=880.025n

.meas tran vdout1_10ck1750 FIND v(dout1_10) AT=880.025n

.meas tran vdout1_11ck1750 FIND v(dout1_11) AT=880.025n

.meas tran vdout1_12ck1750 FIND v(dout1_12) AT=880.025n

.meas tran vdout1_13ck1750 FIND v(dout1_13) AT=880.025n

.meas tran vdout1_14ck1750 FIND v(dout1_14) AT=880.025n

.meas tran vdout1_15ck1750 FIND v(dout1_15) AT=880.025n

.meas tran vdout1_16ck1750 FIND v(dout1_16) AT=880.025n

.meas tran vdout1_17ck1750 FIND v(dout1_17) AT=880.025n

.meas tran vdout1_18ck1750 FIND v(dout1_18) AT=880.025n

.meas tran vdout1_0ck1780 FIND v(dout1_0) AT=895.025n

.meas tran vdout1_1ck1780 FIND v(dout1_1) AT=895.025n

.meas tran vdout1_2ck1780 FIND v(dout1_2) AT=895.025n

.meas tran vdout1_3ck1780 FIND v(dout1_3) AT=895.025n

.meas tran vdout1_4ck1780 FIND v(dout1_4) AT=895.025n

.meas tran vdout1_5ck1780 FIND v(dout1_5) AT=895.025n

.meas tran vdout1_6ck1780 FIND v(dout1_6) AT=895.025n

.meas tran vdout1_7ck1780 FIND v(dout1_7) AT=895.025n

.meas tran vdout1_8ck1780 FIND v(dout1_8) AT=895.025n

.meas tran vdout1_9ck1780 FIND v(dout1_9) AT=895.025n

.meas tran vdout1_10ck1780 FIND v(dout1_10) AT=895.025n

.meas tran vdout1_11ck1780 FIND v(dout1_11) AT=895.025n

.meas tran vdout1_12ck1780 FIND v(dout1_12) AT=895.025n

.meas tran vdout1_13ck1780 FIND v(dout1_13) AT=895.025n

.meas tran vdout1_14ck1780 FIND v(dout1_14) AT=895.025n

.meas tran vdout1_15ck1780 FIND v(dout1_15) AT=895.025n

.meas tran vdout1_16ck1780 FIND v(dout1_16) AT=895.025n

.meas tran vdout1_17ck1780 FIND v(dout1_17) AT=895.025n

.meas tran vdout1_18ck1780 FIND v(dout1_18) AT=895.025n

.meas tran vdout1_0ck1810 FIND v(dout1_0) AT=910.025n

.meas tran vdout1_1ck1810 FIND v(dout1_1) AT=910.025n

.meas tran vdout1_2ck1810 FIND v(dout1_2) AT=910.025n

.meas tran vdout1_3ck1810 FIND v(dout1_3) AT=910.025n

.meas tran vdout1_4ck1810 FIND v(dout1_4) AT=910.025n

.meas tran vdout1_5ck1810 FIND v(dout1_5) AT=910.025n

.meas tran vdout1_6ck1810 FIND v(dout1_6) AT=910.025n

.meas tran vdout1_7ck1810 FIND v(dout1_7) AT=910.025n

.meas tran vdout1_8ck1810 FIND v(dout1_8) AT=910.025n

.meas tran vdout1_9ck1810 FIND v(dout1_9) AT=910.025n

.meas tran vdout1_10ck1810 FIND v(dout1_10) AT=910.025n

.meas tran vdout1_11ck1810 FIND v(dout1_11) AT=910.025n

.meas tran vdout1_12ck1810 FIND v(dout1_12) AT=910.025n

.meas tran vdout1_13ck1810 FIND v(dout1_13) AT=910.025n

.meas tran vdout1_14ck1810 FIND v(dout1_14) AT=910.025n

.meas tran vdout1_15ck1810 FIND v(dout1_15) AT=910.025n

.meas tran vdout1_16ck1810 FIND v(dout1_16) AT=910.025n

.meas tran vdout1_17ck1810 FIND v(dout1_17) AT=910.025n

.meas tran vdout1_18ck1810 FIND v(dout1_18) AT=910.025n

.meas tran vdout1_0ck1830 FIND v(dout1_0) AT=920.025n

.meas tran vdout1_1ck1830 FIND v(dout1_1) AT=920.025n

.meas tran vdout1_2ck1830 FIND v(dout1_2) AT=920.025n

.meas tran vdout1_3ck1830 FIND v(dout1_3) AT=920.025n

.meas tran vdout1_4ck1830 FIND v(dout1_4) AT=920.025n

.meas tran vdout1_5ck1830 FIND v(dout1_5) AT=920.025n

.meas tran vdout1_6ck1830 FIND v(dout1_6) AT=920.025n

.meas tran vdout1_7ck1830 FIND v(dout1_7) AT=920.025n

.meas tran vdout1_8ck1830 FIND v(dout1_8) AT=920.025n

.meas tran vdout1_9ck1830 FIND v(dout1_9) AT=920.025n

.meas tran vdout1_10ck1830 FIND v(dout1_10) AT=920.025n

.meas tran vdout1_11ck1830 FIND v(dout1_11) AT=920.025n

.meas tran vdout1_12ck1830 FIND v(dout1_12) AT=920.025n

.meas tran vdout1_13ck1830 FIND v(dout1_13) AT=920.025n

.meas tran vdout1_14ck1830 FIND v(dout1_14) AT=920.025n

.meas tran vdout1_15ck1830 FIND v(dout1_15) AT=920.025n

.meas tran vdout1_16ck1830 FIND v(dout1_16) AT=920.025n

.meas tran vdout1_17ck1830 FIND v(dout1_17) AT=920.025n

.meas tran vdout1_18ck1830 FIND v(dout1_18) AT=920.025n

.meas tran vdout1_0ck1910 FIND v(dout1_0) AT=960.025n

.meas tran vdout1_1ck1910 FIND v(dout1_1) AT=960.025n

.meas tran vdout1_2ck1910 FIND v(dout1_2) AT=960.025n

.meas tran vdout1_3ck1910 FIND v(dout1_3) AT=960.025n

.meas tran vdout1_4ck1910 FIND v(dout1_4) AT=960.025n

.meas tran vdout1_5ck1910 FIND v(dout1_5) AT=960.025n

.meas tran vdout1_6ck1910 FIND v(dout1_6) AT=960.025n

.meas tran vdout1_7ck1910 FIND v(dout1_7) AT=960.025n

.meas tran vdout1_8ck1910 FIND v(dout1_8) AT=960.025n

.meas tran vdout1_9ck1910 FIND v(dout1_9) AT=960.025n

.meas tran vdout1_10ck1910 FIND v(dout1_10) AT=960.025n

.meas tran vdout1_11ck1910 FIND v(dout1_11) AT=960.025n

.meas tran vdout1_12ck1910 FIND v(dout1_12) AT=960.025n

.meas tran vdout1_13ck1910 FIND v(dout1_13) AT=960.025n

.meas tran vdout1_14ck1910 FIND v(dout1_14) AT=960.025n

.meas tran vdout1_15ck1910 FIND v(dout1_15) AT=960.025n

.meas tran vdout1_16ck1910 FIND v(dout1_16) AT=960.025n

.meas tran vdout1_17ck1910 FIND v(dout1_17) AT=960.025n

.meas tran vdout1_18ck1910 FIND v(dout1_18) AT=960.025n

.meas tran vdout1_0ck1920 FIND v(dout1_0) AT=965.025n

.meas tran vdout1_1ck1920 FIND v(dout1_1) AT=965.025n

.meas tran vdout1_2ck1920 FIND v(dout1_2) AT=965.025n

.meas tran vdout1_3ck1920 FIND v(dout1_3) AT=965.025n

.meas tran vdout1_4ck1920 FIND v(dout1_4) AT=965.025n

.meas tran vdout1_5ck1920 FIND v(dout1_5) AT=965.025n

.meas tran vdout1_6ck1920 FIND v(dout1_6) AT=965.025n

.meas tran vdout1_7ck1920 FIND v(dout1_7) AT=965.025n

.meas tran vdout1_8ck1920 FIND v(dout1_8) AT=965.025n

.meas tran vdout1_9ck1920 FIND v(dout1_9) AT=965.025n

.meas tran vdout1_10ck1920 FIND v(dout1_10) AT=965.025n

.meas tran vdout1_11ck1920 FIND v(dout1_11) AT=965.025n

.meas tran vdout1_12ck1920 FIND v(dout1_12) AT=965.025n

.meas tran vdout1_13ck1920 FIND v(dout1_13) AT=965.025n

.meas tran vdout1_14ck1920 FIND v(dout1_14) AT=965.025n

.meas tran vdout1_15ck1920 FIND v(dout1_15) AT=965.025n

.meas tran vdout1_16ck1920 FIND v(dout1_16) AT=965.025n

.meas tran vdout1_17ck1920 FIND v(dout1_17) AT=965.025n

.meas tran vdout1_18ck1920 FIND v(dout1_18) AT=965.025n

.meas tran vdout1_0ck1940 FIND v(dout1_0) AT=975.025n

.meas tran vdout1_1ck1940 FIND v(dout1_1) AT=975.025n

.meas tran vdout1_2ck1940 FIND v(dout1_2) AT=975.025n

.meas tran vdout1_3ck1940 FIND v(dout1_3) AT=975.025n

.meas tran vdout1_4ck1940 FIND v(dout1_4) AT=975.025n

.meas tran vdout1_5ck1940 FIND v(dout1_5) AT=975.025n

.meas tran vdout1_6ck1940 FIND v(dout1_6) AT=975.025n

.meas tran vdout1_7ck1940 FIND v(dout1_7) AT=975.025n

.meas tran vdout1_8ck1940 FIND v(dout1_8) AT=975.025n

.meas tran vdout1_9ck1940 FIND v(dout1_9) AT=975.025n

.meas tran vdout1_10ck1940 FIND v(dout1_10) AT=975.025n

.meas tran vdout1_11ck1940 FIND v(dout1_11) AT=975.025n

.meas tran vdout1_12ck1940 FIND v(dout1_12) AT=975.025n

.meas tran vdout1_13ck1940 FIND v(dout1_13) AT=975.025n

.meas tran vdout1_14ck1940 FIND v(dout1_14) AT=975.025n

.meas tran vdout1_15ck1940 FIND v(dout1_15) AT=975.025n

.meas tran vdout1_16ck1940 FIND v(dout1_16) AT=975.025n

.meas tran vdout1_17ck1940 FIND v(dout1_17) AT=975.025n

.meas tran vdout1_18ck1940 FIND v(dout1_18) AT=975.025n

.meas tran vdout1_0ck1960 FIND v(dout1_0) AT=985.025n

.meas tran vdout1_1ck1960 FIND v(dout1_1) AT=985.025n

.meas tran vdout1_2ck1960 FIND v(dout1_2) AT=985.025n

.meas tran vdout1_3ck1960 FIND v(dout1_3) AT=985.025n

.meas tran vdout1_4ck1960 FIND v(dout1_4) AT=985.025n

.meas tran vdout1_5ck1960 FIND v(dout1_5) AT=985.025n

.meas tran vdout1_6ck1960 FIND v(dout1_6) AT=985.025n

.meas tran vdout1_7ck1960 FIND v(dout1_7) AT=985.025n

.meas tran vdout1_8ck1960 FIND v(dout1_8) AT=985.025n

.meas tran vdout1_9ck1960 FIND v(dout1_9) AT=985.025n

.meas tran vdout1_10ck1960 FIND v(dout1_10) AT=985.025n

.meas tran vdout1_11ck1960 FIND v(dout1_11) AT=985.025n

.meas tran vdout1_12ck1960 FIND v(dout1_12) AT=985.025n

.meas tran vdout1_13ck1960 FIND v(dout1_13) AT=985.025n

.meas tran vdout1_14ck1960 FIND v(dout1_14) AT=985.025n

.meas tran vdout1_15ck1960 FIND v(dout1_15) AT=985.025n

.meas tran vdout1_16ck1960 FIND v(dout1_16) AT=985.025n

.meas tran vdout1_17ck1960 FIND v(dout1_17) AT=985.025n

.meas tran vdout1_18ck1960 FIND v(dout1_18) AT=985.025n

.meas tran vdout1_0ck1970 FIND v(dout1_0) AT=990.025n

.meas tran vdout1_1ck1970 FIND v(dout1_1) AT=990.025n

.meas tran vdout1_2ck1970 FIND v(dout1_2) AT=990.025n

.meas tran vdout1_3ck1970 FIND v(dout1_3) AT=990.025n

.meas tran vdout1_4ck1970 FIND v(dout1_4) AT=990.025n

.meas tran vdout1_5ck1970 FIND v(dout1_5) AT=990.025n

.meas tran vdout1_6ck1970 FIND v(dout1_6) AT=990.025n

.meas tran vdout1_7ck1970 FIND v(dout1_7) AT=990.025n

.meas tran vdout1_8ck1970 FIND v(dout1_8) AT=990.025n

.meas tran vdout1_9ck1970 FIND v(dout1_9) AT=990.025n

.meas tran vdout1_10ck1970 FIND v(dout1_10) AT=990.025n

.meas tran vdout1_11ck1970 FIND v(dout1_11) AT=990.025n

.meas tran vdout1_12ck1970 FIND v(dout1_12) AT=990.025n

.meas tran vdout1_13ck1970 FIND v(dout1_13) AT=990.025n

.meas tran vdout1_14ck1970 FIND v(dout1_14) AT=990.025n

.meas tran vdout1_15ck1970 FIND v(dout1_15) AT=990.025n

.meas tran vdout1_16ck1970 FIND v(dout1_16) AT=990.025n

.meas tran vdout1_17ck1970 FIND v(dout1_17) AT=990.025n

.meas tran vdout1_18ck1970 FIND v(dout1_18) AT=990.025n

.meas tran vdout1_0ck1990 FIND v(dout1_0) AT=1000.025n

.meas tran vdout1_1ck1990 FIND v(dout1_1) AT=1000.025n

.meas tran vdout1_2ck1990 FIND v(dout1_2) AT=1000.025n

.meas tran vdout1_3ck1990 FIND v(dout1_3) AT=1000.025n

.meas tran vdout1_4ck1990 FIND v(dout1_4) AT=1000.025n

.meas tran vdout1_5ck1990 FIND v(dout1_5) AT=1000.025n

.meas tran vdout1_6ck1990 FIND v(dout1_6) AT=1000.025n

.meas tran vdout1_7ck1990 FIND v(dout1_7) AT=1000.025n

.meas tran vdout1_8ck1990 FIND v(dout1_8) AT=1000.025n

.meas tran vdout1_9ck1990 FIND v(dout1_9) AT=1000.025n

.meas tran vdout1_10ck1990 FIND v(dout1_10) AT=1000.025n

.meas tran vdout1_11ck1990 FIND v(dout1_11) AT=1000.025n

.meas tran vdout1_12ck1990 FIND v(dout1_12) AT=1000.025n

.meas tran vdout1_13ck1990 FIND v(dout1_13) AT=1000.025n

.meas tran vdout1_14ck1990 FIND v(dout1_14) AT=1000.025n

.meas tran vdout1_15ck1990 FIND v(dout1_15) AT=1000.025n

.meas tran vdout1_16ck1990 FIND v(dout1_16) AT=1000.025n

.meas tran vdout1_17ck1990 FIND v(dout1_17) AT=1000.025n

.meas tran vdout1_18ck1990 FIND v(dout1_18) AT=1000.025n

.meas tran vdout1_0ck2010 FIND v(dout1_0) AT=1010.025n

.meas tran vdout1_1ck2010 FIND v(dout1_1) AT=1010.025n

.meas tran vdout1_2ck2010 FIND v(dout1_2) AT=1010.025n

.meas tran vdout1_3ck2010 FIND v(dout1_3) AT=1010.025n

.meas tran vdout1_4ck2010 FIND v(dout1_4) AT=1010.025n

.meas tran vdout1_5ck2010 FIND v(dout1_5) AT=1010.025n

.meas tran vdout1_6ck2010 FIND v(dout1_6) AT=1010.025n

.meas tran vdout1_7ck2010 FIND v(dout1_7) AT=1010.025n

.meas tran vdout1_8ck2010 FIND v(dout1_8) AT=1010.025n

.meas tran vdout1_9ck2010 FIND v(dout1_9) AT=1010.025n

.meas tran vdout1_10ck2010 FIND v(dout1_10) AT=1010.025n

.meas tran vdout1_11ck2010 FIND v(dout1_11) AT=1010.025n

.meas tran vdout1_12ck2010 FIND v(dout1_12) AT=1010.025n

.meas tran vdout1_13ck2010 FIND v(dout1_13) AT=1010.025n

.meas tran vdout1_14ck2010 FIND v(dout1_14) AT=1010.025n

.meas tran vdout1_15ck2010 FIND v(dout1_15) AT=1010.025n

.meas tran vdout1_16ck2010 FIND v(dout1_16) AT=1010.025n

.meas tran vdout1_17ck2010 FIND v(dout1_17) AT=1010.025n

.meas tran vdout1_18ck2010 FIND v(dout1_18) AT=1010.025n
