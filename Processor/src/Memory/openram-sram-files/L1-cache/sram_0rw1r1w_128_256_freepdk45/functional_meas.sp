.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_19ck40 FIND v(dout1_19) AT=25.025n

.meas tran vdout1_20ck40 FIND v(dout1_20) AT=25.025n

.meas tran vdout1_21ck40 FIND v(dout1_21) AT=25.025n

.meas tran vdout1_22ck40 FIND v(dout1_22) AT=25.025n

.meas tran vdout1_23ck40 FIND v(dout1_23) AT=25.025n

.meas tran vdout1_24ck40 FIND v(dout1_24) AT=25.025n

.meas tran vdout1_25ck40 FIND v(dout1_25) AT=25.025n

.meas tran vdout1_26ck40 FIND v(dout1_26) AT=25.025n

.meas tran vdout1_27ck40 FIND v(dout1_27) AT=25.025n

.meas tran vdout1_28ck40 FIND v(dout1_28) AT=25.025n

.meas tran vdout1_29ck40 FIND v(dout1_29) AT=25.025n

.meas tran vdout1_30ck40 FIND v(dout1_30) AT=25.025n

.meas tran vdout1_31ck40 FIND v(dout1_31) AT=25.025n

.meas tran vdout1_32ck40 FIND v(dout1_32) AT=25.025n

.meas tran vdout1_33ck40 FIND v(dout1_33) AT=25.025n

.meas tran vdout1_34ck40 FIND v(dout1_34) AT=25.025n

.meas tran vdout1_35ck40 FIND v(dout1_35) AT=25.025n

.meas tran vdout1_36ck40 FIND v(dout1_36) AT=25.025n

.meas tran vdout1_37ck40 FIND v(dout1_37) AT=25.025n

.meas tran vdout1_38ck40 FIND v(dout1_38) AT=25.025n

.meas tran vdout1_39ck40 FIND v(dout1_39) AT=25.025n

.meas tran vdout1_40ck40 FIND v(dout1_40) AT=25.025n

.meas tran vdout1_41ck40 FIND v(dout1_41) AT=25.025n

.meas tran vdout1_42ck40 FIND v(dout1_42) AT=25.025n

.meas tran vdout1_43ck40 FIND v(dout1_43) AT=25.025n

.meas tran vdout1_44ck40 FIND v(dout1_44) AT=25.025n

.meas tran vdout1_45ck40 FIND v(dout1_45) AT=25.025n

.meas tran vdout1_46ck40 FIND v(dout1_46) AT=25.025n

.meas tran vdout1_47ck40 FIND v(dout1_47) AT=25.025n

.meas tran vdout1_48ck40 FIND v(dout1_48) AT=25.025n

.meas tran vdout1_49ck40 FIND v(dout1_49) AT=25.025n

.meas tran vdout1_50ck40 FIND v(dout1_50) AT=25.025n

.meas tran vdout1_51ck40 FIND v(dout1_51) AT=25.025n

.meas tran vdout1_52ck40 FIND v(dout1_52) AT=25.025n

.meas tran vdout1_53ck40 FIND v(dout1_53) AT=25.025n

.meas tran vdout1_54ck40 FIND v(dout1_54) AT=25.025n

.meas tran vdout1_55ck40 FIND v(dout1_55) AT=25.025n

.meas tran vdout1_56ck40 FIND v(dout1_56) AT=25.025n

.meas tran vdout1_57ck40 FIND v(dout1_57) AT=25.025n

.meas tran vdout1_58ck40 FIND v(dout1_58) AT=25.025n

.meas tran vdout1_59ck40 FIND v(dout1_59) AT=25.025n

.meas tran vdout1_60ck40 FIND v(dout1_60) AT=25.025n

.meas tran vdout1_61ck40 FIND v(dout1_61) AT=25.025n

.meas tran vdout1_62ck40 FIND v(dout1_62) AT=25.025n

.meas tran vdout1_63ck40 FIND v(dout1_63) AT=25.025n

.meas tran vdout1_64ck40 FIND v(dout1_64) AT=25.025n

.meas tran vdout1_65ck40 FIND v(dout1_65) AT=25.025n

.meas tran vdout1_66ck40 FIND v(dout1_66) AT=25.025n

.meas tran vdout1_67ck40 FIND v(dout1_67) AT=25.025n

.meas tran vdout1_68ck40 FIND v(dout1_68) AT=25.025n

.meas tran vdout1_69ck40 FIND v(dout1_69) AT=25.025n

.meas tran vdout1_70ck40 FIND v(dout1_70) AT=25.025n

.meas tran vdout1_71ck40 FIND v(dout1_71) AT=25.025n

.meas tran vdout1_72ck40 FIND v(dout1_72) AT=25.025n

.meas tran vdout1_73ck40 FIND v(dout1_73) AT=25.025n

.meas tran vdout1_74ck40 FIND v(dout1_74) AT=25.025n

.meas tran vdout1_75ck40 FIND v(dout1_75) AT=25.025n

.meas tran vdout1_76ck40 FIND v(dout1_76) AT=25.025n

.meas tran vdout1_77ck40 FIND v(dout1_77) AT=25.025n

.meas tran vdout1_78ck40 FIND v(dout1_78) AT=25.025n

.meas tran vdout1_79ck40 FIND v(dout1_79) AT=25.025n

.meas tran vdout1_80ck40 FIND v(dout1_80) AT=25.025n

.meas tran vdout1_81ck40 FIND v(dout1_81) AT=25.025n

.meas tran vdout1_82ck40 FIND v(dout1_82) AT=25.025n

.meas tran vdout1_83ck40 FIND v(dout1_83) AT=25.025n

.meas tran vdout1_84ck40 FIND v(dout1_84) AT=25.025n

.meas tran vdout1_85ck40 FIND v(dout1_85) AT=25.025n

.meas tran vdout1_86ck40 FIND v(dout1_86) AT=25.025n

.meas tran vdout1_87ck40 FIND v(dout1_87) AT=25.025n

.meas tran vdout1_88ck40 FIND v(dout1_88) AT=25.025n

.meas tran vdout1_89ck40 FIND v(dout1_89) AT=25.025n

.meas tran vdout1_90ck40 FIND v(dout1_90) AT=25.025n

.meas tran vdout1_91ck40 FIND v(dout1_91) AT=25.025n

.meas tran vdout1_92ck40 FIND v(dout1_92) AT=25.025n

.meas tran vdout1_93ck40 FIND v(dout1_93) AT=25.025n

.meas tran vdout1_94ck40 FIND v(dout1_94) AT=25.025n

.meas tran vdout1_95ck40 FIND v(dout1_95) AT=25.025n

.meas tran vdout1_96ck40 FIND v(dout1_96) AT=25.025n

.meas tran vdout1_97ck40 FIND v(dout1_97) AT=25.025n

.meas tran vdout1_98ck40 FIND v(dout1_98) AT=25.025n

.meas tran vdout1_99ck40 FIND v(dout1_99) AT=25.025n

.meas tran vdout1_100ck40 FIND v(dout1_100) AT=25.025n

.meas tran vdout1_101ck40 FIND v(dout1_101) AT=25.025n

.meas tran vdout1_102ck40 FIND v(dout1_102) AT=25.025n

.meas tran vdout1_103ck40 FIND v(dout1_103) AT=25.025n

.meas tran vdout1_104ck40 FIND v(dout1_104) AT=25.025n

.meas tran vdout1_105ck40 FIND v(dout1_105) AT=25.025n

.meas tran vdout1_106ck40 FIND v(dout1_106) AT=25.025n

.meas tran vdout1_107ck40 FIND v(dout1_107) AT=25.025n

.meas tran vdout1_108ck40 FIND v(dout1_108) AT=25.025n

.meas tran vdout1_109ck40 FIND v(dout1_109) AT=25.025n

.meas tran vdout1_110ck40 FIND v(dout1_110) AT=25.025n

.meas tran vdout1_111ck40 FIND v(dout1_111) AT=25.025n

.meas tran vdout1_112ck40 FIND v(dout1_112) AT=25.025n

.meas tran vdout1_113ck40 FIND v(dout1_113) AT=25.025n

.meas tran vdout1_114ck40 FIND v(dout1_114) AT=25.025n

.meas tran vdout1_115ck40 FIND v(dout1_115) AT=25.025n

.meas tran vdout1_116ck40 FIND v(dout1_116) AT=25.025n

.meas tran vdout1_117ck40 FIND v(dout1_117) AT=25.025n

.meas tran vdout1_118ck40 FIND v(dout1_118) AT=25.025n

.meas tran vdout1_119ck40 FIND v(dout1_119) AT=25.025n

.meas tran vdout1_120ck40 FIND v(dout1_120) AT=25.025n

.meas tran vdout1_121ck40 FIND v(dout1_121) AT=25.025n

.meas tran vdout1_122ck40 FIND v(dout1_122) AT=25.025n

.meas tran vdout1_123ck40 FIND v(dout1_123) AT=25.025n

.meas tran vdout1_124ck40 FIND v(dout1_124) AT=25.025n

.meas tran vdout1_125ck40 FIND v(dout1_125) AT=25.025n

.meas tran vdout1_126ck40 FIND v(dout1_126) AT=25.025n

.meas tran vdout1_127ck40 FIND v(dout1_127) AT=25.025n

.meas tran vdout1_0ck60 FIND v(dout1_0) AT=35.025n

.meas tran vdout1_1ck60 FIND v(dout1_1) AT=35.025n

.meas tran vdout1_2ck60 FIND v(dout1_2) AT=35.025n

.meas tran vdout1_3ck60 FIND v(dout1_3) AT=35.025n

.meas tran vdout1_4ck60 FIND v(dout1_4) AT=35.025n

.meas tran vdout1_5ck60 FIND v(dout1_5) AT=35.025n

.meas tran vdout1_6ck60 FIND v(dout1_6) AT=35.025n

.meas tran vdout1_7ck60 FIND v(dout1_7) AT=35.025n

.meas tran vdout1_8ck60 FIND v(dout1_8) AT=35.025n

.meas tran vdout1_9ck60 FIND v(dout1_9) AT=35.025n

.meas tran vdout1_10ck60 FIND v(dout1_10) AT=35.025n

.meas tran vdout1_11ck60 FIND v(dout1_11) AT=35.025n

.meas tran vdout1_12ck60 FIND v(dout1_12) AT=35.025n

.meas tran vdout1_13ck60 FIND v(dout1_13) AT=35.025n

.meas tran vdout1_14ck60 FIND v(dout1_14) AT=35.025n

.meas tran vdout1_15ck60 FIND v(dout1_15) AT=35.025n

.meas tran vdout1_16ck60 FIND v(dout1_16) AT=35.025n

.meas tran vdout1_17ck60 FIND v(dout1_17) AT=35.025n

.meas tran vdout1_18ck60 FIND v(dout1_18) AT=35.025n

.meas tran vdout1_19ck60 FIND v(dout1_19) AT=35.025n

.meas tran vdout1_20ck60 FIND v(dout1_20) AT=35.025n

.meas tran vdout1_21ck60 FIND v(dout1_21) AT=35.025n

.meas tran vdout1_22ck60 FIND v(dout1_22) AT=35.025n

.meas tran vdout1_23ck60 FIND v(dout1_23) AT=35.025n

.meas tran vdout1_24ck60 FIND v(dout1_24) AT=35.025n

.meas tran vdout1_25ck60 FIND v(dout1_25) AT=35.025n

.meas tran vdout1_26ck60 FIND v(dout1_26) AT=35.025n

.meas tran vdout1_27ck60 FIND v(dout1_27) AT=35.025n

.meas tran vdout1_28ck60 FIND v(dout1_28) AT=35.025n

.meas tran vdout1_29ck60 FIND v(dout1_29) AT=35.025n

.meas tran vdout1_30ck60 FIND v(dout1_30) AT=35.025n

.meas tran vdout1_31ck60 FIND v(dout1_31) AT=35.025n

.meas tran vdout1_32ck60 FIND v(dout1_32) AT=35.025n

.meas tran vdout1_33ck60 FIND v(dout1_33) AT=35.025n

.meas tran vdout1_34ck60 FIND v(dout1_34) AT=35.025n

.meas tran vdout1_35ck60 FIND v(dout1_35) AT=35.025n

.meas tran vdout1_36ck60 FIND v(dout1_36) AT=35.025n

.meas tran vdout1_37ck60 FIND v(dout1_37) AT=35.025n

.meas tran vdout1_38ck60 FIND v(dout1_38) AT=35.025n

.meas tran vdout1_39ck60 FIND v(dout1_39) AT=35.025n

.meas tran vdout1_40ck60 FIND v(dout1_40) AT=35.025n

.meas tran vdout1_41ck60 FIND v(dout1_41) AT=35.025n

.meas tran vdout1_42ck60 FIND v(dout1_42) AT=35.025n

.meas tran vdout1_43ck60 FIND v(dout1_43) AT=35.025n

.meas tran vdout1_44ck60 FIND v(dout1_44) AT=35.025n

.meas tran vdout1_45ck60 FIND v(dout1_45) AT=35.025n

.meas tran vdout1_46ck60 FIND v(dout1_46) AT=35.025n

.meas tran vdout1_47ck60 FIND v(dout1_47) AT=35.025n

.meas tran vdout1_48ck60 FIND v(dout1_48) AT=35.025n

.meas tran vdout1_49ck60 FIND v(dout1_49) AT=35.025n

.meas tran vdout1_50ck60 FIND v(dout1_50) AT=35.025n

.meas tran vdout1_51ck60 FIND v(dout1_51) AT=35.025n

.meas tran vdout1_52ck60 FIND v(dout1_52) AT=35.025n

.meas tran vdout1_53ck60 FIND v(dout1_53) AT=35.025n

.meas tran vdout1_54ck60 FIND v(dout1_54) AT=35.025n

.meas tran vdout1_55ck60 FIND v(dout1_55) AT=35.025n

.meas tran vdout1_56ck60 FIND v(dout1_56) AT=35.025n

.meas tran vdout1_57ck60 FIND v(dout1_57) AT=35.025n

.meas tran vdout1_58ck60 FIND v(dout1_58) AT=35.025n

.meas tran vdout1_59ck60 FIND v(dout1_59) AT=35.025n

.meas tran vdout1_60ck60 FIND v(dout1_60) AT=35.025n

.meas tran vdout1_61ck60 FIND v(dout1_61) AT=35.025n

.meas tran vdout1_62ck60 FIND v(dout1_62) AT=35.025n

.meas tran vdout1_63ck60 FIND v(dout1_63) AT=35.025n

.meas tran vdout1_64ck60 FIND v(dout1_64) AT=35.025n

.meas tran vdout1_65ck60 FIND v(dout1_65) AT=35.025n

.meas tran vdout1_66ck60 FIND v(dout1_66) AT=35.025n

.meas tran vdout1_67ck60 FIND v(dout1_67) AT=35.025n

.meas tran vdout1_68ck60 FIND v(dout1_68) AT=35.025n

.meas tran vdout1_69ck60 FIND v(dout1_69) AT=35.025n

.meas tran vdout1_70ck60 FIND v(dout1_70) AT=35.025n

.meas tran vdout1_71ck60 FIND v(dout1_71) AT=35.025n

.meas tran vdout1_72ck60 FIND v(dout1_72) AT=35.025n

.meas tran vdout1_73ck60 FIND v(dout1_73) AT=35.025n

.meas tran vdout1_74ck60 FIND v(dout1_74) AT=35.025n

.meas tran vdout1_75ck60 FIND v(dout1_75) AT=35.025n

.meas tran vdout1_76ck60 FIND v(dout1_76) AT=35.025n

.meas tran vdout1_77ck60 FIND v(dout1_77) AT=35.025n

.meas tran vdout1_78ck60 FIND v(dout1_78) AT=35.025n

.meas tran vdout1_79ck60 FIND v(dout1_79) AT=35.025n

.meas tran vdout1_80ck60 FIND v(dout1_80) AT=35.025n

.meas tran vdout1_81ck60 FIND v(dout1_81) AT=35.025n

.meas tran vdout1_82ck60 FIND v(dout1_82) AT=35.025n

.meas tran vdout1_83ck60 FIND v(dout1_83) AT=35.025n

.meas tran vdout1_84ck60 FIND v(dout1_84) AT=35.025n

.meas tran vdout1_85ck60 FIND v(dout1_85) AT=35.025n

.meas tran vdout1_86ck60 FIND v(dout1_86) AT=35.025n

.meas tran vdout1_87ck60 FIND v(dout1_87) AT=35.025n

.meas tran vdout1_88ck60 FIND v(dout1_88) AT=35.025n

.meas tran vdout1_89ck60 FIND v(dout1_89) AT=35.025n

.meas tran vdout1_90ck60 FIND v(dout1_90) AT=35.025n

.meas tran vdout1_91ck60 FIND v(dout1_91) AT=35.025n

.meas tran vdout1_92ck60 FIND v(dout1_92) AT=35.025n

.meas tran vdout1_93ck60 FIND v(dout1_93) AT=35.025n

.meas tran vdout1_94ck60 FIND v(dout1_94) AT=35.025n

.meas tran vdout1_95ck60 FIND v(dout1_95) AT=35.025n

.meas tran vdout1_96ck60 FIND v(dout1_96) AT=35.025n

.meas tran vdout1_97ck60 FIND v(dout1_97) AT=35.025n

.meas tran vdout1_98ck60 FIND v(dout1_98) AT=35.025n

.meas tran vdout1_99ck60 FIND v(dout1_99) AT=35.025n

.meas tran vdout1_100ck60 FIND v(dout1_100) AT=35.025n

.meas tran vdout1_101ck60 FIND v(dout1_101) AT=35.025n

.meas tran vdout1_102ck60 FIND v(dout1_102) AT=35.025n

.meas tran vdout1_103ck60 FIND v(dout1_103) AT=35.025n

.meas tran vdout1_104ck60 FIND v(dout1_104) AT=35.025n

.meas tran vdout1_105ck60 FIND v(dout1_105) AT=35.025n

.meas tran vdout1_106ck60 FIND v(dout1_106) AT=35.025n

.meas tran vdout1_107ck60 FIND v(dout1_107) AT=35.025n

.meas tran vdout1_108ck60 FIND v(dout1_108) AT=35.025n

.meas tran vdout1_109ck60 FIND v(dout1_109) AT=35.025n

.meas tran vdout1_110ck60 FIND v(dout1_110) AT=35.025n

.meas tran vdout1_111ck60 FIND v(dout1_111) AT=35.025n

.meas tran vdout1_112ck60 FIND v(dout1_112) AT=35.025n

.meas tran vdout1_113ck60 FIND v(dout1_113) AT=35.025n

.meas tran vdout1_114ck60 FIND v(dout1_114) AT=35.025n

.meas tran vdout1_115ck60 FIND v(dout1_115) AT=35.025n

.meas tran vdout1_116ck60 FIND v(dout1_116) AT=35.025n

.meas tran vdout1_117ck60 FIND v(dout1_117) AT=35.025n

.meas tran vdout1_118ck60 FIND v(dout1_118) AT=35.025n

.meas tran vdout1_119ck60 FIND v(dout1_119) AT=35.025n

.meas tran vdout1_120ck60 FIND v(dout1_120) AT=35.025n

.meas tran vdout1_121ck60 FIND v(dout1_121) AT=35.025n

.meas tran vdout1_122ck60 FIND v(dout1_122) AT=35.025n

.meas tran vdout1_123ck60 FIND v(dout1_123) AT=35.025n

.meas tran vdout1_124ck60 FIND v(dout1_124) AT=35.025n

.meas tran vdout1_125ck60 FIND v(dout1_125) AT=35.025n

.meas tran vdout1_126ck60 FIND v(dout1_126) AT=35.025n

.meas tran vdout1_127ck60 FIND v(dout1_127) AT=35.025n

.meas tran vdout1_0ck100 FIND v(dout1_0) AT=55.025n

.meas tran vdout1_1ck100 FIND v(dout1_1) AT=55.025n

.meas tran vdout1_2ck100 FIND v(dout1_2) AT=55.025n

.meas tran vdout1_3ck100 FIND v(dout1_3) AT=55.025n

.meas tran vdout1_4ck100 FIND v(dout1_4) AT=55.025n

.meas tran vdout1_5ck100 FIND v(dout1_5) AT=55.025n

.meas tran vdout1_6ck100 FIND v(dout1_6) AT=55.025n

.meas tran vdout1_7ck100 FIND v(dout1_7) AT=55.025n

.meas tran vdout1_8ck100 FIND v(dout1_8) AT=55.025n

.meas tran vdout1_9ck100 FIND v(dout1_9) AT=55.025n

.meas tran vdout1_10ck100 FIND v(dout1_10) AT=55.025n

.meas tran vdout1_11ck100 FIND v(dout1_11) AT=55.025n

.meas tran vdout1_12ck100 FIND v(dout1_12) AT=55.025n

.meas tran vdout1_13ck100 FIND v(dout1_13) AT=55.025n

.meas tran vdout1_14ck100 FIND v(dout1_14) AT=55.025n

.meas tran vdout1_15ck100 FIND v(dout1_15) AT=55.025n

.meas tran vdout1_16ck100 FIND v(dout1_16) AT=55.025n

.meas tran vdout1_17ck100 FIND v(dout1_17) AT=55.025n

.meas tran vdout1_18ck100 FIND v(dout1_18) AT=55.025n

.meas tran vdout1_19ck100 FIND v(dout1_19) AT=55.025n

.meas tran vdout1_20ck100 FIND v(dout1_20) AT=55.025n

.meas tran vdout1_21ck100 FIND v(dout1_21) AT=55.025n

.meas tran vdout1_22ck100 FIND v(dout1_22) AT=55.025n

.meas tran vdout1_23ck100 FIND v(dout1_23) AT=55.025n

.meas tran vdout1_24ck100 FIND v(dout1_24) AT=55.025n

.meas tran vdout1_25ck100 FIND v(dout1_25) AT=55.025n

.meas tran vdout1_26ck100 FIND v(dout1_26) AT=55.025n

.meas tran vdout1_27ck100 FIND v(dout1_27) AT=55.025n

.meas tran vdout1_28ck100 FIND v(dout1_28) AT=55.025n

.meas tran vdout1_29ck100 FIND v(dout1_29) AT=55.025n

.meas tran vdout1_30ck100 FIND v(dout1_30) AT=55.025n

.meas tran vdout1_31ck100 FIND v(dout1_31) AT=55.025n

.meas tran vdout1_32ck100 FIND v(dout1_32) AT=55.025n

.meas tran vdout1_33ck100 FIND v(dout1_33) AT=55.025n

.meas tran vdout1_34ck100 FIND v(dout1_34) AT=55.025n

.meas tran vdout1_35ck100 FIND v(dout1_35) AT=55.025n

.meas tran vdout1_36ck100 FIND v(dout1_36) AT=55.025n

.meas tran vdout1_37ck100 FIND v(dout1_37) AT=55.025n

.meas tran vdout1_38ck100 FIND v(dout1_38) AT=55.025n

.meas tran vdout1_39ck100 FIND v(dout1_39) AT=55.025n

.meas tran vdout1_40ck100 FIND v(dout1_40) AT=55.025n

.meas tran vdout1_41ck100 FIND v(dout1_41) AT=55.025n

.meas tran vdout1_42ck100 FIND v(dout1_42) AT=55.025n

.meas tran vdout1_43ck100 FIND v(dout1_43) AT=55.025n

.meas tran vdout1_44ck100 FIND v(dout1_44) AT=55.025n

.meas tran vdout1_45ck100 FIND v(dout1_45) AT=55.025n

.meas tran vdout1_46ck100 FIND v(dout1_46) AT=55.025n

.meas tran vdout1_47ck100 FIND v(dout1_47) AT=55.025n

.meas tran vdout1_48ck100 FIND v(dout1_48) AT=55.025n

.meas tran vdout1_49ck100 FIND v(dout1_49) AT=55.025n

.meas tran vdout1_50ck100 FIND v(dout1_50) AT=55.025n

.meas tran vdout1_51ck100 FIND v(dout1_51) AT=55.025n

.meas tran vdout1_52ck100 FIND v(dout1_52) AT=55.025n

.meas tran vdout1_53ck100 FIND v(dout1_53) AT=55.025n

.meas tran vdout1_54ck100 FIND v(dout1_54) AT=55.025n

.meas tran vdout1_55ck100 FIND v(dout1_55) AT=55.025n

.meas tran vdout1_56ck100 FIND v(dout1_56) AT=55.025n

.meas tran vdout1_57ck100 FIND v(dout1_57) AT=55.025n

.meas tran vdout1_58ck100 FIND v(dout1_58) AT=55.025n

.meas tran vdout1_59ck100 FIND v(dout1_59) AT=55.025n

.meas tran vdout1_60ck100 FIND v(dout1_60) AT=55.025n

.meas tran vdout1_61ck100 FIND v(dout1_61) AT=55.025n

.meas tran vdout1_62ck100 FIND v(dout1_62) AT=55.025n

.meas tran vdout1_63ck100 FIND v(dout1_63) AT=55.025n

.meas tran vdout1_64ck100 FIND v(dout1_64) AT=55.025n

.meas tran vdout1_65ck100 FIND v(dout1_65) AT=55.025n

.meas tran vdout1_66ck100 FIND v(dout1_66) AT=55.025n

.meas tran vdout1_67ck100 FIND v(dout1_67) AT=55.025n

.meas tran vdout1_68ck100 FIND v(dout1_68) AT=55.025n

.meas tran vdout1_69ck100 FIND v(dout1_69) AT=55.025n

.meas tran vdout1_70ck100 FIND v(dout1_70) AT=55.025n

.meas tran vdout1_71ck100 FIND v(dout1_71) AT=55.025n

.meas tran vdout1_72ck100 FIND v(dout1_72) AT=55.025n

.meas tran vdout1_73ck100 FIND v(dout1_73) AT=55.025n

.meas tran vdout1_74ck100 FIND v(dout1_74) AT=55.025n

.meas tran vdout1_75ck100 FIND v(dout1_75) AT=55.025n

.meas tran vdout1_76ck100 FIND v(dout1_76) AT=55.025n

.meas tran vdout1_77ck100 FIND v(dout1_77) AT=55.025n

.meas tran vdout1_78ck100 FIND v(dout1_78) AT=55.025n

.meas tran vdout1_79ck100 FIND v(dout1_79) AT=55.025n

.meas tran vdout1_80ck100 FIND v(dout1_80) AT=55.025n

.meas tran vdout1_81ck100 FIND v(dout1_81) AT=55.025n

.meas tran vdout1_82ck100 FIND v(dout1_82) AT=55.025n

.meas tran vdout1_83ck100 FIND v(dout1_83) AT=55.025n

.meas tran vdout1_84ck100 FIND v(dout1_84) AT=55.025n

.meas tran vdout1_85ck100 FIND v(dout1_85) AT=55.025n

.meas tran vdout1_86ck100 FIND v(dout1_86) AT=55.025n

.meas tran vdout1_87ck100 FIND v(dout1_87) AT=55.025n

.meas tran vdout1_88ck100 FIND v(dout1_88) AT=55.025n

.meas tran vdout1_89ck100 FIND v(dout1_89) AT=55.025n

.meas tran vdout1_90ck100 FIND v(dout1_90) AT=55.025n

.meas tran vdout1_91ck100 FIND v(dout1_91) AT=55.025n

.meas tran vdout1_92ck100 FIND v(dout1_92) AT=55.025n

.meas tran vdout1_93ck100 FIND v(dout1_93) AT=55.025n

.meas tran vdout1_94ck100 FIND v(dout1_94) AT=55.025n

.meas tran vdout1_95ck100 FIND v(dout1_95) AT=55.025n

.meas tran vdout1_96ck100 FIND v(dout1_96) AT=55.025n

.meas tran vdout1_97ck100 FIND v(dout1_97) AT=55.025n

.meas tran vdout1_98ck100 FIND v(dout1_98) AT=55.025n

.meas tran vdout1_99ck100 FIND v(dout1_99) AT=55.025n

.meas tran vdout1_100ck100 FIND v(dout1_100) AT=55.025n

.meas tran vdout1_101ck100 FIND v(dout1_101) AT=55.025n

.meas tran vdout1_102ck100 FIND v(dout1_102) AT=55.025n

.meas tran vdout1_103ck100 FIND v(dout1_103) AT=55.025n

.meas tran vdout1_104ck100 FIND v(dout1_104) AT=55.025n

.meas tran vdout1_105ck100 FIND v(dout1_105) AT=55.025n

.meas tran vdout1_106ck100 FIND v(dout1_106) AT=55.025n

.meas tran vdout1_107ck100 FIND v(dout1_107) AT=55.025n

.meas tran vdout1_108ck100 FIND v(dout1_108) AT=55.025n

.meas tran vdout1_109ck100 FIND v(dout1_109) AT=55.025n

.meas tran vdout1_110ck100 FIND v(dout1_110) AT=55.025n

.meas tran vdout1_111ck100 FIND v(dout1_111) AT=55.025n

.meas tran vdout1_112ck100 FIND v(dout1_112) AT=55.025n

.meas tran vdout1_113ck100 FIND v(dout1_113) AT=55.025n

.meas tran vdout1_114ck100 FIND v(dout1_114) AT=55.025n

.meas tran vdout1_115ck100 FIND v(dout1_115) AT=55.025n

.meas tran vdout1_116ck100 FIND v(dout1_116) AT=55.025n

.meas tran vdout1_117ck100 FIND v(dout1_117) AT=55.025n

.meas tran vdout1_118ck100 FIND v(dout1_118) AT=55.025n

.meas tran vdout1_119ck100 FIND v(dout1_119) AT=55.025n

.meas tran vdout1_120ck100 FIND v(dout1_120) AT=55.025n

.meas tran vdout1_121ck100 FIND v(dout1_121) AT=55.025n

.meas tran vdout1_122ck100 FIND v(dout1_122) AT=55.025n

.meas tran vdout1_123ck100 FIND v(dout1_123) AT=55.025n

.meas tran vdout1_124ck100 FIND v(dout1_124) AT=55.025n

.meas tran vdout1_125ck100 FIND v(dout1_125) AT=55.025n

.meas tran vdout1_126ck100 FIND v(dout1_126) AT=55.025n

.meas tran vdout1_127ck100 FIND v(dout1_127) AT=55.025n

.meas tran vdout1_0ck130 FIND v(dout1_0) AT=70.025n

.meas tran vdout1_1ck130 FIND v(dout1_1) AT=70.025n

.meas tran vdout1_2ck130 FIND v(dout1_2) AT=70.025n

.meas tran vdout1_3ck130 FIND v(dout1_3) AT=70.025n

.meas tran vdout1_4ck130 FIND v(dout1_4) AT=70.025n

.meas tran vdout1_5ck130 FIND v(dout1_5) AT=70.025n

.meas tran vdout1_6ck130 FIND v(dout1_6) AT=70.025n

.meas tran vdout1_7ck130 FIND v(dout1_7) AT=70.025n

.meas tran vdout1_8ck130 FIND v(dout1_8) AT=70.025n

.meas tran vdout1_9ck130 FIND v(dout1_9) AT=70.025n

.meas tran vdout1_10ck130 FIND v(dout1_10) AT=70.025n

.meas tran vdout1_11ck130 FIND v(dout1_11) AT=70.025n

.meas tran vdout1_12ck130 FIND v(dout1_12) AT=70.025n

.meas tran vdout1_13ck130 FIND v(dout1_13) AT=70.025n

.meas tran vdout1_14ck130 FIND v(dout1_14) AT=70.025n

.meas tran vdout1_15ck130 FIND v(dout1_15) AT=70.025n

.meas tran vdout1_16ck130 FIND v(dout1_16) AT=70.025n

.meas tran vdout1_17ck130 FIND v(dout1_17) AT=70.025n

.meas tran vdout1_18ck130 FIND v(dout1_18) AT=70.025n

.meas tran vdout1_19ck130 FIND v(dout1_19) AT=70.025n

.meas tran vdout1_20ck130 FIND v(dout1_20) AT=70.025n

.meas tran vdout1_21ck130 FIND v(dout1_21) AT=70.025n

.meas tran vdout1_22ck130 FIND v(dout1_22) AT=70.025n

.meas tran vdout1_23ck130 FIND v(dout1_23) AT=70.025n

.meas tran vdout1_24ck130 FIND v(dout1_24) AT=70.025n

.meas tran vdout1_25ck130 FIND v(dout1_25) AT=70.025n

.meas tran vdout1_26ck130 FIND v(dout1_26) AT=70.025n

.meas tran vdout1_27ck130 FIND v(dout1_27) AT=70.025n

.meas tran vdout1_28ck130 FIND v(dout1_28) AT=70.025n

.meas tran vdout1_29ck130 FIND v(dout1_29) AT=70.025n

.meas tran vdout1_30ck130 FIND v(dout1_30) AT=70.025n

.meas tran vdout1_31ck130 FIND v(dout1_31) AT=70.025n

.meas tran vdout1_32ck130 FIND v(dout1_32) AT=70.025n

.meas tran vdout1_33ck130 FIND v(dout1_33) AT=70.025n

.meas tran vdout1_34ck130 FIND v(dout1_34) AT=70.025n

.meas tran vdout1_35ck130 FIND v(dout1_35) AT=70.025n

.meas tran vdout1_36ck130 FIND v(dout1_36) AT=70.025n

.meas tran vdout1_37ck130 FIND v(dout1_37) AT=70.025n

.meas tran vdout1_38ck130 FIND v(dout1_38) AT=70.025n

.meas tran vdout1_39ck130 FIND v(dout1_39) AT=70.025n

.meas tran vdout1_40ck130 FIND v(dout1_40) AT=70.025n

.meas tran vdout1_41ck130 FIND v(dout1_41) AT=70.025n

.meas tran vdout1_42ck130 FIND v(dout1_42) AT=70.025n

.meas tran vdout1_43ck130 FIND v(dout1_43) AT=70.025n

.meas tran vdout1_44ck130 FIND v(dout1_44) AT=70.025n

.meas tran vdout1_45ck130 FIND v(dout1_45) AT=70.025n

.meas tran vdout1_46ck130 FIND v(dout1_46) AT=70.025n

.meas tran vdout1_47ck130 FIND v(dout1_47) AT=70.025n

.meas tran vdout1_48ck130 FIND v(dout1_48) AT=70.025n

.meas tran vdout1_49ck130 FIND v(dout1_49) AT=70.025n

.meas tran vdout1_50ck130 FIND v(dout1_50) AT=70.025n

.meas tran vdout1_51ck130 FIND v(dout1_51) AT=70.025n

.meas tran vdout1_52ck130 FIND v(dout1_52) AT=70.025n

.meas tran vdout1_53ck130 FIND v(dout1_53) AT=70.025n

.meas tran vdout1_54ck130 FIND v(dout1_54) AT=70.025n

.meas tran vdout1_55ck130 FIND v(dout1_55) AT=70.025n

.meas tran vdout1_56ck130 FIND v(dout1_56) AT=70.025n

.meas tran vdout1_57ck130 FIND v(dout1_57) AT=70.025n

.meas tran vdout1_58ck130 FIND v(dout1_58) AT=70.025n

.meas tran vdout1_59ck130 FIND v(dout1_59) AT=70.025n

.meas tran vdout1_60ck130 FIND v(dout1_60) AT=70.025n

.meas tran vdout1_61ck130 FIND v(dout1_61) AT=70.025n

.meas tran vdout1_62ck130 FIND v(dout1_62) AT=70.025n

.meas tran vdout1_63ck130 FIND v(dout1_63) AT=70.025n

.meas tran vdout1_64ck130 FIND v(dout1_64) AT=70.025n

.meas tran vdout1_65ck130 FIND v(dout1_65) AT=70.025n

.meas tran vdout1_66ck130 FIND v(dout1_66) AT=70.025n

.meas tran vdout1_67ck130 FIND v(dout1_67) AT=70.025n

.meas tran vdout1_68ck130 FIND v(dout1_68) AT=70.025n

.meas tran vdout1_69ck130 FIND v(dout1_69) AT=70.025n

.meas tran vdout1_70ck130 FIND v(dout1_70) AT=70.025n

.meas tran vdout1_71ck130 FIND v(dout1_71) AT=70.025n

.meas tran vdout1_72ck130 FIND v(dout1_72) AT=70.025n

.meas tran vdout1_73ck130 FIND v(dout1_73) AT=70.025n

.meas tran vdout1_74ck130 FIND v(dout1_74) AT=70.025n

.meas tran vdout1_75ck130 FIND v(dout1_75) AT=70.025n

.meas tran vdout1_76ck130 FIND v(dout1_76) AT=70.025n

.meas tran vdout1_77ck130 FIND v(dout1_77) AT=70.025n

.meas tran vdout1_78ck130 FIND v(dout1_78) AT=70.025n

.meas tran vdout1_79ck130 FIND v(dout1_79) AT=70.025n

.meas tran vdout1_80ck130 FIND v(dout1_80) AT=70.025n

.meas tran vdout1_81ck130 FIND v(dout1_81) AT=70.025n

.meas tran vdout1_82ck130 FIND v(dout1_82) AT=70.025n

.meas tran vdout1_83ck130 FIND v(dout1_83) AT=70.025n

.meas tran vdout1_84ck130 FIND v(dout1_84) AT=70.025n

.meas tran vdout1_85ck130 FIND v(dout1_85) AT=70.025n

.meas tran vdout1_86ck130 FIND v(dout1_86) AT=70.025n

.meas tran vdout1_87ck130 FIND v(dout1_87) AT=70.025n

.meas tran vdout1_88ck130 FIND v(dout1_88) AT=70.025n

.meas tran vdout1_89ck130 FIND v(dout1_89) AT=70.025n

.meas tran vdout1_90ck130 FIND v(dout1_90) AT=70.025n

.meas tran vdout1_91ck130 FIND v(dout1_91) AT=70.025n

.meas tran vdout1_92ck130 FIND v(dout1_92) AT=70.025n

.meas tran vdout1_93ck130 FIND v(dout1_93) AT=70.025n

.meas tran vdout1_94ck130 FIND v(dout1_94) AT=70.025n

.meas tran vdout1_95ck130 FIND v(dout1_95) AT=70.025n

.meas tran vdout1_96ck130 FIND v(dout1_96) AT=70.025n

.meas tran vdout1_97ck130 FIND v(dout1_97) AT=70.025n

.meas tran vdout1_98ck130 FIND v(dout1_98) AT=70.025n

.meas tran vdout1_99ck130 FIND v(dout1_99) AT=70.025n

.meas tran vdout1_100ck130 FIND v(dout1_100) AT=70.025n

.meas tran vdout1_101ck130 FIND v(dout1_101) AT=70.025n

.meas tran vdout1_102ck130 FIND v(dout1_102) AT=70.025n

.meas tran vdout1_103ck130 FIND v(dout1_103) AT=70.025n

.meas tran vdout1_104ck130 FIND v(dout1_104) AT=70.025n

.meas tran vdout1_105ck130 FIND v(dout1_105) AT=70.025n

.meas tran vdout1_106ck130 FIND v(dout1_106) AT=70.025n

.meas tran vdout1_107ck130 FIND v(dout1_107) AT=70.025n

.meas tran vdout1_108ck130 FIND v(dout1_108) AT=70.025n

.meas tran vdout1_109ck130 FIND v(dout1_109) AT=70.025n

.meas tran vdout1_110ck130 FIND v(dout1_110) AT=70.025n

.meas tran vdout1_111ck130 FIND v(dout1_111) AT=70.025n

.meas tran vdout1_112ck130 FIND v(dout1_112) AT=70.025n

.meas tran vdout1_113ck130 FIND v(dout1_113) AT=70.025n

.meas tran vdout1_114ck130 FIND v(dout1_114) AT=70.025n

.meas tran vdout1_115ck130 FIND v(dout1_115) AT=70.025n

.meas tran vdout1_116ck130 FIND v(dout1_116) AT=70.025n

.meas tran vdout1_117ck130 FIND v(dout1_117) AT=70.025n

.meas tran vdout1_118ck130 FIND v(dout1_118) AT=70.025n

.meas tran vdout1_119ck130 FIND v(dout1_119) AT=70.025n

.meas tran vdout1_120ck130 FIND v(dout1_120) AT=70.025n

.meas tran vdout1_121ck130 FIND v(dout1_121) AT=70.025n

.meas tran vdout1_122ck130 FIND v(dout1_122) AT=70.025n

.meas tran vdout1_123ck130 FIND v(dout1_123) AT=70.025n

.meas tran vdout1_124ck130 FIND v(dout1_124) AT=70.025n

.meas tran vdout1_125ck130 FIND v(dout1_125) AT=70.025n

.meas tran vdout1_126ck130 FIND v(dout1_126) AT=70.025n

.meas tran vdout1_127ck130 FIND v(dout1_127) AT=70.025n

.meas tran vdout1_0ck150 FIND v(dout1_0) AT=80.025n

.meas tran vdout1_1ck150 FIND v(dout1_1) AT=80.025n

.meas tran vdout1_2ck150 FIND v(dout1_2) AT=80.025n

.meas tran vdout1_3ck150 FIND v(dout1_3) AT=80.025n

.meas tran vdout1_4ck150 FIND v(dout1_4) AT=80.025n

.meas tran vdout1_5ck150 FIND v(dout1_5) AT=80.025n

.meas tran vdout1_6ck150 FIND v(dout1_6) AT=80.025n

.meas tran vdout1_7ck150 FIND v(dout1_7) AT=80.025n

.meas tran vdout1_8ck150 FIND v(dout1_8) AT=80.025n

.meas tran vdout1_9ck150 FIND v(dout1_9) AT=80.025n

.meas tran vdout1_10ck150 FIND v(dout1_10) AT=80.025n

.meas tran vdout1_11ck150 FIND v(dout1_11) AT=80.025n

.meas tran vdout1_12ck150 FIND v(dout1_12) AT=80.025n

.meas tran vdout1_13ck150 FIND v(dout1_13) AT=80.025n

.meas tran vdout1_14ck150 FIND v(dout1_14) AT=80.025n

.meas tran vdout1_15ck150 FIND v(dout1_15) AT=80.025n

.meas tran vdout1_16ck150 FIND v(dout1_16) AT=80.025n

.meas tran vdout1_17ck150 FIND v(dout1_17) AT=80.025n

.meas tran vdout1_18ck150 FIND v(dout1_18) AT=80.025n

.meas tran vdout1_19ck150 FIND v(dout1_19) AT=80.025n

.meas tran vdout1_20ck150 FIND v(dout1_20) AT=80.025n

.meas tran vdout1_21ck150 FIND v(dout1_21) AT=80.025n

.meas tran vdout1_22ck150 FIND v(dout1_22) AT=80.025n

.meas tran vdout1_23ck150 FIND v(dout1_23) AT=80.025n

.meas tran vdout1_24ck150 FIND v(dout1_24) AT=80.025n

.meas tran vdout1_25ck150 FIND v(dout1_25) AT=80.025n

.meas tran vdout1_26ck150 FIND v(dout1_26) AT=80.025n

.meas tran vdout1_27ck150 FIND v(dout1_27) AT=80.025n

.meas tran vdout1_28ck150 FIND v(dout1_28) AT=80.025n

.meas tran vdout1_29ck150 FIND v(dout1_29) AT=80.025n

.meas tran vdout1_30ck150 FIND v(dout1_30) AT=80.025n

.meas tran vdout1_31ck150 FIND v(dout1_31) AT=80.025n

.meas tran vdout1_32ck150 FIND v(dout1_32) AT=80.025n

.meas tran vdout1_33ck150 FIND v(dout1_33) AT=80.025n

.meas tran vdout1_34ck150 FIND v(dout1_34) AT=80.025n

.meas tran vdout1_35ck150 FIND v(dout1_35) AT=80.025n

.meas tran vdout1_36ck150 FIND v(dout1_36) AT=80.025n

.meas tran vdout1_37ck150 FIND v(dout1_37) AT=80.025n

.meas tran vdout1_38ck150 FIND v(dout1_38) AT=80.025n

.meas tran vdout1_39ck150 FIND v(dout1_39) AT=80.025n

.meas tran vdout1_40ck150 FIND v(dout1_40) AT=80.025n

.meas tran vdout1_41ck150 FIND v(dout1_41) AT=80.025n

.meas tran vdout1_42ck150 FIND v(dout1_42) AT=80.025n

.meas tran vdout1_43ck150 FIND v(dout1_43) AT=80.025n

.meas tran vdout1_44ck150 FIND v(dout1_44) AT=80.025n

.meas tran vdout1_45ck150 FIND v(dout1_45) AT=80.025n

.meas tran vdout1_46ck150 FIND v(dout1_46) AT=80.025n

.meas tran vdout1_47ck150 FIND v(dout1_47) AT=80.025n

.meas tran vdout1_48ck150 FIND v(dout1_48) AT=80.025n

.meas tran vdout1_49ck150 FIND v(dout1_49) AT=80.025n

.meas tran vdout1_50ck150 FIND v(dout1_50) AT=80.025n

.meas tran vdout1_51ck150 FIND v(dout1_51) AT=80.025n

.meas tran vdout1_52ck150 FIND v(dout1_52) AT=80.025n

.meas tran vdout1_53ck150 FIND v(dout1_53) AT=80.025n

.meas tran vdout1_54ck150 FIND v(dout1_54) AT=80.025n

.meas tran vdout1_55ck150 FIND v(dout1_55) AT=80.025n

.meas tran vdout1_56ck150 FIND v(dout1_56) AT=80.025n

.meas tran vdout1_57ck150 FIND v(dout1_57) AT=80.025n

.meas tran vdout1_58ck150 FIND v(dout1_58) AT=80.025n

.meas tran vdout1_59ck150 FIND v(dout1_59) AT=80.025n

.meas tran vdout1_60ck150 FIND v(dout1_60) AT=80.025n

.meas tran vdout1_61ck150 FIND v(dout1_61) AT=80.025n

.meas tran vdout1_62ck150 FIND v(dout1_62) AT=80.025n

.meas tran vdout1_63ck150 FIND v(dout1_63) AT=80.025n

.meas tran vdout1_64ck150 FIND v(dout1_64) AT=80.025n

.meas tran vdout1_65ck150 FIND v(dout1_65) AT=80.025n

.meas tran vdout1_66ck150 FIND v(dout1_66) AT=80.025n

.meas tran vdout1_67ck150 FIND v(dout1_67) AT=80.025n

.meas tran vdout1_68ck150 FIND v(dout1_68) AT=80.025n

.meas tran vdout1_69ck150 FIND v(dout1_69) AT=80.025n

.meas tran vdout1_70ck150 FIND v(dout1_70) AT=80.025n

.meas tran vdout1_71ck150 FIND v(dout1_71) AT=80.025n

.meas tran vdout1_72ck150 FIND v(dout1_72) AT=80.025n

.meas tran vdout1_73ck150 FIND v(dout1_73) AT=80.025n

.meas tran vdout1_74ck150 FIND v(dout1_74) AT=80.025n

.meas tran vdout1_75ck150 FIND v(dout1_75) AT=80.025n

.meas tran vdout1_76ck150 FIND v(dout1_76) AT=80.025n

.meas tran vdout1_77ck150 FIND v(dout1_77) AT=80.025n

.meas tran vdout1_78ck150 FIND v(dout1_78) AT=80.025n

.meas tran vdout1_79ck150 FIND v(dout1_79) AT=80.025n

.meas tran vdout1_80ck150 FIND v(dout1_80) AT=80.025n

.meas tran vdout1_81ck150 FIND v(dout1_81) AT=80.025n

.meas tran vdout1_82ck150 FIND v(dout1_82) AT=80.025n

.meas tran vdout1_83ck150 FIND v(dout1_83) AT=80.025n

.meas tran vdout1_84ck150 FIND v(dout1_84) AT=80.025n

.meas tran vdout1_85ck150 FIND v(dout1_85) AT=80.025n

.meas tran vdout1_86ck150 FIND v(dout1_86) AT=80.025n

.meas tran vdout1_87ck150 FIND v(dout1_87) AT=80.025n

.meas tran vdout1_88ck150 FIND v(dout1_88) AT=80.025n

.meas tran vdout1_89ck150 FIND v(dout1_89) AT=80.025n

.meas tran vdout1_90ck150 FIND v(dout1_90) AT=80.025n

.meas tran vdout1_91ck150 FIND v(dout1_91) AT=80.025n

.meas tran vdout1_92ck150 FIND v(dout1_92) AT=80.025n

.meas tran vdout1_93ck150 FIND v(dout1_93) AT=80.025n

.meas tran vdout1_94ck150 FIND v(dout1_94) AT=80.025n

.meas tran vdout1_95ck150 FIND v(dout1_95) AT=80.025n

.meas tran vdout1_96ck150 FIND v(dout1_96) AT=80.025n

.meas tran vdout1_97ck150 FIND v(dout1_97) AT=80.025n

.meas tran vdout1_98ck150 FIND v(dout1_98) AT=80.025n

.meas tran vdout1_99ck150 FIND v(dout1_99) AT=80.025n

.meas tran vdout1_100ck150 FIND v(dout1_100) AT=80.025n

.meas tran vdout1_101ck150 FIND v(dout1_101) AT=80.025n

.meas tran vdout1_102ck150 FIND v(dout1_102) AT=80.025n

.meas tran vdout1_103ck150 FIND v(dout1_103) AT=80.025n

.meas tran vdout1_104ck150 FIND v(dout1_104) AT=80.025n

.meas tran vdout1_105ck150 FIND v(dout1_105) AT=80.025n

.meas tran vdout1_106ck150 FIND v(dout1_106) AT=80.025n

.meas tran vdout1_107ck150 FIND v(dout1_107) AT=80.025n

.meas tran vdout1_108ck150 FIND v(dout1_108) AT=80.025n

.meas tran vdout1_109ck150 FIND v(dout1_109) AT=80.025n

.meas tran vdout1_110ck150 FIND v(dout1_110) AT=80.025n

.meas tran vdout1_111ck150 FIND v(dout1_111) AT=80.025n

.meas tran vdout1_112ck150 FIND v(dout1_112) AT=80.025n

.meas tran vdout1_113ck150 FIND v(dout1_113) AT=80.025n

.meas tran vdout1_114ck150 FIND v(dout1_114) AT=80.025n

.meas tran vdout1_115ck150 FIND v(dout1_115) AT=80.025n

.meas tran vdout1_116ck150 FIND v(dout1_116) AT=80.025n

.meas tran vdout1_117ck150 FIND v(dout1_117) AT=80.025n

.meas tran vdout1_118ck150 FIND v(dout1_118) AT=80.025n

.meas tran vdout1_119ck150 FIND v(dout1_119) AT=80.025n

.meas tran vdout1_120ck150 FIND v(dout1_120) AT=80.025n

.meas tran vdout1_121ck150 FIND v(dout1_121) AT=80.025n

.meas tran vdout1_122ck150 FIND v(dout1_122) AT=80.025n

.meas tran vdout1_123ck150 FIND v(dout1_123) AT=80.025n

.meas tran vdout1_124ck150 FIND v(dout1_124) AT=80.025n

.meas tran vdout1_125ck150 FIND v(dout1_125) AT=80.025n

.meas tran vdout1_126ck150 FIND v(dout1_126) AT=80.025n

.meas tran vdout1_127ck150 FIND v(dout1_127) AT=80.025n

.meas tran vdout1_0ck190 FIND v(dout1_0) AT=100.025n

.meas tran vdout1_1ck190 FIND v(dout1_1) AT=100.025n

.meas tran vdout1_2ck190 FIND v(dout1_2) AT=100.025n

.meas tran vdout1_3ck190 FIND v(dout1_3) AT=100.025n

.meas tran vdout1_4ck190 FIND v(dout1_4) AT=100.025n

.meas tran vdout1_5ck190 FIND v(dout1_5) AT=100.025n

.meas tran vdout1_6ck190 FIND v(dout1_6) AT=100.025n

.meas tran vdout1_7ck190 FIND v(dout1_7) AT=100.025n

.meas tran vdout1_8ck190 FIND v(dout1_8) AT=100.025n

.meas tran vdout1_9ck190 FIND v(dout1_9) AT=100.025n

.meas tran vdout1_10ck190 FIND v(dout1_10) AT=100.025n

.meas tran vdout1_11ck190 FIND v(dout1_11) AT=100.025n

.meas tran vdout1_12ck190 FIND v(dout1_12) AT=100.025n

.meas tran vdout1_13ck190 FIND v(dout1_13) AT=100.025n

.meas tran vdout1_14ck190 FIND v(dout1_14) AT=100.025n

.meas tran vdout1_15ck190 FIND v(dout1_15) AT=100.025n

.meas tran vdout1_16ck190 FIND v(dout1_16) AT=100.025n

.meas tran vdout1_17ck190 FIND v(dout1_17) AT=100.025n

.meas tran vdout1_18ck190 FIND v(dout1_18) AT=100.025n

.meas tran vdout1_19ck190 FIND v(dout1_19) AT=100.025n

.meas tran vdout1_20ck190 FIND v(dout1_20) AT=100.025n

.meas tran vdout1_21ck190 FIND v(dout1_21) AT=100.025n

.meas tran vdout1_22ck190 FIND v(dout1_22) AT=100.025n

.meas tran vdout1_23ck190 FIND v(dout1_23) AT=100.025n

.meas tran vdout1_24ck190 FIND v(dout1_24) AT=100.025n

.meas tran vdout1_25ck190 FIND v(dout1_25) AT=100.025n

.meas tran vdout1_26ck190 FIND v(dout1_26) AT=100.025n

.meas tran vdout1_27ck190 FIND v(dout1_27) AT=100.025n

.meas tran vdout1_28ck190 FIND v(dout1_28) AT=100.025n

.meas tran vdout1_29ck190 FIND v(dout1_29) AT=100.025n

.meas tran vdout1_30ck190 FIND v(dout1_30) AT=100.025n

.meas tran vdout1_31ck190 FIND v(dout1_31) AT=100.025n

.meas tran vdout1_32ck190 FIND v(dout1_32) AT=100.025n

.meas tran vdout1_33ck190 FIND v(dout1_33) AT=100.025n

.meas tran vdout1_34ck190 FIND v(dout1_34) AT=100.025n

.meas tran vdout1_35ck190 FIND v(dout1_35) AT=100.025n

.meas tran vdout1_36ck190 FIND v(dout1_36) AT=100.025n

.meas tran vdout1_37ck190 FIND v(dout1_37) AT=100.025n

.meas tran vdout1_38ck190 FIND v(dout1_38) AT=100.025n

.meas tran vdout1_39ck190 FIND v(dout1_39) AT=100.025n

.meas tran vdout1_40ck190 FIND v(dout1_40) AT=100.025n

.meas tran vdout1_41ck190 FIND v(dout1_41) AT=100.025n

.meas tran vdout1_42ck190 FIND v(dout1_42) AT=100.025n

.meas tran vdout1_43ck190 FIND v(dout1_43) AT=100.025n

.meas tran vdout1_44ck190 FIND v(dout1_44) AT=100.025n

.meas tran vdout1_45ck190 FIND v(dout1_45) AT=100.025n

.meas tran vdout1_46ck190 FIND v(dout1_46) AT=100.025n

.meas tran vdout1_47ck190 FIND v(dout1_47) AT=100.025n

.meas tran vdout1_48ck190 FIND v(dout1_48) AT=100.025n

.meas tran vdout1_49ck190 FIND v(dout1_49) AT=100.025n

.meas tran vdout1_50ck190 FIND v(dout1_50) AT=100.025n

.meas tran vdout1_51ck190 FIND v(dout1_51) AT=100.025n

.meas tran vdout1_52ck190 FIND v(dout1_52) AT=100.025n

.meas tran vdout1_53ck190 FIND v(dout1_53) AT=100.025n

.meas tran vdout1_54ck190 FIND v(dout1_54) AT=100.025n

.meas tran vdout1_55ck190 FIND v(dout1_55) AT=100.025n

.meas tran vdout1_56ck190 FIND v(dout1_56) AT=100.025n

.meas tran vdout1_57ck190 FIND v(dout1_57) AT=100.025n

.meas tran vdout1_58ck190 FIND v(dout1_58) AT=100.025n

.meas tran vdout1_59ck190 FIND v(dout1_59) AT=100.025n

.meas tran vdout1_60ck190 FIND v(dout1_60) AT=100.025n

.meas tran vdout1_61ck190 FIND v(dout1_61) AT=100.025n

.meas tran vdout1_62ck190 FIND v(dout1_62) AT=100.025n

.meas tran vdout1_63ck190 FIND v(dout1_63) AT=100.025n

.meas tran vdout1_64ck190 FIND v(dout1_64) AT=100.025n

.meas tran vdout1_65ck190 FIND v(dout1_65) AT=100.025n

.meas tran vdout1_66ck190 FIND v(dout1_66) AT=100.025n

.meas tran vdout1_67ck190 FIND v(dout1_67) AT=100.025n

.meas tran vdout1_68ck190 FIND v(dout1_68) AT=100.025n

.meas tran vdout1_69ck190 FIND v(dout1_69) AT=100.025n

.meas tran vdout1_70ck190 FIND v(dout1_70) AT=100.025n

.meas tran vdout1_71ck190 FIND v(dout1_71) AT=100.025n

.meas tran vdout1_72ck190 FIND v(dout1_72) AT=100.025n

.meas tran vdout1_73ck190 FIND v(dout1_73) AT=100.025n

.meas tran vdout1_74ck190 FIND v(dout1_74) AT=100.025n

.meas tran vdout1_75ck190 FIND v(dout1_75) AT=100.025n

.meas tran vdout1_76ck190 FIND v(dout1_76) AT=100.025n

.meas tran vdout1_77ck190 FIND v(dout1_77) AT=100.025n

.meas tran vdout1_78ck190 FIND v(dout1_78) AT=100.025n

.meas tran vdout1_79ck190 FIND v(dout1_79) AT=100.025n

.meas tran vdout1_80ck190 FIND v(dout1_80) AT=100.025n

.meas tran vdout1_81ck190 FIND v(dout1_81) AT=100.025n

.meas tran vdout1_82ck190 FIND v(dout1_82) AT=100.025n

.meas tran vdout1_83ck190 FIND v(dout1_83) AT=100.025n

.meas tran vdout1_84ck190 FIND v(dout1_84) AT=100.025n

.meas tran vdout1_85ck190 FIND v(dout1_85) AT=100.025n

.meas tran vdout1_86ck190 FIND v(dout1_86) AT=100.025n

.meas tran vdout1_87ck190 FIND v(dout1_87) AT=100.025n

.meas tran vdout1_88ck190 FIND v(dout1_88) AT=100.025n

.meas tran vdout1_89ck190 FIND v(dout1_89) AT=100.025n

.meas tran vdout1_90ck190 FIND v(dout1_90) AT=100.025n

.meas tran vdout1_91ck190 FIND v(dout1_91) AT=100.025n

.meas tran vdout1_92ck190 FIND v(dout1_92) AT=100.025n

.meas tran vdout1_93ck190 FIND v(dout1_93) AT=100.025n

.meas tran vdout1_94ck190 FIND v(dout1_94) AT=100.025n

.meas tran vdout1_95ck190 FIND v(dout1_95) AT=100.025n

.meas tran vdout1_96ck190 FIND v(dout1_96) AT=100.025n

.meas tran vdout1_97ck190 FIND v(dout1_97) AT=100.025n

.meas tran vdout1_98ck190 FIND v(dout1_98) AT=100.025n

.meas tran vdout1_99ck190 FIND v(dout1_99) AT=100.025n

.meas tran vdout1_100ck190 FIND v(dout1_100) AT=100.025n

.meas tran vdout1_101ck190 FIND v(dout1_101) AT=100.025n

.meas tran vdout1_102ck190 FIND v(dout1_102) AT=100.025n

.meas tran vdout1_103ck190 FIND v(dout1_103) AT=100.025n

.meas tran vdout1_104ck190 FIND v(dout1_104) AT=100.025n

.meas tran vdout1_105ck190 FIND v(dout1_105) AT=100.025n

.meas tran vdout1_106ck190 FIND v(dout1_106) AT=100.025n

.meas tran vdout1_107ck190 FIND v(dout1_107) AT=100.025n

.meas tran vdout1_108ck190 FIND v(dout1_108) AT=100.025n

.meas tran vdout1_109ck190 FIND v(dout1_109) AT=100.025n

.meas tran vdout1_110ck190 FIND v(dout1_110) AT=100.025n

.meas tran vdout1_111ck190 FIND v(dout1_111) AT=100.025n

.meas tran vdout1_112ck190 FIND v(dout1_112) AT=100.025n

.meas tran vdout1_113ck190 FIND v(dout1_113) AT=100.025n

.meas tran vdout1_114ck190 FIND v(dout1_114) AT=100.025n

.meas tran vdout1_115ck190 FIND v(dout1_115) AT=100.025n

.meas tran vdout1_116ck190 FIND v(dout1_116) AT=100.025n

.meas tran vdout1_117ck190 FIND v(dout1_117) AT=100.025n

.meas tran vdout1_118ck190 FIND v(dout1_118) AT=100.025n

.meas tran vdout1_119ck190 FIND v(dout1_119) AT=100.025n

.meas tran vdout1_120ck190 FIND v(dout1_120) AT=100.025n

.meas tran vdout1_121ck190 FIND v(dout1_121) AT=100.025n

.meas tran vdout1_122ck190 FIND v(dout1_122) AT=100.025n

.meas tran vdout1_123ck190 FIND v(dout1_123) AT=100.025n

.meas tran vdout1_124ck190 FIND v(dout1_124) AT=100.025n

.meas tran vdout1_125ck190 FIND v(dout1_125) AT=100.025n

.meas tran vdout1_126ck190 FIND v(dout1_126) AT=100.025n

.meas tran vdout1_127ck190 FIND v(dout1_127) AT=100.025n

.meas tran vdout1_0ck220 FIND v(dout1_0) AT=115.025n

.meas tran vdout1_1ck220 FIND v(dout1_1) AT=115.025n

.meas tran vdout1_2ck220 FIND v(dout1_2) AT=115.025n

.meas tran vdout1_3ck220 FIND v(dout1_3) AT=115.025n

.meas tran vdout1_4ck220 FIND v(dout1_4) AT=115.025n

.meas tran vdout1_5ck220 FIND v(dout1_5) AT=115.025n

.meas tran vdout1_6ck220 FIND v(dout1_6) AT=115.025n

.meas tran vdout1_7ck220 FIND v(dout1_7) AT=115.025n

.meas tran vdout1_8ck220 FIND v(dout1_8) AT=115.025n

.meas tran vdout1_9ck220 FIND v(dout1_9) AT=115.025n

.meas tran vdout1_10ck220 FIND v(dout1_10) AT=115.025n

.meas tran vdout1_11ck220 FIND v(dout1_11) AT=115.025n

.meas tran vdout1_12ck220 FIND v(dout1_12) AT=115.025n

.meas tran vdout1_13ck220 FIND v(dout1_13) AT=115.025n

.meas tran vdout1_14ck220 FIND v(dout1_14) AT=115.025n

.meas tran vdout1_15ck220 FIND v(dout1_15) AT=115.025n

.meas tran vdout1_16ck220 FIND v(dout1_16) AT=115.025n

.meas tran vdout1_17ck220 FIND v(dout1_17) AT=115.025n

.meas tran vdout1_18ck220 FIND v(dout1_18) AT=115.025n

.meas tran vdout1_19ck220 FIND v(dout1_19) AT=115.025n

.meas tran vdout1_20ck220 FIND v(dout1_20) AT=115.025n

.meas tran vdout1_21ck220 FIND v(dout1_21) AT=115.025n

.meas tran vdout1_22ck220 FIND v(dout1_22) AT=115.025n

.meas tran vdout1_23ck220 FIND v(dout1_23) AT=115.025n

.meas tran vdout1_24ck220 FIND v(dout1_24) AT=115.025n

.meas tran vdout1_25ck220 FIND v(dout1_25) AT=115.025n

.meas tran vdout1_26ck220 FIND v(dout1_26) AT=115.025n

.meas tran vdout1_27ck220 FIND v(dout1_27) AT=115.025n

.meas tran vdout1_28ck220 FIND v(dout1_28) AT=115.025n

.meas tran vdout1_29ck220 FIND v(dout1_29) AT=115.025n

.meas tran vdout1_30ck220 FIND v(dout1_30) AT=115.025n

.meas tran vdout1_31ck220 FIND v(dout1_31) AT=115.025n

.meas tran vdout1_32ck220 FIND v(dout1_32) AT=115.025n

.meas tran vdout1_33ck220 FIND v(dout1_33) AT=115.025n

.meas tran vdout1_34ck220 FIND v(dout1_34) AT=115.025n

.meas tran vdout1_35ck220 FIND v(dout1_35) AT=115.025n

.meas tran vdout1_36ck220 FIND v(dout1_36) AT=115.025n

.meas tran vdout1_37ck220 FIND v(dout1_37) AT=115.025n

.meas tran vdout1_38ck220 FIND v(dout1_38) AT=115.025n

.meas tran vdout1_39ck220 FIND v(dout1_39) AT=115.025n

.meas tran vdout1_40ck220 FIND v(dout1_40) AT=115.025n

.meas tran vdout1_41ck220 FIND v(dout1_41) AT=115.025n

.meas tran vdout1_42ck220 FIND v(dout1_42) AT=115.025n

.meas tran vdout1_43ck220 FIND v(dout1_43) AT=115.025n

.meas tran vdout1_44ck220 FIND v(dout1_44) AT=115.025n

.meas tran vdout1_45ck220 FIND v(dout1_45) AT=115.025n

.meas tran vdout1_46ck220 FIND v(dout1_46) AT=115.025n

.meas tran vdout1_47ck220 FIND v(dout1_47) AT=115.025n

.meas tran vdout1_48ck220 FIND v(dout1_48) AT=115.025n

.meas tran vdout1_49ck220 FIND v(dout1_49) AT=115.025n

.meas tran vdout1_50ck220 FIND v(dout1_50) AT=115.025n

.meas tran vdout1_51ck220 FIND v(dout1_51) AT=115.025n

.meas tran vdout1_52ck220 FIND v(dout1_52) AT=115.025n

.meas tran vdout1_53ck220 FIND v(dout1_53) AT=115.025n

.meas tran vdout1_54ck220 FIND v(dout1_54) AT=115.025n

.meas tran vdout1_55ck220 FIND v(dout1_55) AT=115.025n

.meas tran vdout1_56ck220 FIND v(dout1_56) AT=115.025n

.meas tran vdout1_57ck220 FIND v(dout1_57) AT=115.025n

.meas tran vdout1_58ck220 FIND v(dout1_58) AT=115.025n

.meas tran vdout1_59ck220 FIND v(dout1_59) AT=115.025n

.meas tran vdout1_60ck220 FIND v(dout1_60) AT=115.025n

.meas tran vdout1_61ck220 FIND v(dout1_61) AT=115.025n

.meas tran vdout1_62ck220 FIND v(dout1_62) AT=115.025n

.meas tran vdout1_63ck220 FIND v(dout1_63) AT=115.025n

.meas tran vdout1_64ck220 FIND v(dout1_64) AT=115.025n

.meas tran vdout1_65ck220 FIND v(dout1_65) AT=115.025n

.meas tran vdout1_66ck220 FIND v(dout1_66) AT=115.025n

.meas tran vdout1_67ck220 FIND v(dout1_67) AT=115.025n

.meas tran vdout1_68ck220 FIND v(dout1_68) AT=115.025n

.meas tran vdout1_69ck220 FIND v(dout1_69) AT=115.025n

.meas tran vdout1_70ck220 FIND v(dout1_70) AT=115.025n

.meas tran vdout1_71ck220 FIND v(dout1_71) AT=115.025n

.meas tran vdout1_72ck220 FIND v(dout1_72) AT=115.025n

.meas tran vdout1_73ck220 FIND v(dout1_73) AT=115.025n

.meas tran vdout1_74ck220 FIND v(dout1_74) AT=115.025n

.meas tran vdout1_75ck220 FIND v(dout1_75) AT=115.025n

.meas tran vdout1_76ck220 FIND v(dout1_76) AT=115.025n

.meas tran vdout1_77ck220 FIND v(dout1_77) AT=115.025n

.meas tran vdout1_78ck220 FIND v(dout1_78) AT=115.025n

.meas tran vdout1_79ck220 FIND v(dout1_79) AT=115.025n

.meas tran vdout1_80ck220 FIND v(dout1_80) AT=115.025n

.meas tran vdout1_81ck220 FIND v(dout1_81) AT=115.025n

.meas tran vdout1_82ck220 FIND v(dout1_82) AT=115.025n

.meas tran vdout1_83ck220 FIND v(dout1_83) AT=115.025n

.meas tran vdout1_84ck220 FIND v(dout1_84) AT=115.025n

.meas tran vdout1_85ck220 FIND v(dout1_85) AT=115.025n

.meas tran vdout1_86ck220 FIND v(dout1_86) AT=115.025n

.meas tran vdout1_87ck220 FIND v(dout1_87) AT=115.025n

.meas tran vdout1_88ck220 FIND v(dout1_88) AT=115.025n

.meas tran vdout1_89ck220 FIND v(dout1_89) AT=115.025n

.meas tran vdout1_90ck220 FIND v(dout1_90) AT=115.025n

.meas tran vdout1_91ck220 FIND v(dout1_91) AT=115.025n

.meas tran vdout1_92ck220 FIND v(dout1_92) AT=115.025n

.meas tran vdout1_93ck220 FIND v(dout1_93) AT=115.025n

.meas tran vdout1_94ck220 FIND v(dout1_94) AT=115.025n

.meas tran vdout1_95ck220 FIND v(dout1_95) AT=115.025n

.meas tran vdout1_96ck220 FIND v(dout1_96) AT=115.025n

.meas tran vdout1_97ck220 FIND v(dout1_97) AT=115.025n

.meas tran vdout1_98ck220 FIND v(dout1_98) AT=115.025n

.meas tran vdout1_99ck220 FIND v(dout1_99) AT=115.025n

.meas tran vdout1_100ck220 FIND v(dout1_100) AT=115.025n

.meas tran vdout1_101ck220 FIND v(dout1_101) AT=115.025n

.meas tran vdout1_102ck220 FIND v(dout1_102) AT=115.025n

.meas tran vdout1_103ck220 FIND v(dout1_103) AT=115.025n

.meas tran vdout1_104ck220 FIND v(dout1_104) AT=115.025n

.meas tran vdout1_105ck220 FIND v(dout1_105) AT=115.025n

.meas tran vdout1_106ck220 FIND v(dout1_106) AT=115.025n

.meas tran vdout1_107ck220 FIND v(dout1_107) AT=115.025n

.meas tran vdout1_108ck220 FIND v(dout1_108) AT=115.025n

.meas tran vdout1_109ck220 FIND v(dout1_109) AT=115.025n

.meas tran vdout1_110ck220 FIND v(dout1_110) AT=115.025n

.meas tran vdout1_111ck220 FIND v(dout1_111) AT=115.025n

.meas tran vdout1_112ck220 FIND v(dout1_112) AT=115.025n

.meas tran vdout1_113ck220 FIND v(dout1_113) AT=115.025n

.meas tran vdout1_114ck220 FIND v(dout1_114) AT=115.025n

.meas tran vdout1_115ck220 FIND v(dout1_115) AT=115.025n

.meas tran vdout1_116ck220 FIND v(dout1_116) AT=115.025n

.meas tran vdout1_117ck220 FIND v(dout1_117) AT=115.025n

.meas tran vdout1_118ck220 FIND v(dout1_118) AT=115.025n

.meas tran vdout1_119ck220 FIND v(dout1_119) AT=115.025n

.meas tran vdout1_120ck220 FIND v(dout1_120) AT=115.025n

.meas tran vdout1_121ck220 FIND v(dout1_121) AT=115.025n

.meas tran vdout1_122ck220 FIND v(dout1_122) AT=115.025n

.meas tran vdout1_123ck220 FIND v(dout1_123) AT=115.025n

.meas tran vdout1_124ck220 FIND v(dout1_124) AT=115.025n

.meas tran vdout1_125ck220 FIND v(dout1_125) AT=115.025n

.meas tran vdout1_126ck220 FIND v(dout1_126) AT=115.025n

.meas tran vdout1_127ck220 FIND v(dout1_127) AT=115.025n

.meas tran vdout1_0ck230 FIND v(dout1_0) AT=120.025n

.meas tran vdout1_1ck230 FIND v(dout1_1) AT=120.025n

.meas tran vdout1_2ck230 FIND v(dout1_2) AT=120.025n

.meas tran vdout1_3ck230 FIND v(dout1_3) AT=120.025n

.meas tran vdout1_4ck230 FIND v(dout1_4) AT=120.025n

.meas tran vdout1_5ck230 FIND v(dout1_5) AT=120.025n

.meas tran vdout1_6ck230 FIND v(dout1_6) AT=120.025n

.meas tran vdout1_7ck230 FIND v(dout1_7) AT=120.025n

.meas tran vdout1_8ck230 FIND v(dout1_8) AT=120.025n

.meas tran vdout1_9ck230 FIND v(dout1_9) AT=120.025n

.meas tran vdout1_10ck230 FIND v(dout1_10) AT=120.025n

.meas tran vdout1_11ck230 FIND v(dout1_11) AT=120.025n

.meas tran vdout1_12ck230 FIND v(dout1_12) AT=120.025n

.meas tran vdout1_13ck230 FIND v(dout1_13) AT=120.025n

.meas tran vdout1_14ck230 FIND v(dout1_14) AT=120.025n

.meas tran vdout1_15ck230 FIND v(dout1_15) AT=120.025n

.meas tran vdout1_16ck230 FIND v(dout1_16) AT=120.025n

.meas tran vdout1_17ck230 FIND v(dout1_17) AT=120.025n

.meas tran vdout1_18ck230 FIND v(dout1_18) AT=120.025n

.meas tran vdout1_19ck230 FIND v(dout1_19) AT=120.025n

.meas tran vdout1_20ck230 FIND v(dout1_20) AT=120.025n

.meas tran vdout1_21ck230 FIND v(dout1_21) AT=120.025n

.meas tran vdout1_22ck230 FIND v(dout1_22) AT=120.025n

.meas tran vdout1_23ck230 FIND v(dout1_23) AT=120.025n

.meas tran vdout1_24ck230 FIND v(dout1_24) AT=120.025n

.meas tran vdout1_25ck230 FIND v(dout1_25) AT=120.025n

.meas tran vdout1_26ck230 FIND v(dout1_26) AT=120.025n

.meas tran vdout1_27ck230 FIND v(dout1_27) AT=120.025n

.meas tran vdout1_28ck230 FIND v(dout1_28) AT=120.025n

.meas tran vdout1_29ck230 FIND v(dout1_29) AT=120.025n

.meas tran vdout1_30ck230 FIND v(dout1_30) AT=120.025n

.meas tran vdout1_31ck230 FIND v(dout1_31) AT=120.025n

.meas tran vdout1_32ck230 FIND v(dout1_32) AT=120.025n

.meas tran vdout1_33ck230 FIND v(dout1_33) AT=120.025n

.meas tran vdout1_34ck230 FIND v(dout1_34) AT=120.025n

.meas tran vdout1_35ck230 FIND v(dout1_35) AT=120.025n

.meas tran vdout1_36ck230 FIND v(dout1_36) AT=120.025n

.meas tran vdout1_37ck230 FIND v(dout1_37) AT=120.025n

.meas tran vdout1_38ck230 FIND v(dout1_38) AT=120.025n

.meas tran vdout1_39ck230 FIND v(dout1_39) AT=120.025n

.meas tran vdout1_40ck230 FIND v(dout1_40) AT=120.025n

.meas tran vdout1_41ck230 FIND v(dout1_41) AT=120.025n

.meas tran vdout1_42ck230 FIND v(dout1_42) AT=120.025n

.meas tran vdout1_43ck230 FIND v(dout1_43) AT=120.025n

.meas tran vdout1_44ck230 FIND v(dout1_44) AT=120.025n

.meas tran vdout1_45ck230 FIND v(dout1_45) AT=120.025n

.meas tran vdout1_46ck230 FIND v(dout1_46) AT=120.025n

.meas tran vdout1_47ck230 FIND v(dout1_47) AT=120.025n

.meas tran vdout1_48ck230 FIND v(dout1_48) AT=120.025n

.meas tran vdout1_49ck230 FIND v(dout1_49) AT=120.025n

.meas tran vdout1_50ck230 FIND v(dout1_50) AT=120.025n

.meas tran vdout1_51ck230 FIND v(dout1_51) AT=120.025n

.meas tran vdout1_52ck230 FIND v(dout1_52) AT=120.025n

.meas tran vdout1_53ck230 FIND v(dout1_53) AT=120.025n

.meas tran vdout1_54ck230 FIND v(dout1_54) AT=120.025n

.meas tran vdout1_55ck230 FIND v(dout1_55) AT=120.025n

.meas tran vdout1_56ck230 FIND v(dout1_56) AT=120.025n

.meas tran vdout1_57ck230 FIND v(dout1_57) AT=120.025n

.meas tran vdout1_58ck230 FIND v(dout1_58) AT=120.025n

.meas tran vdout1_59ck230 FIND v(dout1_59) AT=120.025n

.meas tran vdout1_60ck230 FIND v(dout1_60) AT=120.025n

.meas tran vdout1_61ck230 FIND v(dout1_61) AT=120.025n

.meas tran vdout1_62ck230 FIND v(dout1_62) AT=120.025n

.meas tran vdout1_63ck230 FIND v(dout1_63) AT=120.025n

.meas tran vdout1_64ck230 FIND v(dout1_64) AT=120.025n

.meas tran vdout1_65ck230 FIND v(dout1_65) AT=120.025n

.meas tran vdout1_66ck230 FIND v(dout1_66) AT=120.025n

.meas tran vdout1_67ck230 FIND v(dout1_67) AT=120.025n

.meas tran vdout1_68ck230 FIND v(dout1_68) AT=120.025n

.meas tran vdout1_69ck230 FIND v(dout1_69) AT=120.025n

.meas tran vdout1_70ck230 FIND v(dout1_70) AT=120.025n

.meas tran vdout1_71ck230 FIND v(dout1_71) AT=120.025n

.meas tran vdout1_72ck230 FIND v(dout1_72) AT=120.025n

.meas tran vdout1_73ck230 FIND v(dout1_73) AT=120.025n

.meas tran vdout1_74ck230 FIND v(dout1_74) AT=120.025n

.meas tran vdout1_75ck230 FIND v(dout1_75) AT=120.025n

.meas tran vdout1_76ck230 FIND v(dout1_76) AT=120.025n

.meas tran vdout1_77ck230 FIND v(dout1_77) AT=120.025n

.meas tran vdout1_78ck230 FIND v(dout1_78) AT=120.025n

.meas tran vdout1_79ck230 FIND v(dout1_79) AT=120.025n

.meas tran vdout1_80ck230 FIND v(dout1_80) AT=120.025n

.meas tran vdout1_81ck230 FIND v(dout1_81) AT=120.025n

.meas tran vdout1_82ck230 FIND v(dout1_82) AT=120.025n

.meas tran vdout1_83ck230 FIND v(dout1_83) AT=120.025n

.meas tran vdout1_84ck230 FIND v(dout1_84) AT=120.025n

.meas tran vdout1_85ck230 FIND v(dout1_85) AT=120.025n

.meas tran vdout1_86ck230 FIND v(dout1_86) AT=120.025n

.meas tran vdout1_87ck230 FIND v(dout1_87) AT=120.025n

.meas tran vdout1_88ck230 FIND v(dout1_88) AT=120.025n

.meas tran vdout1_89ck230 FIND v(dout1_89) AT=120.025n

.meas tran vdout1_90ck230 FIND v(dout1_90) AT=120.025n

.meas tran vdout1_91ck230 FIND v(dout1_91) AT=120.025n

.meas tran vdout1_92ck230 FIND v(dout1_92) AT=120.025n

.meas tran vdout1_93ck230 FIND v(dout1_93) AT=120.025n

.meas tran vdout1_94ck230 FIND v(dout1_94) AT=120.025n

.meas tran vdout1_95ck230 FIND v(dout1_95) AT=120.025n

.meas tran vdout1_96ck230 FIND v(dout1_96) AT=120.025n

.meas tran vdout1_97ck230 FIND v(dout1_97) AT=120.025n

.meas tran vdout1_98ck230 FIND v(dout1_98) AT=120.025n

.meas tran vdout1_99ck230 FIND v(dout1_99) AT=120.025n

.meas tran vdout1_100ck230 FIND v(dout1_100) AT=120.025n

.meas tran vdout1_101ck230 FIND v(dout1_101) AT=120.025n

.meas tran vdout1_102ck230 FIND v(dout1_102) AT=120.025n

.meas tran vdout1_103ck230 FIND v(dout1_103) AT=120.025n

.meas tran vdout1_104ck230 FIND v(dout1_104) AT=120.025n

.meas tran vdout1_105ck230 FIND v(dout1_105) AT=120.025n

.meas tran vdout1_106ck230 FIND v(dout1_106) AT=120.025n

.meas tran vdout1_107ck230 FIND v(dout1_107) AT=120.025n

.meas tran vdout1_108ck230 FIND v(dout1_108) AT=120.025n

.meas tran vdout1_109ck230 FIND v(dout1_109) AT=120.025n

.meas tran vdout1_110ck230 FIND v(dout1_110) AT=120.025n

.meas tran vdout1_111ck230 FIND v(dout1_111) AT=120.025n

.meas tran vdout1_112ck230 FIND v(dout1_112) AT=120.025n

.meas tran vdout1_113ck230 FIND v(dout1_113) AT=120.025n

.meas tran vdout1_114ck230 FIND v(dout1_114) AT=120.025n

.meas tran vdout1_115ck230 FIND v(dout1_115) AT=120.025n

.meas tran vdout1_116ck230 FIND v(dout1_116) AT=120.025n

.meas tran vdout1_117ck230 FIND v(dout1_117) AT=120.025n

.meas tran vdout1_118ck230 FIND v(dout1_118) AT=120.025n

.meas tran vdout1_119ck230 FIND v(dout1_119) AT=120.025n

.meas tran vdout1_120ck230 FIND v(dout1_120) AT=120.025n

.meas tran vdout1_121ck230 FIND v(dout1_121) AT=120.025n

.meas tran vdout1_122ck230 FIND v(dout1_122) AT=120.025n

.meas tran vdout1_123ck230 FIND v(dout1_123) AT=120.025n

.meas tran vdout1_124ck230 FIND v(dout1_124) AT=120.025n

.meas tran vdout1_125ck230 FIND v(dout1_125) AT=120.025n

.meas tran vdout1_126ck230 FIND v(dout1_126) AT=120.025n

.meas tran vdout1_127ck230 FIND v(dout1_127) AT=120.025n

.meas tran vdout1_0ck290 FIND v(dout1_0) AT=150.025n

.meas tran vdout1_1ck290 FIND v(dout1_1) AT=150.025n

.meas tran vdout1_2ck290 FIND v(dout1_2) AT=150.025n

.meas tran vdout1_3ck290 FIND v(dout1_3) AT=150.025n

.meas tran vdout1_4ck290 FIND v(dout1_4) AT=150.025n

.meas tran vdout1_5ck290 FIND v(dout1_5) AT=150.025n

.meas tran vdout1_6ck290 FIND v(dout1_6) AT=150.025n

.meas tran vdout1_7ck290 FIND v(dout1_7) AT=150.025n

.meas tran vdout1_8ck290 FIND v(dout1_8) AT=150.025n

.meas tran vdout1_9ck290 FIND v(dout1_9) AT=150.025n

.meas tran vdout1_10ck290 FIND v(dout1_10) AT=150.025n

.meas tran vdout1_11ck290 FIND v(dout1_11) AT=150.025n

.meas tran vdout1_12ck290 FIND v(dout1_12) AT=150.025n

.meas tran vdout1_13ck290 FIND v(dout1_13) AT=150.025n

.meas tran vdout1_14ck290 FIND v(dout1_14) AT=150.025n

.meas tran vdout1_15ck290 FIND v(dout1_15) AT=150.025n

.meas tran vdout1_16ck290 FIND v(dout1_16) AT=150.025n

.meas tran vdout1_17ck290 FIND v(dout1_17) AT=150.025n

.meas tran vdout1_18ck290 FIND v(dout1_18) AT=150.025n

.meas tran vdout1_19ck290 FIND v(dout1_19) AT=150.025n

.meas tran vdout1_20ck290 FIND v(dout1_20) AT=150.025n

.meas tran vdout1_21ck290 FIND v(dout1_21) AT=150.025n

.meas tran vdout1_22ck290 FIND v(dout1_22) AT=150.025n

.meas tran vdout1_23ck290 FIND v(dout1_23) AT=150.025n

.meas tran vdout1_24ck290 FIND v(dout1_24) AT=150.025n

.meas tran vdout1_25ck290 FIND v(dout1_25) AT=150.025n

.meas tran vdout1_26ck290 FIND v(dout1_26) AT=150.025n

.meas tran vdout1_27ck290 FIND v(dout1_27) AT=150.025n

.meas tran vdout1_28ck290 FIND v(dout1_28) AT=150.025n

.meas tran vdout1_29ck290 FIND v(dout1_29) AT=150.025n

.meas tran vdout1_30ck290 FIND v(dout1_30) AT=150.025n

.meas tran vdout1_31ck290 FIND v(dout1_31) AT=150.025n

.meas tran vdout1_32ck290 FIND v(dout1_32) AT=150.025n

.meas tran vdout1_33ck290 FIND v(dout1_33) AT=150.025n

.meas tran vdout1_34ck290 FIND v(dout1_34) AT=150.025n

.meas tran vdout1_35ck290 FIND v(dout1_35) AT=150.025n

.meas tran vdout1_36ck290 FIND v(dout1_36) AT=150.025n

.meas tran vdout1_37ck290 FIND v(dout1_37) AT=150.025n

.meas tran vdout1_38ck290 FIND v(dout1_38) AT=150.025n

.meas tran vdout1_39ck290 FIND v(dout1_39) AT=150.025n

.meas tran vdout1_40ck290 FIND v(dout1_40) AT=150.025n

.meas tran vdout1_41ck290 FIND v(dout1_41) AT=150.025n

.meas tran vdout1_42ck290 FIND v(dout1_42) AT=150.025n

.meas tran vdout1_43ck290 FIND v(dout1_43) AT=150.025n

.meas tran vdout1_44ck290 FIND v(dout1_44) AT=150.025n

.meas tran vdout1_45ck290 FIND v(dout1_45) AT=150.025n

.meas tran vdout1_46ck290 FIND v(dout1_46) AT=150.025n

.meas tran vdout1_47ck290 FIND v(dout1_47) AT=150.025n

.meas tran vdout1_48ck290 FIND v(dout1_48) AT=150.025n

.meas tran vdout1_49ck290 FIND v(dout1_49) AT=150.025n

.meas tran vdout1_50ck290 FIND v(dout1_50) AT=150.025n

.meas tran vdout1_51ck290 FIND v(dout1_51) AT=150.025n

.meas tran vdout1_52ck290 FIND v(dout1_52) AT=150.025n

.meas tran vdout1_53ck290 FIND v(dout1_53) AT=150.025n

.meas tran vdout1_54ck290 FIND v(dout1_54) AT=150.025n

.meas tran vdout1_55ck290 FIND v(dout1_55) AT=150.025n

.meas tran vdout1_56ck290 FIND v(dout1_56) AT=150.025n

.meas tran vdout1_57ck290 FIND v(dout1_57) AT=150.025n

.meas tran vdout1_58ck290 FIND v(dout1_58) AT=150.025n

.meas tran vdout1_59ck290 FIND v(dout1_59) AT=150.025n

.meas tran vdout1_60ck290 FIND v(dout1_60) AT=150.025n

.meas tran vdout1_61ck290 FIND v(dout1_61) AT=150.025n

.meas tran vdout1_62ck290 FIND v(dout1_62) AT=150.025n

.meas tran vdout1_63ck290 FIND v(dout1_63) AT=150.025n

.meas tran vdout1_64ck290 FIND v(dout1_64) AT=150.025n

.meas tran vdout1_65ck290 FIND v(dout1_65) AT=150.025n

.meas tran vdout1_66ck290 FIND v(dout1_66) AT=150.025n

.meas tran vdout1_67ck290 FIND v(dout1_67) AT=150.025n

.meas tran vdout1_68ck290 FIND v(dout1_68) AT=150.025n

.meas tran vdout1_69ck290 FIND v(dout1_69) AT=150.025n

.meas tran vdout1_70ck290 FIND v(dout1_70) AT=150.025n

.meas tran vdout1_71ck290 FIND v(dout1_71) AT=150.025n

.meas tran vdout1_72ck290 FIND v(dout1_72) AT=150.025n

.meas tran vdout1_73ck290 FIND v(dout1_73) AT=150.025n

.meas tran vdout1_74ck290 FIND v(dout1_74) AT=150.025n

.meas tran vdout1_75ck290 FIND v(dout1_75) AT=150.025n

.meas tran vdout1_76ck290 FIND v(dout1_76) AT=150.025n

.meas tran vdout1_77ck290 FIND v(dout1_77) AT=150.025n

.meas tran vdout1_78ck290 FIND v(dout1_78) AT=150.025n

.meas tran vdout1_79ck290 FIND v(dout1_79) AT=150.025n

.meas tran vdout1_80ck290 FIND v(dout1_80) AT=150.025n

.meas tran vdout1_81ck290 FIND v(dout1_81) AT=150.025n

.meas tran vdout1_82ck290 FIND v(dout1_82) AT=150.025n

.meas tran vdout1_83ck290 FIND v(dout1_83) AT=150.025n

.meas tran vdout1_84ck290 FIND v(dout1_84) AT=150.025n

.meas tran vdout1_85ck290 FIND v(dout1_85) AT=150.025n

.meas tran vdout1_86ck290 FIND v(dout1_86) AT=150.025n

.meas tran vdout1_87ck290 FIND v(dout1_87) AT=150.025n

.meas tran vdout1_88ck290 FIND v(dout1_88) AT=150.025n

.meas tran vdout1_89ck290 FIND v(dout1_89) AT=150.025n

.meas tran vdout1_90ck290 FIND v(dout1_90) AT=150.025n

.meas tran vdout1_91ck290 FIND v(dout1_91) AT=150.025n

.meas tran vdout1_92ck290 FIND v(dout1_92) AT=150.025n

.meas tran vdout1_93ck290 FIND v(dout1_93) AT=150.025n

.meas tran vdout1_94ck290 FIND v(dout1_94) AT=150.025n

.meas tran vdout1_95ck290 FIND v(dout1_95) AT=150.025n

.meas tran vdout1_96ck290 FIND v(dout1_96) AT=150.025n

.meas tran vdout1_97ck290 FIND v(dout1_97) AT=150.025n

.meas tran vdout1_98ck290 FIND v(dout1_98) AT=150.025n

.meas tran vdout1_99ck290 FIND v(dout1_99) AT=150.025n

.meas tran vdout1_100ck290 FIND v(dout1_100) AT=150.025n

.meas tran vdout1_101ck290 FIND v(dout1_101) AT=150.025n

.meas tran vdout1_102ck290 FIND v(dout1_102) AT=150.025n

.meas tran vdout1_103ck290 FIND v(dout1_103) AT=150.025n

.meas tran vdout1_104ck290 FIND v(dout1_104) AT=150.025n

.meas tran vdout1_105ck290 FIND v(dout1_105) AT=150.025n

.meas tran vdout1_106ck290 FIND v(dout1_106) AT=150.025n

.meas tran vdout1_107ck290 FIND v(dout1_107) AT=150.025n

.meas tran vdout1_108ck290 FIND v(dout1_108) AT=150.025n

.meas tran vdout1_109ck290 FIND v(dout1_109) AT=150.025n

.meas tran vdout1_110ck290 FIND v(dout1_110) AT=150.025n

.meas tran vdout1_111ck290 FIND v(dout1_111) AT=150.025n

.meas tran vdout1_112ck290 FIND v(dout1_112) AT=150.025n

.meas tran vdout1_113ck290 FIND v(dout1_113) AT=150.025n

.meas tran vdout1_114ck290 FIND v(dout1_114) AT=150.025n

.meas tran vdout1_115ck290 FIND v(dout1_115) AT=150.025n

.meas tran vdout1_116ck290 FIND v(dout1_116) AT=150.025n

.meas tran vdout1_117ck290 FIND v(dout1_117) AT=150.025n

.meas tran vdout1_118ck290 FIND v(dout1_118) AT=150.025n

.meas tran vdout1_119ck290 FIND v(dout1_119) AT=150.025n

.meas tran vdout1_120ck290 FIND v(dout1_120) AT=150.025n

.meas tran vdout1_121ck290 FIND v(dout1_121) AT=150.025n

.meas tran vdout1_122ck290 FIND v(dout1_122) AT=150.025n

.meas tran vdout1_123ck290 FIND v(dout1_123) AT=150.025n

.meas tran vdout1_124ck290 FIND v(dout1_124) AT=150.025n

.meas tran vdout1_125ck290 FIND v(dout1_125) AT=150.025n

.meas tran vdout1_126ck290 FIND v(dout1_126) AT=150.025n

.meas tran vdout1_127ck290 FIND v(dout1_127) AT=150.025n

.meas tran vdout1_0ck300 FIND v(dout1_0) AT=155.025n

.meas tran vdout1_1ck300 FIND v(dout1_1) AT=155.025n

.meas tran vdout1_2ck300 FIND v(dout1_2) AT=155.025n

.meas tran vdout1_3ck300 FIND v(dout1_3) AT=155.025n

.meas tran vdout1_4ck300 FIND v(dout1_4) AT=155.025n

.meas tran vdout1_5ck300 FIND v(dout1_5) AT=155.025n

.meas tran vdout1_6ck300 FIND v(dout1_6) AT=155.025n

.meas tran vdout1_7ck300 FIND v(dout1_7) AT=155.025n

.meas tran vdout1_8ck300 FIND v(dout1_8) AT=155.025n

.meas tran vdout1_9ck300 FIND v(dout1_9) AT=155.025n

.meas tran vdout1_10ck300 FIND v(dout1_10) AT=155.025n

.meas tran vdout1_11ck300 FIND v(dout1_11) AT=155.025n

.meas tran vdout1_12ck300 FIND v(dout1_12) AT=155.025n

.meas tran vdout1_13ck300 FIND v(dout1_13) AT=155.025n

.meas tran vdout1_14ck300 FIND v(dout1_14) AT=155.025n

.meas tran vdout1_15ck300 FIND v(dout1_15) AT=155.025n

.meas tran vdout1_16ck300 FIND v(dout1_16) AT=155.025n

.meas tran vdout1_17ck300 FIND v(dout1_17) AT=155.025n

.meas tran vdout1_18ck300 FIND v(dout1_18) AT=155.025n

.meas tran vdout1_19ck300 FIND v(dout1_19) AT=155.025n

.meas tran vdout1_20ck300 FIND v(dout1_20) AT=155.025n

.meas tran vdout1_21ck300 FIND v(dout1_21) AT=155.025n

.meas tran vdout1_22ck300 FIND v(dout1_22) AT=155.025n

.meas tran vdout1_23ck300 FIND v(dout1_23) AT=155.025n

.meas tran vdout1_24ck300 FIND v(dout1_24) AT=155.025n

.meas tran vdout1_25ck300 FIND v(dout1_25) AT=155.025n

.meas tran vdout1_26ck300 FIND v(dout1_26) AT=155.025n

.meas tran vdout1_27ck300 FIND v(dout1_27) AT=155.025n

.meas tran vdout1_28ck300 FIND v(dout1_28) AT=155.025n

.meas tran vdout1_29ck300 FIND v(dout1_29) AT=155.025n

.meas tran vdout1_30ck300 FIND v(dout1_30) AT=155.025n

.meas tran vdout1_31ck300 FIND v(dout1_31) AT=155.025n

.meas tran vdout1_32ck300 FIND v(dout1_32) AT=155.025n

.meas tran vdout1_33ck300 FIND v(dout1_33) AT=155.025n

.meas tran vdout1_34ck300 FIND v(dout1_34) AT=155.025n

.meas tran vdout1_35ck300 FIND v(dout1_35) AT=155.025n

.meas tran vdout1_36ck300 FIND v(dout1_36) AT=155.025n

.meas tran vdout1_37ck300 FIND v(dout1_37) AT=155.025n

.meas tran vdout1_38ck300 FIND v(dout1_38) AT=155.025n

.meas tran vdout1_39ck300 FIND v(dout1_39) AT=155.025n

.meas tran vdout1_40ck300 FIND v(dout1_40) AT=155.025n

.meas tran vdout1_41ck300 FIND v(dout1_41) AT=155.025n

.meas tran vdout1_42ck300 FIND v(dout1_42) AT=155.025n

.meas tran vdout1_43ck300 FIND v(dout1_43) AT=155.025n

.meas tran vdout1_44ck300 FIND v(dout1_44) AT=155.025n

.meas tran vdout1_45ck300 FIND v(dout1_45) AT=155.025n

.meas tran vdout1_46ck300 FIND v(dout1_46) AT=155.025n

.meas tran vdout1_47ck300 FIND v(dout1_47) AT=155.025n

.meas tran vdout1_48ck300 FIND v(dout1_48) AT=155.025n

.meas tran vdout1_49ck300 FIND v(dout1_49) AT=155.025n

.meas tran vdout1_50ck300 FIND v(dout1_50) AT=155.025n

.meas tran vdout1_51ck300 FIND v(dout1_51) AT=155.025n

.meas tran vdout1_52ck300 FIND v(dout1_52) AT=155.025n

.meas tran vdout1_53ck300 FIND v(dout1_53) AT=155.025n

.meas tran vdout1_54ck300 FIND v(dout1_54) AT=155.025n

.meas tran vdout1_55ck300 FIND v(dout1_55) AT=155.025n

.meas tran vdout1_56ck300 FIND v(dout1_56) AT=155.025n

.meas tran vdout1_57ck300 FIND v(dout1_57) AT=155.025n

.meas tran vdout1_58ck300 FIND v(dout1_58) AT=155.025n

.meas tran vdout1_59ck300 FIND v(dout1_59) AT=155.025n

.meas tran vdout1_60ck300 FIND v(dout1_60) AT=155.025n

.meas tran vdout1_61ck300 FIND v(dout1_61) AT=155.025n

.meas tran vdout1_62ck300 FIND v(dout1_62) AT=155.025n

.meas tran vdout1_63ck300 FIND v(dout1_63) AT=155.025n

.meas tran vdout1_64ck300 FIND v(dout1_64) AT=155.025n

.meas tran vdout1_65ck300 FIND v(dout1_65) AT=155.025n

.meas tran vdout1_66ck300 FIND v(dout1_66) AT=155.025n

.meas tran vdout1_67ck300 FIND v(dout1_67) AT=155.025n

.meas tran vdout1_68ck300 FIND v(dout1_68) AT=155.025n

.meas tran vdout1_69ck300 FIND v(dout1_69) AT=155.025n

.meas tran vdout1_70ck300 FIND v(dout1_70) AT=155.025n

.meas tran vdout1_71ck300 FIND v(dout1_71) AT=155.025n

.meas tran vdout1_72ck300 FIND v(dout1_72) AT=155.025n

.meas tran vdout1_73ck300 FIND v(dout1_73) AT=155.025n

.meas tran vdout1_74ck300 FIND v(dout1_74) AT=155.025n

.meas tran vdout1_75ck300 FIND v(dout1_75) AT=155.025n

.meas tran vdout1_76ck300 FIND v(dout1_76) AT=155.025n

.meas tran vdout1_77ck300 FIND v(dout1_77) AT=155.025n

.meas tran vdout1_78ck300 FIND v(dout1_78) AT=155.025n

.meas tran vdout1_79ck300 FIND v(dout1_79) AT=155.025n

.meas tran vdout1_80ck300 FIND v(dout1_80) AT=155.025n

.meas tran vdout1_81ck300 FIND v(dout1_81) AT=155.025n

.meas tran vdout1_82ck300 FIND v(dout1_82) AT=155.025n

.meas tran vdout1_83ck300 FIND v(dout1_83) AT=155.025n

.meas tran vdout1_84ck300 FIND v(dout1_84) AT=155.025n

.meas tran vdout1_85ck300 FIND v(dout1_85) AT=155.025n

.meas tran vdout1_86ck300 FIND v(dout1_86) AT=155.025n

.meas tran vdout1_87ck300 FIND v(dout1_87) AT=155.025n

.meas tran vdout1_88ck300 FIND v(dout1_88) AT=155.025n

.meas tran vdout1_89ck300 FIND v(dout1_89) AT=155.025n

.meas tran vdout1_90ck300 FIND v(dout1_90) AT=155.025n

.meas tran vdout1_91ck300 FIND v(dout1_91) AT=155.025n

.meas tran vdout1_92ck300 FIND v(dout1_92) AT=155.025n

.meas tran vdout1_93ck300 FIND v(dout1_93) AT=155.025n

.meas tran vdout1_94ck300 FIND v(dout1_94) AT=155.025n

.meas tran vdout1_95ck300 FIND v(dout1_95) AT=155.025n

.meas tran vdout1_96ck300 FIND v(dout1_96) AT=155.025n

.meas tran vdout1_97ck300 FIND v(dout1_97) AT=155.025n

.meas tran vdout1_98ck300 FIND v(dout1_98) AT=155.025n

.meas tran vdout1_99ck300 FIND v(dout1_99) AT=155.025n

.meas tran vdout1_100ck300 FIND v(dout1_100) AT=155.025n

.meas tran vdout1_101ck300 FIND v(dout1_101) AT=155.025n

.meas tran vdout1_102ck300 FIND v(dout1_102) AT=155.025n

.meas tran vdout1_103ck300 FIND v(dout1_103) AT=155.025n

.meas tran vdout1_104ck300 FIND v(dout1_104) AT=155.025n

.meas tran vdout1_105ck300 FIND v(dout1_105) AT=155.025n

.meas tran vdout1_106ck300 FIND v(dout1_106) AT=155.025n

.meas tran vdout1_107ck300 FIND v(dout1_107) AT=155.025n

.meas tran vdout1_108ck300 FIND v(dout1_108) AT=155.025n

.meas tran vdout1_109ck300 FIND v(dout1_109) AT=155.025n

.meas tran vdout1_110ck300 FIND v(dout1_110) AT=155.025n

.meas tran vdout1_111ck300 FIND v(dout1_111) AT=155.025n

.meas tran vdout1_112ck300 FIND v(dout1_112) AT=155.025n

.meas tran vdout1_113ck300 FIND v(dout1_113) AT=155.025n

.meas tran vdout1_114ck300 FIND v(dout1_114) AT=155.025n

.meas tran vdout1_115ck300 FIND v(dout1_115) AT=155.025n

.meas tran vdout1_116ck300 FIND v(dout1_116) AT=155.025n

.meas tran vdout1_117ck300 FIND v(dout1_117) AT=155.025n

.meas tran vdout1_118ck300 FIND v(dout1_118) AT=155.025n

.meas tran vdout1_119ck300 FIND v(dout1_119) AT=155.025n

.meas tran vdout1_120ck300 FIND v(dout1_120) AT=155.025n

.meas tran vdout1_121ck300 FIND v(dout1_121) AT=155.025n

.meas tran vdout1_122ck300 FIND v(dout1_122) AT=155.025n

.meas tran vdout1_123ck300 FIND v(dout1_123) AT=155.025n

.meas tran vdout1_124ck300 FIND v(dout1_124) AT=155.025n

.meas tran vdout1_125ck300 FIND v(dout1_125) AT=155.025n

.meas tran vdout1_126ck300 FIND v(dout1_126) AT=155.025n

.meas tran vdout1_127ck300 FIND v(dout1_127) AT=155.025n

.meas tran vdout1_0ck330 FIND v(dout1_0) AT=170.025n

.meas tran vdout1_1ck330 FIND v(dout1_1) AT=170.025n

.meas tran vdout1_2ck330 FIND v(dout1_2) AT=170.025n

.meas tran vdout1_3ck330 FIND v(dout1_3) AT=170.025n

.meas tran vdout1_4ck330 FIND v(dout1_4) AT=170.025n

.meas tran vdout1_5ck330 FIND v(dout1_5) AT=170.025n

.meas tran vdout1_6ck330 FIND v(dout1_6) AT=170.025n

.meas tran vdout1_7ck330 FIND v(dout1_7) AT=170.025n

.meas tran vdout1_8ck330 FIND v(dout1_8) AT=170.025n

.meas tran vdout1_9ck330 FIND v(dout1_9) AT=170.025n

.meas tran vdout1_10ck330 FIND v(dout1_10) AT=170.025n

.meas tran vdout1_11ck330 FIND v(dout1_11) AT=170.025n

.meas tran vdout1_12ck330 FIND v(dout1_12) AT=170.025n

.meas tran vdout1_13ck330 FIND v(dout1_13) AT=170.025n

.meas tran vdout1_14ck330 FIND v(dout1_14) AT=170.025n

.meas tran vdout1_15ck330 FIND v(dout1_15) AT=170.025n

.meas tran vdout1_16ck330 FIND v(dout1_16) AT=170.025n

.meas tran vdout1_17ck330 FIND v(dout1_17) AT=170.025n

.meas tran vdout1_18ck330 FIND v(dout1_18) AT=170.025n

.meas tran vdout1_19ck330 FIND v(dout1_19) AT=170.025n

.meas tran vdout1_20ck330 FIND v(dout1_20) AT=170.025n

.meas tran vdout1_21ck330 FIND v(dout1_21) AT=170.025n

.meas tran vdout1_22ck330 FIND v(dout1_22) AT=170.025n

.meas tran vdout1_23ck330 FIND v(dout1_23) AT=170.025n

.meas tran vdout1_24ck330 FIND v(dout1_24) AT=170.025n

.meas tran vdout1_25ck330 FIND v(dout1_25) AT=170.025n

.meas tran vdout1_26ck330 FIND v(dout1_26) AT=170.025n

.meas tran vdout1_27ck330 FIND v(dout1_27) AT=170.025n

.meas tran vdout1_28ck330 FIND v(dout1_28) AT=170.025n

.meas tran vdout1_29ck330 FIND v(dout1_29) AT=170.025n

.meas tran vdout1_30ck330 FIND v(dout1_30) AT=170.025n

.meas tran vdout1_31ck330 FIND v(dout1_31) AT=170.025n

.meas tran vdout1_32ck330 FIND v(dout1_32) AT=170.025n

.meas tran vdout1_33ck330 FIND v(dout1_33) AT=170.025n

.meas tran vdout1_34ck330 FIND v(dout1_34) AT=170.025n

.meas tran vdout1_35ck330 FIND v(dout1_35) AT=170.025n

.meas tran vdout1_36ck330 FIND v(dout1_36) AT=170.025n

.meas tran vdout1_37ck330 FIND v(dout1_37) AT=170.025n

.meas tran vdout1_38ck330 FIND v(dout1_38) AT=170.025n

.meas tran vdout1_39ck330 FIND v(dout1_39) AT=170.025n

.meas tran vdout1_40ck330 FIND v(dout1_40) AT=170.025n

.meas tran vdout1_41ck330 FIND v(dout1_41) AT=170.025n

.meas tran vdout1_42ck330 FIND v(dout1_42) AT=170.025n

.meas tran vdout1_43ck330 FIND v(dout1_43) AT=170.025n

.meas tran vdout1_44ck330 FIND v(dout1_44) AT=170.025n

.meas tran vdout1_45ck330 FIND v(dout1_45) AT=170.025n

.meas tran vdout1_46ck330 FIND v(dout1_46) AT=170.025n

.meas tran vdout1_47ck330 FIND v(dout1_47) AT=170.025n

.meas tran vdout1_48ck330 FIND v(dout1_48) AT=170.025n

.meas tran vdout1_49ck330 FIND v(dout1_49) AT=170.025n

.meas tran vdout1_50ck330 FIND v(dout1_50) AT=170.025n

.meas tran vdout1_51ck330 FIND v(dout1_51) AT=170.025n

.meas tran vdout1_52ck330 FIND v(dout1_52) AT=170.025n

.meas tran vdout1_53ck330 FIND v(dout1_53) AT=170.025n

.meas tran vdout1_54ck330 FIND v(dout1_54) AT=170.025n

.meas tran vdout1_55ck330 FIND v(dout1_55) AT=170.025n

.meas tran vdout1_56ck330 FIND v(dout1_56) AT=170.025n

.meas tran vdout1_57ck330 FIND v(dout1_57) AT=170.025n

.meas tran vdout1_58ck330 FIND v(dout1_58) AT=170.025n

.meas tran vdout1_59ck330 FIND v(dout1_59) AT=170.025n

.meas tran vdout1_60ck330 FIND v(dout1_60) AT=170.025n

.meas tran vdout1_61ck330 FIND v(dout1_61) AT=170.025n

.meas tran vdout1_62ck330 FIND v(dout1_62) AT=170.025n

.meas tran vdout1_63ck330 FIND v(dout1_63) AT=170.025n

.meas tran vdout1_64ck330 FIND v(dout1_64) AT=170.025n

.meas tran vdout1_65ck330 FIND v(dout1_65) AT=170.025n

.meas tran vdout1_66ck330 FIND v(dout1_66) AT=170.025n

.meas tran vdout1_67ck330 FIND v(dout1_67) AT=170.025n

.meas tran vdout1_68ck330 FIND v(dout1_68) AT=170.025n

.meas tran vdout1_69ck330 FIND v(dout1_69) AT=170.025n

.meas tran vdout1_70ck330 FIND v(dout1_70) AT=170.025n

.meas tran vdout1_71ck330 FIND v(dout1_71) AT=170.025n

.meas tran vdout1_72ck330 FIND v(dout1_72) AT=170.025n

.meas tran vdout1_73ck330 FIND v(dout1_73) AT=170.025n

.meas tran vdout1_74ck330 FIND v(dout1_74) AT=170.025n

.meas tran vdout1_75ck330 FIND v(dout1_75) AT=170.025n

.meas tran vdout1_76ck330 FIND v(dout1_76) AT=170.025n

.meas tran vdout1_77ck330 FIND v(dout1_77) AT=170.025n

.meas tran vdout1_78ck330 FIND v(dout1_78) AT=170.025n

.meas tran vdout1_79ck330 FIND v(dout1_79) AT=170.025n

.meas tran vdout1_80ck330 FIND v(dout1_80) AT=170.025n

.meas tran vdout1_81ck330 FIND v(dout1_81) AT=170.025n

.meas tran vdout1_82ck330 FIND v(dout1_82) AT=170.025n

.meas tran vdout1_83ck330 FIND v(dout1_83) AT=170.025n

.meas tran vdout1_84ck330 FIND v(dout1_84) AT=170.025n

.meas tran vdout1_85ck330 FIND v(dout1_85) AT=170.025n

.meas tran vdout1_86ck330 FIND v(dout1_86) AT=170.025n

.meas tran vdout1_87ck330 FIND v(dout1_87) AT=170.025n

.meas tran vdout1_88ck330 FIND v(dout1_88) AT=170.025n

.meas tran vdout1_89ck330 FIND v(dout1_89) AT=170.025n

.meas tran vdout1_90ck330 FIND v(dout1_90) AT=170.025n

.meas tran vdout1_91ck330 FIND v(dout1_91) AT=170.025n

.meas tran vdout1_92ck330 FIND v(dout1_92) AT=170.025n

.meas tran vdout1_93ck330 FIND v(dout1_93) AT=170.025n

.meas tran vdout1_94ck330 FIND v(dout1_94) AT=170.025n

.meas tran vdout1_95ck330 FIND v(dout1_95) AT=170.025n

.meas tran vdout1_96ck330 FIND v(dout1_96) AT=170.025n

.meas tran vdout1_97ck330 FIND v(dout1_97) AT=170.025n

.meas tran vdout1_98ck330 FIND v(dout1_98) AT=170.025n

.meas tran vdout1_99ck330 FIND v(dout1_99) AT=170.025n

.meas tran vdout1_100ck330 FIND v(dout1_100) AT=170.025n

.meas tran vdout1_101ck330 FIND v(dout1_101) AT=170.025n

.meas tran vdout1_102ck330 FIND v(dout1_102) AT=170.025n

.meas tran vdout1_103ck330 FIND v(dout1_103) AT=170.025n

.meas tran vdout1_104ck330 FIND v(dout1_104) AT=170.025n

.meas tran vdout1_105ck330 FIND v(dout1_105) AT=170.025n

.meas tran vdout1_106ck330 FIND v(dout1_106) AT=170.025n

.meas tran vdout1_107ck330 FIND v(dout1_107) AT=170.025n

.meas tran vdout1_108ck330 FIND v(dout1_108) AT=170.025n

.meas tran vdout1_109ck330 FIND v(dout1_109) AT=170.025n

.meas tran vdout1_110ck330 FIND v(dout1_110) AT=170.025n

.meas tran vdout1_111ck330 FIND v(dout1_111) AT=170.025n

.meas tran vdout1_112ck330 FIND v(dout1_112) AT=170.025n

.meas tran vdout1_113ck330 FIND v(dout1_113) AT=170.025n

.meas tran vdout1_114ck330 FIND v(dout1_114) AT=170.025n

.meas tran vdout1_115ck330 FIND v(dout1_115) AT=170.025n

.meas tran vdout1_116ck330 FIND v(dout1_116) AT=170.025n

.meas tran vdout1_117ck330 FIND v(dout1_117) AT=170.025n

.meas tran vdout1_118ck330 FIND v(dout1_118) AT=170.025n

.meas tran vdout1_119ck330 FIND v(dout1_119) AT=170.025n

.meas tran vdout1_120ck330 FIND v(dout1_120) AT=170.025n

.meas tran vdout1_121ck330 FIND v(dout1_121) AT=170.025n

.meas tran vdout1_122ck330 FIND v(dout1_122) AT=170.025n

.meas tran vdout1_123ck330 FIND v(dout1_123) AT=170.025n

.meas tran vdout1_124ck330 FIND v(dout1_124) AT=170.025n

.meas tran vdout1_125ck330 FIND v(dout1_125) AT=170.025n

.meas tran vdout1_126ck330 FIND v(dout1_126) AT=170.025n

.meas tran vdout1_127ck330 FIND v(dout1_127) AT=170.025n

.meas tran vdout1_0ck370 FIND v(dout1_0) AT=190.025n

.meas tran vdout1_1ck370 FIND v(dout1_1) AT=190.025n

.meas tran vdout1_2ck370 FIND v(dout1_2) AT=190.025n

.meas tran vdout1_3ck370 FIND v(dout1_3) AT=190.025n

.meas tran vdout1_4ck370 FIND v(dout1_4) AT=190.025n

.meas tran vdout1_5ck370 FIND v(dout1_5) AT=190.025n

.meas tran vdout1_6ck370 FIND v(dout1_6) AT=190.025n

.meas tran vdout1_7ck370 FIND v(dout1_7) AT=190.025n

.meas tran vdout1_8ck370 FIND v(dout1_8) AT=190.025n

.meas tran vdout1_9ck370 FIND v(dout1_9) AT=190.025n

.meas tran vdout1_10ck370 FIND v(dout1_10) AT=190.025n

.meas tran vdout1_11ck370 FIND v(dout1_11) AT=190.025n

.meas tran vdout1_12ck370 FIND v(dout1_12) AT=190.025n

.meas tran vdout1_13ck370 FIND v(dout1_13) AT=190.025n

.meas tran vdout1_14ck370 FIND v(dout1_14) AT=190.025n

.meas tran vdout1_15ck370 FIND v(dout1_15) AT=190.025n

.meas tran vdout1_16ck370 FIND v(dout1_16) AT=190.025n

.meas tran vdout1_17ck370 FIND v(dout1_17) AT=190.025n

.meas tran vdout1_18ck370 FIND v(dout1_18) AT=190.025n

.meas tran vdout1_19ck370 FIND v(dout1_19) AT=190.025n

.meas tran vdout1_20ck370 FIND v(dout1_20) AT=190.025n

.meas tran vdout1_21ck370 FIND v(dout1_21) AT=190.025n

.meas tran vdout1_22ck370 FIND v(dout1_22) AT=190.025n

.meas tran vdout1_23ck370 FIND v(dout1_23) AT=190.025n

.meas tran vdout1_24ck370 FIND v(dout1_24) AT=190.025n

.meas tran vdout1_25ck370 FIND v(dout1_25) AT=190.025n

.meas tran vdout1_26ck370 FIND v(dout1_26) AT=190.025n

.meas tran vdout1_27ck370 FIND v(dout1_27) AT=190.025n

.meas tran vdout1_28ck370 FIND v(dout1_28) AT=190.025n

.meas tran vdout1_29ck370 FIND v(dout1_29) AT=190.025n

.meas tran vdout1_30ck370 FIND v(dout1_30) AT=190.025n

.meas tran vdout1_31ck370 FIND v(dout1_31) AT=190.025n

.meas tran vdout1_32ck370 FIND v(dout1_32) AT=190.025n

.meas tran vdout1_33ck370 FIND v(dout1_33) AT=190.025n

.meas tran vdout1_34ck370 FIND v(dout1_34) AT=190.025n

.meas tran vdout1_35ck370 FIND v(dout1_35) AT=190.025n

.meas tran vdout1_36ck370 FIND v(dout1_36) AT=190.025n

.meas tran vdout1_37ck370 FIND v(dout1_37) AT=190.025n

.meas tran vdout1_38ck370 FIND v(dout1_38) AT=190.025n

.meas tran vdout1_39ck370 FIND v(dout1_39) AT=190.025n

.meas tran vdout1_40ck370 FIND v(dout1_40) AT=190.025n

.meas tran vdout1_41ck370 FIND v(dout1_41) AT=190.025n

.meas tran vdout1_42ck370 FIND v(dout1_42) AT=190.025n

.meas tran vdout1_43ck370 FIND v(dout1_43) AT=190.025n

.meas tran vdout1_44ck370 FIND v(dout1_44) AT=190.025n

.meas tran vdout1_45ck370 FIND v(dout1_45) AT=190.025n

.meas tran vdout1_46ck370 FIND v(dout1_46) AT=190.025n

.meas tran vdout1_47ck370 FIND v(dout1_47) AT=190.025n

.meas tran vdout1_48ck370 FIND v(dout1_48) AT=190.025n

.meas tran vdout1_49ck370 FIND v(dout1_49) AT=190.025n

.meas tran vdout1_50ck370 FIND v(dout1_50) AT=190.025n

.meas tran vdout1_51ck370 FIND v(dout1_51) AT=190.025n

.meas tran vdout1_52ck370 FIND v(dout1_52) AT=190.025n

.meas tran vdout1_53ck370 FIND v(dout1_53) AT=190.025n

.meas tran vdout1_54ck370 FIND v(dout1_54) AT=190.025n

.meas tran vdout1_55ck370 FIND v(dout1_55) AT=190.025n

.meas tran vdout1_56ck370 FIND v(dout1_56) AT=190.025n

.meas tran vdout1_57ck370 FIND v(dout1_57) AT=190.025n

.meas tran vdout1_58ck370 FIND v(dout1_58) AT=190.025n

.meas tran vdout1_59ck370 FIND v(dout1_59) AT=190.025n

.meas tran vdout1_60ck370 FIND v(dout1_60) AT=190.025n

.meas tran vdout1_61ck370 FIND v(dout1_61) AT=190.025n

.meas tran vdout1_62ck370 FIND v(dout1_62) AT=190.025n

.meas tran vdout1_63ck370 FIND v(dout1_63) AT=190.025n

.meas tran vdout1_64ck370 FIND v(dout1_64) AT=190.025n

.meas tran vdout1_65ck370 FIND v(dout1_65) AT=190.025n

.meas tran vdout1_66ck370 FIND v(dout1_66) AT=190.025n

.meas tran vdout1_67ck370 FIND v(dout1_67) AT=190.025n

.meas tran vdout1_68ck370 FIND v(dout1_68) AT=190.025n

.meas tran vdout1_69ck370 FIND v(dout1_69) AT=190.025n

.meas tran vdout1_70ck370 FIND v(dout1_70) AT=190.025n

.meas tran vdout1_71ck370 FIND v(dout1_71) AT=190.025n

.meas tran vdout1_72ck370 FIND v(dout1_72) AT=190.025n

.meas tran vdout1_73ck370 FIND v(dout1_73) AT=190.025n

.meas tran vdout1_74ck370 FIND v(dout1_74) AT=190.025n

.meas tran vdout1_75ck370 FIND v(dout1_75) AT=190.025n

.meas tran vdout1_76ck370 FIND v(dout1_76) AT=190.025n

.meas tran vdout1_77ck370 FIND v(dout1_77) AT=190.025n

.meas tran vdout1_78ck370 FIND v(dout1_78) AT=190.025n

.meas tran vdout1_79ck370 FIND v(dout1_79) AT=190.025n

.meas tran vdout1_80ck370 FIND v(dout1_80) AT=190.025n

.meas tran vdout1_81ck370 FIND v(dout1_81) AT=190.025n

.meas tran vdout1_82ck370 FIND v(dout1_82) AT=190.025n

.meas tran vdout1_83ck370 FIND v(dout1_83) AT=190.025n

.meas tran vdout1_84ck370 FIND v(dout1_84) AT=190.025n

.meas tran vdout1_85ck370 FIND v(dout1_85) AT=190.025n

.meas tran vdout1_86ck370 FIND v(dout1_86) AT=190.025n

.meas tran vdout1_87ck370 FIND v(dout1_87) AT=190.025n

.meas tran vdout1_88ck370 FIND v(dout1_88) AT=190.025n

.meas tran vdout1_89ck370 FIND v(dout1_89) AT=190.025n

.meas tran vdout1_90ck370 FIND v(dout1_90) AT=190.025n

.meas tran vdout1_91ck370 FIND v(dout1_91) AT=190.025n

.meas tran vdout1_92ck370 FIND v(dout1_92) AT=190.025n

.meas tran vdout1_93ck370 FIND v(dout1_93) AT=190.025n

.meas tran vdout1_94ck370 FIND v(dout1_94) AT=190.025n

.meas tran vdout1_95ck370 FIND v(dout1_95) AT=190.025n

.meas tran vdout1_96ck370 FIND v(dout1_96) AT=190.025n

.meas tran vdout1_97ck370 FIND v(dout1_97) AT=190.025n

.meas tran vdout1_98ck370 FIND v(dout1_98) AT=190.025n

.meas tran vdout1_99ck370 FIND v(dout1_99) AT=190.025n

.meas tran vdout1_100ck370 FIND v(dout1_100) AT=190.025n

.meas tran vdout1_101ck370 FIND v(dout1_101) AT=190.025n

.meas tran vdout1_102ck370 FIND v(dout1_102) AT=190.025n

.meas tran vdout1_103ck370 FIND v(dout1_103) AT=190.025n

.meas tran vdout1_104ck370 FIND v(dout1_104) AT=190.025n

.meas tran vdout1_105ck370 FIND v(dout1_105) AT=190.025n

.meas tran vdout1_106ck370 FIND v(dout1_106) AT=190.025n

.meas tran vdout1_107ck370 FIND v(dout1_107) AT=190.025n

.meas tran vdout1_108ck370 FIND v(dout1_108) AT=190.025n

.meas tran vdout1_109ck370 FIND v(dout1_109) AT=190.025n

.meas tran vdout1_110ck370 FIND v(dout1_110) AT=190.025n

.meas tran vdout1_111ck370 FIND v(dout1_111) AT=190.025n

.meas tran vdout1_112ck370 FIND v(dout1_112) AT=190.025n

.meas tran vdout1_113ck370 FIND v(dout1_113) AT=190.025n

.meas tran vdout1_114ck370 FIND v(dout1_114) AT=190.025n

.meas tran vdout1_115ck370 FIND v(dout1_115) AT=190.025n

.meas tran vdout1_116ck370 FIND v(dout1_116) AT=190.025n

.meas tran vdout1_117ck370 FIND v(dout1_117) AT=190.025n

.meas tran vdout1_118ck370 FIND v(dout1_118) AT=190.025n

.meas tran vdout1_119ck370 FIND v(dout1_119) AT=190.025n

.meas tran vdout1_120ck370 FIND v(dout1_120) AT=190.025n

.meas tran vdout1_121ck370 FIND v(dout1_121) AT=190.025n

.meas tran vdout1_122ck370 FIND v(dout1_122) AT=190.025n

.meas tran vdout1_123ck370 FIND v(dout1_123) AT=190.025n

.meas tran vdout1_124ck370 FIND v(dout1_124) AT=190.025n

.meas tran vdout1_125ck370 FIND v(dout1_125) AT=190.025n

.meas tran vdout1_126ck370 FIND v(dout1_126) AT=190.025n

.meas tran vdout1_127ck370 FIND v(dout1_127) AT=190.025n

.meas tran vdout1_0ck380 FIND v(dout1_0) AT=195.025n

.meas tran vdout1_1ck380 FIND v(dout1_1) AT=195.025n

.meas tran vdout1_2ck380 FIND v(dout1_2) AT=195.025n

.meas tran vdout1_3ck380 FIND v(dout1_3) AT=195.025n

.meas tran vdout1_4ck380 FIND v(dout1_4) AT=195.025n

.meas tran vdout1_5ck380 FIND v(dout1_5) AT=195.025n

.meas tran vdout1_6ck380 FIND v(dout1_6) AT=195.025n

.meas tran vdout1_7ck380 FIND v(dout1_7) AT=195.025n

.meas tran vdout1_8ck380 FIND v(dout1_8) AT=195.025n

.meas tran vdout1_9ck380 FIND v(dout1_9) AT=195.025n

.meas tran vdout1_10ck380 FIND v(dout1_10) AT=195.025n

.meas tran vdout1_11ck380 FIND v(dout1_11) AT=195.025n

.meas tran vdout1_12ck380 FIND v(dout1_12) AT=195.025n

.meas tran vdout1_13ck380 FIND v(dout1_13) AT=195.025n

.meas tran vdout1_14ck380 FIND v(dout1_14) AT=195.025n

.meas tran vdout1_15ck380 FIND v(dout1_15) AT=195.025n

.meas tran vdout1_16ck380 FIND v(dout1_16) AT=195.025n

.meas tran vdout1_17ck380 FIND v(dout1_17) AT=195.025n

.meas tran vdout1_18ck380 FIND v(dout1_18) AT=195.025n

.meas tran vdout1_19ck380 FIND v(dout1_19) AT=195.025n

.meas tran vdout1_20ck380 FIND v(dout1_20) AT=195.025n

.meas tran vdout1_21ck380 FIND v(dout1_21) AT=195.025n

.meas tran vdout1_22ck380 FIND v(dout1_22) AT=195.025n

.meas tran vdout1_23ck380 FIND v(dout1_23) AT=195.025n

.meas tran vdout1_24ck380 FIND v(dout1_24) AT=195.025n

.meas tran vdout1_25ck380 FIND v(dout1_25) AT=195.025n

.meas tran vdout1_26ck380 FIND v(dout1_26) AT=195.025n

.meas tran vdout1_27ck380 FIND v(dout1_27) AT=195.025n

.meas tran vdout1_28ck380 FIND v(dout1_28) AT=195.025n

.meas tran vdout1_29ck380 FIND v(dout1_29) AT=195.025n

.meas tran vdout1_30ck380 FIND v(dout1_30) AT=195.025n

.meas tran vdout1_31ck380 FIND v(dout1_31) AT=195.025n

.meas tran vdout1_32ck380 FIND v(dout1_32) AT=195.025n

.meas tran vdout1_33ck380 FIND v(dout1_33) AT=195.025n

.meas tran vdout1_34ck380 FIND v(dout1_34) AT=195.025n

.meas tran vdout1_35ck380 FIND v(dout1_35) AT=195.025n

.meas tran vdout1_36ck380 FIND v(dout1_36) AT=195.025n

.meas tran vdout1_37ck380 FIND v(dout1_37) AT=195.025n

.meas tran vdout1_38ck380 FIND v(dout1_38) AT=195.025n

.meas tran vdout1_39ck380 FIND v(dout1_39) AT=195.025n

.meas tran vdout1_40ck380 FIND v(dout1_40) AT=195.025n

.meas tran vdout1_41ck380 FIND v(dout1_41) AT=195.025n

.meas tran vdout1_42ck380 FIND v(dout1_42) AT=195.025n

.meas tran vdout1_43ck380 FIND v(dout1_43) AT=195.025n

.meas tran vdout1_44ck380 FIND v(dout1_44) AT=195.025n

.meas tran vdout1_45ck380 FIND v(dout1_45) AT=195.025n

.meas tran vdout1_46ck380 FIND v(dout1_46) AT=195.025n

.meas tran vdout1_47ck380 FIND v(dout1_47) AT=195.025n

.meas tran vdout1_48ck380 FIND v(dout1_48) AT=195.025n

.meas tran vdout1_49ck380 FIND v(dout1_49) AT=195.025n

.meas tran vdout1_50ck380 FIND v(dout1_50) AT=195.025n

.meas tran vdout1_51ck380 FIND v(dout1_51) AT=195.025n

.meas tran vdout1_52ck380 FIND v(dout1_52) AT=195.025n

.meas tran vdout1_53ck380 FIND v(dout1_53) AT=195.025n

.meas tran vdout1_54ck380 FIND v(dout1_54) AT=195.025n

.meas tran vdout1_55ck380 FIND v(dout1_55) AT=195.025n

.meas tran vdout1_56ck380 FIND v(dout1_56) AT=195.025n

.meas tran vdout1_57ck380 FIND v(dout1_57) AT=195.025n

.meas tran vdout1_58ck380 FIND v(dout1_58) AT=195.025n

.meas tran vdout1_59ck380 FIND v(dout1_59) AT=195.025n

.meas tran vdout1_60ck380 FIND v(dout1_60) AT=195.025n

.meas tran vdout1_61ck380 FIND v(dout1_61) AT=195.025n

.meas tran vdout1_62ck380 FIND v(dout1_62) AT=195.025n

.meas tran vdout1_63ck380 FIND v(dout1_63) AT=195.025n

.meas tran vdout1_64ck380 FIND v(dout1_64) AT=195.025n

.meas tran vdout1_65ck380 FIND v(dout1_65) AT=195.025n

.meas tran vdout1_66ck380 FIND v(dout1_66) AT=195.025n

.meas tran vdout1_67ck380 FIND v(dout1_67) AT=195.025n

.meas tran vdout1_68ck380 FIND v(dout1_68) AT=195.025n

.meas tran vdout1_69ck380 FIND v(dout1_69) AT=195.025n

.meas tran vdout1_70ck380 FIND v(dout1_70) AT=195.025n

.meas tran vdout1_71ck380 FIND v(dout1_71) AT=195.025n

.meas tran vdout1_72ck380 FIND v(dout1_72) AT=195.025n

.meas tran vdout1_73ck380 FIND v(dout1_73) AT=195.025n

.meas tran vdout1_74ck380 FIND v(dout1_74) AT=195.025n

.meas tran vdout1_75ck380 FIND v(dout1_75) AT=195.025n

.meas tran vdout1_76ck380 FIND v(dout1_76) AT=195.025n

.meas tran vdout1_77ck380 FIND v(dout1_77) AT=195.025n

.meas tran vdout1_78ck380 FIND v(dout1_78) AT=195.025n

.meas tran vdout1_79ck380 FIND v(dout1_79) AT=195.025n

.meas tran vdout1_80ck380 FIND v(dout1_80) AT=195.025n

.meas tran vdout1_81ck380 FIND v(dout1_81) AT=195.025n

.meas tran vdout1_82ck380 FIND v(dout1_82) AT=195.025n

.meas tran vdout1_83ck380 FIND v(dout1_83) AT=195.025n

.meas tran vdout1_84ck380 FIND v(dout1_84) AT=195.025n

.meas tran vdout1_85ck380 FIND v(dout1_85) AT=195.025n

.meas tran vdout1_86ck380 FIND v(dout1_86) AT=195.025n

.meas tran vdout1_87ck380 FIND v(dout1_87) AT=195.025n

.meas tran vdout1_88ck380 FIND v(dout1_88) AT=195.025n

.meas tran vdout1_89ck380 FIND v(dout1_89) AT=195.025n

.meas tran vdout1_90ck380 FIND v(dout1_90) AT=195.025n

.meas tran vdout1_91ck380 FIND v(dout1_91) AT=195.025n

.meas tran vdout1_92ck380 FIND v(dout1_92) AT=195.025n

.meas tran vdout1_93ck380 FIND v(dout1_93) AT=195.025n

.meas tran vdout1_94ck380 FIND v(dout1_94) AT=195.025n

.meas tran vdout1_95ck380 FIND v(dout1_95) AT=195.025n

.meas tran vdout1_96ck380 FIND v(dout1_96) AT=195.025n

.meas tran vdout1_97ck380 FIND v(dout1_97) AT=195.025n

.meas tran vdout1_98ck380 FIND v(dout1_98) AT=195.025n

.meas tran vdout1_99ck380 FIND v(dout1_99) AT=195.025n

.meas tran vdout1_100ck380 FIND v(dout1_100) AT=195.025n

.meas tran vdout1_101ck380 FIND v(dout1_101) AT=195.025n

.meas tran vdout1_102ck380 FIND v(dout1_102) AT=195.025n

.meas tran vdout1_103ck380 FIND v(dout1_103) AT=195.025n

.meas tran vdout1_104ck380 FIND v(dout1_104) AT=195.025n

.meas tran vdout1_105ck380 FIND v(dout1_105) AT=195.025n

.meas tran vdout1_106ck380 FIND v(dout1_106) AT=195.025n

.meas tran vdout1_107ck380 FIND v(dout1_107) AT=195.025n

.meas tran vdout1_108ck380 FIND v(dout1_108) AT=195.025n

.meas tran vdout1_109ck380 FIND v(dout1_109) AT=195.025n

.meas tran vdout1_110ck380 FIND v(dout1_110) AT=195.025n

.meas tran vdout1_111ck380 FIND v(dout1_111) AT=195.025n

.meas tran vdout1_112ck380 FIND v(dout1_112) AT=195.025n

.meas tran vdout1_113ck380 FIND v(dout1_113) AT=195.025n

.meas tran vdout1_114ck380 FIND v(dout1_114) AT=195.025n

.meas tran vdout1_115ck380 FIND v(dout1_115) AT=195.025n

.meas tran vdout1_116ck380 FIND v(dout1_116) AT=195.025n

.meas tran vdout1_117ck380 FIND v(dout1_117) AT=195.025n

.meas tran vdout1_118ck380 FIND v(dout1_118) AT=195.025n

.meas tran vdout1_119ck380 FIND v(dout1_119) AT=195.025n

.meas tran vdout1_120ck380 FIND v(dout1_120) AT=195.025n

.meas tran vdout1_121ck380 FIND v(dout1_121) AT=195.025n

.meas tran vdout1_122ck380 FIND v(dout1_122) AT=195.025n

.meas tran vdout1_123ck380 FIND v(dout1_123) AT=195.025n

.meas tran vdout1_124ck380 FIND v(dout1_124) AT=195.025n

.meas tran vdout1_125ck380 FIND v(dout1_125) AT=195.025n

.meas tran vdout1_126ck380 FIND v(dout1_126) AT=195.025n

.meas tran vdout1_127ck380 FIND v(dout1_127) AT=195.025n

.meas tran vdout1_0ck400 FIND v(dout1_0) AT=205.025n

.meas tran vdout1_1ck400 FIND v(dout1_1) AT=205.025n

.meas tran vdout1_2ck400 FIND v(dout1_2) AT=205.025n

.meas tran vdout1_3ck400 FIND v(dout1_3) AT=205.025n

.meas tran vdout1_4ck400 FIND v(dout1_4) AT=205.025n

.meas tran vdout1_5ck400 FIND v(dout1_5) AT=205.025n

.meas tran vdout1_6ck400 FIND v(dout1_6) AT=205.025n

.meas tran vdout1_7ck400 FIND v(dout1_7) AT=205.025n

.meas tran vdout1_8ck400 FIND v(dout1_8) AT=205.025n

.meas tran vdout1_9ck400 FIND v(dout1_9) AT=205.025n

.meas tran vdout1_10ck400 FIND v(dout1_10) AT=205.025n

.meas tran vdout1_11ck400 FIND v(dout1_11) AT=205.025n

.meas tran vdout1_12ck400 FIND v(dout1_12) AT=205.025n

.meas tran vdout1_13ck400 FIND v(dout1_13) AT=205.025n

.meas tran vdout1_14ck400 FIND v(dout1_14) AT=205.025n

.meas tran vdout1_15ck400 FIND v(dout1_15) AT=205.025n

.meas tran vdout1_16ck400 FIND v(dout1_16) AT=205.025n

.meas tran vdout1_17ck400 FIND v(dout1_17) AT=205.025n

.meas tran vdout1_18ck400 FIND v(dout1_18) AT=205.025n

.meas tran vdout1_19ck400 FIND v(dout1_19) AT=205.025n

.meas tran vdout1_20ck400 FIND v(dout1_20) AT=205.025n

.meas tran vdout1_21ck400 FIND v(dout1_21) AT=205.025n

.meas tran vdout1_22ck400 FIND v(dout1_22) AT=205.025n

.meas tran vdout1_23ck400 FIND v(dout1_23) AT=205.025n

.meas tran vdout1_24ck400 FIND v(dout1_24) AT=205.025n

.meas tran vdout1_25ck400 FIND v(dout1_25) AT=205.025n

.meas tran vdout1_26ck400 FIND v(dout1_26) AT=205.025n

.meas tran vdout1_27ck400 FIND v(dout1_27) AT=205.025n

.meas tran vdout1_28ck400 FIND v(dout1_28) AT=205.025n

.meas tran vdout1_29ck400 FIND v(dout1_29) AT=205.025n

.meas tran vdout1_30ck400 FIND v(dout1_30) AT=205.025n

.meas tran vdout1_31ck400 FIND v(dout1_31) AT=205.025n

.meas tran vdout1_32ck400 FIND v(dout1_32) AT=205.025n

.meas tran vdout1_33ck400 FIND v(dout1_33) AT=205.025n

.meas tran vdout1_34ck400 FIND v(dout1_34) AT=205.025n

.meas tran vdout1_35ck400 FIND v(dout1_35) AT=205.025n

.meas tran vdout1_36ck400 FIND v(dout1_36) AT=205.025n

.meas tran vdout1_37ck400 FIND v(dout1_37) AT=205.025n

.meas tran vdout1_38ck400 FIND v(dout1_38) AT=205.025n

.meas tran vdout1_39ck400 FIND v(dout1_39) AT=205.025n

.meas tran vdout1_40ck400 FIND v(dout1_40) AT=205.025n

.meas tran vdout1_41ck400 FIND v(dout1_41) AT=205.025n

.meas tran vdout1_42ck400 FIND v(dout1_42) AT=205.025n

.meas tran vdout1_43ck400 FIND v(dout1_43) AT=205.025n

.meas tran vdout1_44ck400 FIND v(dout1_44) AT=205.025n

.meas tran vdout1_45ck400 FIND v(dout1_45) AT=205.025n

.meas tran vdout1_46ck400 FIND v(dout1_46) AT=205.025n

.meas tran vdout1_47ck400 FIND v(dout1_47) AT=205.025n

.meas tran vdout1_48ck400 FIND v(dout1_48) AT=205.025n

.meas tran vdout1_49ck400 FIND v(dout1_49) AT=205.025n

.meas tran vdout1_50ck400 FIND v(dout1_50) AT=205.025n

.meas tran vdout1_51ck400 FIND v(dout1_51) AT=205.025n

.meas tran vdout1_52ck400 FIND v(dout1_52) AT=205.025n

.meas tran vdout1_53ck400 FIND v(dout1_53) AT=205.025n

.meas tran vdout1_54ck400 FIND v(dout1_54) AT=205.025n

.meas tran vdout1_55ck400 FIND v(dout1_55) AT=205.025n

.meas tran vdout1_56ck400 FIND v(dout1_56) AT=205.025n

.meas tran vdout1_57ck400 FIND v(dout1_57) AT=205.025n

.meas tran vdout1_58ck400 FIND v(dout1_58) AT=205.025n

.meas tran vdout1_59ck400 FIND v(dout1_59) AT=205.025n

.meas tran vdout1_60ck400 FIND v(dout1_60) AT=205.025n

.meas tran vdout1_61ck400 FIND v(dout1_61) AT=205.025n

.meas tran vdout1_62ck400 FIND v(dout1_62) AT=205.025n

.meas tran vdout1_63ck400 FIND v(dout1_63) AT=205.025n

.meas tran vdout1_64ck400 FIND v(dout1_64) AT=205.025n

.meas tran vdout1_65ck400 FIND v(dout1_65) AT=205.025n

.meas tran vdout1_66ck400 FIND v(dout1_66) AT=205.025n

.meas tran vdout1_67ck400 FIND v(dout1_67) AT=205.025n

.meas tran vdout1_68ck400 FIND v(dout1_68) AT=205.025n

.meas tran vdout1_69ck400 FIND v(dout1_69) AT=205.025n

.meas tran vdout1_70ck400 FIND v(dout1_70) AT=205.025n

.meas tran vdout1_71ck400 FIND v(dout1_71) AT=205.025n

.meas tran vdout1_72ck400 FIND v(dout1_72) AT=205.025n

.meas tran vdout1_73ck400 FIND v(dout1_73) AT=205.025n

.meas tran vdout1_74ck400 FIND v(dout1_74) AT=205.025n

.meas tran vdout1_75ck400 FIND v(dout1_75) AT=205.025n

.meas tran vdout1_76ck400 FIND v(dout1_76) AT=205.025n

.meas tran vdout1_77ck400 FIND v(dout1_77) AT=205.025n

.meas tran vdout1_78ck400 FIND v(dout1_78) AT=205.025n

.meas tran vdout1_79ck400 FIND v(dout1_79) AT=205.025n

.meas tran vdout1_80ck400 FIND v(dout1_80) AT=205.025n

.meas tran vdout1_81ck400 FIND v(dout1_81) AT=205.025n

.meas tran vdout1_82ck400 FIND v(dout1_82) AT=205.025n

.meas tran vdout1_83ck400 FIND v(dout1_83) AT=205.025n

.meas tran vdout1_84ck400 FIND v(dout1_84) AT=205.025n

.meas tran vdout1_85ck400 FIND v(dout1_85) AT=205.025n

.meas tran vdout1_86ck400 FIND v(dout1_86) AT=205.025n

.meas tran vdout1_87ck400 FIND v(dout1_87) AT=205.025n

.meas tran vdout1_88ck400 FIND v(dout1_88) AT=205.025n

.meas tran vdout1_89ck400 FIND v(dout1_89) AT=205.025n

.meas tran vdout1_90ck400 FIND v(dout1_90) AT=205.025n

.meas tran vdout1_91ck400 FIND v(dout1_91) AT=205.025n

.meas tran vdout1_92ck400 FIND v(dout1_92) AT=205.025n

.meas tran vdout1_93ck400 FIND v(dout1_93) AT=205.025n

.meas tran vdout1_94ck400 FIND v(dout1_94) AT=205.025n

.meas tran vdout1_95ck400 FIND v(dout1_95) AT=205.025n

.meas tran vdout1_96ck400 FIND v(dout1_96) AT=205.025n

.meas tran vdout1_97ck400 FIND v(dout1_97) AT=205.025n

.meas tran vdout1_98ck400 FIND v(dout1_98) AT=205.025n

.meas tran vdout1_99ck400 FIND v(dout1_99) AT=205.025n

.meas tran vdout1_100ck400 FIND v(dout1_100) AT=205.025n

.meas tran vdout1_101ck400 FIND v(dout1_101) AT=205.025n

.meas tran vdout1_102ck400 FIND v(dout1_102) AT=205.025n

.meas tran vdout1_103ck400 FIND v(dout1_103) AT=205.025n

.meas tran vdout1_104ck400 FIND v(dout1_104) AT=205.025n

.meas tran vdout1_105ck400 FIND v(dout1_105) AT=205.025n

.meas tran vdout1_106ck400 FIND v(dout1_106) AT=205.025n

.meas tran vdout1_107ck400 FIND v(dout1_107) AT=205.025n

.meas tran vdout1_108ck400 FIND v(dout1_108) AT=205.025n

.meas tran vdout1_109ck400 FIND v(dout1_109) AT=205.025n

.meas tran vdout1_110ck400 FIND v(dout1_110) AT=205.025n

.meas tran vdout1_111ck400 FIND v(dout1_111) AT=205.025n

.meas tran vdout1_112ck400 FIND v(dout1_112) AT=205.025n

.meas tran vdout1_113ck400 FIND v(dout1_113) AT=205.025n

.meas tran vdout1_114ck400 FIND v(dout1_114) AT=205.025n

.meas tran vdout1_115ck400 FIND v(dout1_115) AT=205.025n

.meas tran vdout1_116ck400 FIND v(dout1_116) AT=205.025n

.meas tran vdout1_117ck400 FIND v(dout1_117) AT=205.025n

.meas tran vdout1_118ck400 FIND v(dout1_118) AT=205.025n

.meas tran vdout1_119ck400 FIND v(dout1_119) AT=205.025n

.meas tran vdout1_120ck400 FIND v(dout1_120) AT=205.025n

.meas tran vdout1_121ck400 FIND v(dout1_121) AT=205.025n

.meas tran vdout1_122ck400 FIND v(dout1_122) AT=205.025n

.meas tran vdout1_123ck400 FIND v(dout1_123) AT=205.025n

.meas tran vdout1_124ck400 FIND v(dout1_124) AT=205.025n

.meas tran vdout1_125ck400 FIND v(dout1_125) AT=205.025n

.meas tran vdout1_126ck400 FIND v(dout1_126) AT=205.025n

.meas tran vdout1_127ck400 FIND v(dout1_127) AT=205.025n

.meas tran vdout1_0ck470 FIND v(dout1_0) AT=240.025n

.meas tran vdout1_1ck470 FIND v(dout1_1) AT=240.025n

.meas tran vdout1_2ck470 FIND v(dout1_2) AT=240.025n

.meas tran vdout1_3ck470 FIND v(dout1_3) AT=240.025n

.meas tran vdout1_4ck470 FIND v(dout1_4) AT=240.025n

.meas tran vdout1_5ck470 FIND v(dout1_5) AT=240.025n

.meas tran vdout1_6ck470 FIND v(dout1_6) AT=240.025n

.meas tran vdout1_7ck470 FIND v(dout1_7) AT=240.025n

.meas tran vdout1_8ck470 FIND v(dout1_8) AT=240.025n

.meas tran vdout1_9ck470 FIND v(dout1_9) AT=240.025n

.meas tran vdout1_10ck470 FIND v(dout1_10) AT=240.025n

.meas tran vdout1_11ck470 FIND v(dout1_11) AT=240.025n

.meas tran vdout1_12ck470 FIND v(dout1_12) AT=240.025n

.meas tran vdout1_13ck470 FIND v(dout1_13) AT=240.025n

.meas tran vdout1_14ck470 FIND v(dout1_14) AT=240.025n

.meas tran vdout1_15ck470 FIND v(dout1_15) AT=240.025n

.meas tran vdout1_16ck470 FIND v(dout1_16) AT=240.025n

.meas tran vdout1_17ck470 FIND v(dout1_17) AT=240.025n

.meas tran vdout1_18ck470 FIND v(dout1_18) AT=240.025n

.meas tran vdout1_19ck470 FIND v(dout1_19) AT=240.025n

.meas tran vdout1_20ck470 FIND v(dout1_20) AT=240.025n

.meas tran vdout1_21ck470 FIND v(dout1_21) AT=240.025n

.meas tran vdout1_22ck470 FIND v(dout1_22) AT=240.025n

.meas tran vdout1_23ck470 FIND v(dout1_23) AT=240.025n

.meas tran vdout1_24ck470 FIND v(dout1_24) AT=240.025n

.meas tran vdout1_25ck470 FIND v(dout1_25) AT=240.025n

.meas tran vdout1_26ck470 FIND v(dout1_26) AT=240.025n

.meas tran vdout1_27ck470 FIND v(dout1_27) AT=240.025n

.meas tran vdout1_28ck470 FIND v(dout1_28) AT=240.025n

.meas tran vdout1_29ck470 FIND v(dout1_29) AT=240.025n

.meas tran vdout1_30ck470 FIND v(dout1_30) AT=240.025n

.meas tran vdout1_31ck470 FIND v(dout1_31) AT=240.025n

.meas tran vdout1_32ck470 FIND v(dout1_32) AT=240.025n

.meas tran vdout1_33ck470 FIND v(dout1_33) AT=240.025n

.meas tran vdout1_34ck470 FIND v(dout1_34) AT=240.025n

.meas tran vdout1_35ck470 FIND v(dout1_35) AT=240.025n

.meas tran vdout1_36ck470 FIND v(dout1_36) AT=240.025n

.meas tran vdout1_37ck470 FIND v(dout1_37) AT=240.025n

.meas tran vdout1_38ck470 FIND v(dout1_38) AT=240.025n

.meas tran vdout1_39ck470 FIND v(dout1_39) AT=240.025n

.meas tran vdout1_40ck470 FIND v(dout1_40) AT=240.025n

.meas tran vdout1_41ck470 FIND v(dout1_41) AT=240.025n

.meas tran vdout1_42ck470 FIND v(dout1_42) AT=240.025n

.meas tran vdout1_43ck470 FIND v(dout1_43) AT=240.025n

.meas tran vdout1_44ck470 FIND v(dout1_44) AT=240.025n

.meas tran vdout1_45ck470 FIND v(dout1_45) AT=240.025n

.meas tran vdout1_46ck470 FIND v(dout1_46) AT=240.025n

.meas tran vdout1_47ck470 FIND v(dout1_47) AT=240.025n

.meas tran vdout1_48ck470 FIND v(dout1_48) AT=240.025n

.meas tran vdout1_49ck470 FIND v(dout1_49) AT=240.025n

.meas tran vdout1_50ck470 FIND v(dout1_50) AT=240.025n

.meas tran vdout1_51ck470 FIND v(dout1_51) AT=240.025n

.meas tran vdout1_52ck470 FIND v(dout1_52) AT=240.025n

.meas tran vdout1_53ck470 FIND v(dout1_53) AT=240.025n

.meas tran vdout1_54ck470 FIND v(dout1_54) AT=240.025n

.meas tran vdout1_55ck470 FIND v(dout1_55) AT=240.025n

.meas tran vdout1_56ck470 FIND v(dout1_56) AT=240.025n

.meas tran vdout1_57ck470 FIND v(dout1_57) AT=240.025n

.meas tran vdout1_58ck470 FIND v(dout1_58) AT=240.025n

.meas tran vdout1_59ck470 FIND v(dout1_59) AT=240.025n

.meas tran vdout1_60ck470 FIND v(dout1_60) AT=240.025n

.meas tran vdout1_61ck470 FIND v(dout1_61) AT=240.025n

.meas tran vdout1_62ck470 FIND v(dout1_62) AT=240.025n

.meas tran vdout1_63ck470 FIND v(dout1_63) AT=240.025n

.meas tran vdout1_64ck470 FIND v(dout1_64) AT=240.025n

.meas tran vdout1_65ck470 FIND v(dout1_65) AT=240.025n

.meas tran vdout1_66ck470 FIND v(dout1_66) AT=240.025n

.meas tran vdout1_67ck470 FIND v(dout1_67) AT=240.025n

.meas tran vdout1_68ck470 FIND v(dout1_68) AT=240.025n

.meas tran vdout1_69ck470 FIND v(dout1_69) AT=240.025n

.meas tran vdout1_70ck470 FIND v(dout1_70) AT=240.025n

.meas tran vdout1_71ck470 FIND v(dout1_71) AT=240.025n

.meas tran vdout1_72ck470 FIND v(dout1_72) AT=240.025n

.meas tran vdout1_73ck470 FIND v(dout1_73) AT=240.025n

.meas tran vdout1_74ck470 FIND v(dout1_74) AT=240.025n

.meas tran vdout1_75ck470 FIND v(dout1_75) AT=240.025n

.meas tran vdout1_76ck470 FIND v(dout1_76) AT=240.025n

.meas tran vdout1_77ck470 FIND v(dout1_77) AT=240.025n

.meas tran vdout1_78ck470 FIND v(dout1_78) AT=240.025n

.meas tran vdout1_79ck470 FIND v(dout1_79) AT=240.025n

.meas tran vdout1_80ck470 FIND v(dout1_80) AT=240.025n

.meas tran vdout1_81ck470 FIND v(dout1_81) AT=240.025n

.meas tran vdout1_82ck470 FIND v(dout1_82) AT=240.025n

.meas tran vdout1_83ck470 FIND v(dout1_83) AT=240.025n

.meas tran vdout1_84ck470 FIND v(dout1_84) AT=240.025n

.meas tran vdout1_85ck470 FIND v(dout1_85) AT=240.025n

.meas tran vdout1_86ck470 FIND v(dout1_86) AT=240.025n

.meas tran vdout1_87ck470 FIND v(dout1_87) AT=240.025n

.meas tran vdout1_88ck470 FIND v(dout1_88) AT=240.025n

.meas tran vdout1_89ck470 FIND v(dout1_89) AT=240.025n

.meas tran vdout1_90ck470 FIND v(dout1_90) AT=240.025n

.meas tran vdout1_91ck470 FIND v(dout1_91) AT=240.025n

.meas tran vdout1_92ck470 FIND v(dout1_92) AT=240.025n

.meas tran vdout1_93ck470 FIND v(dout1_93) AT=240.025n

.meas tran vdout1_94ck470 FIND v(dout1_94) AT=240.025n

.meas tran vdout1_95ck470 FIND v(dout1_95) AT=240.025n

.meas tran vdout1_96ck470 FIND v(dout1_96) AT=240.025n

.meas tran vdout1_97ck470 FIND v(dout1_97) AT=240.025n

.meas tran vdout1_98ck470 FIND v(dout1_98) AT=240.025n

.meas tran vdout1_99ck470 FIND v(dout1_99) AT=240.025n

.meas tran vdout1_100ck470 FIND v(dout1_100) AT=240.025n

.meas tran vdout1_101ck470 FIND v(dout1_101) AT=240.025n

.meas tran vdout1_102ck470 FIND v(dout1_102) AT=240.025n

.meas tran vdout1_103ck470 FIND v(dout1_103) AT=240.025n

.meas tran vdout1_104ck470 FIND v(dout1_104) AT=240.025n

.meas tran vdout1_105ck470 FIND v(dout1_105) AT=240.025n

.meas tran vdout1_106ck470 FIND v(dout1_106) AT=240.025n

.meas tran vdout1_107ck470 FIND v(dout1_107) AT=240.025n

.meas tran vdout1_108ck470 FIND v(dout1_108) AT=240.025n

.meas tran vdout1_109ck470 FIND v(dout1_109) AT=240.025n

.meas tran vdout1_110ck470 FIND v(dout1_110) AT=240.025n

.meas tran vdout1_111ck470 FIND v(dout1_111) AT=240.025n

.meas tran vdout1_112ck470 FIND v(dout1_112) AT=240.025n

.meas tran vdout1_113ck470 FIND v(dout1_113) AT=240.025n

.meas tran vdout1_114ck470 FIND v(dout1_114) AT=240.025n

.meas tran vdout1_115ck470 FIND v(dout1_115) AT=240.025n

.meas tran vdout1_116ck470 FIND v(dout1_116) AT=240.025n

.meas tran vdout1_117ck470 FIND v(dout1_117) AT=240.025n

.meas tran vdout1_118ck470 FIND v(dout1_118) AT=240.025n

.meas tran vdout1_119ck470 FIND v(dout1_119) AT=240.025n

.meas tran vdout1_120ck470 FIND v(dout1_120) AT=240.025n

.meas tran vdout1_121ck470 FIND v(dout1_121) AT=240.025n

.meas tran vdout1_122ck470 FIND v(dout1_122) AT=240.025n

.meas tran vdout1_123ck470 FIND v(dout1_123) AT=240.025n

.meas tran vdout1_124ck470 FIND v(dout1_124) AT=240.025n

.meas tran vdout1_125ck470 FIND v(dout1_125) AT=240.025n

.meas tran vdout1_126ck470 FIND v(dout1_126) AT=240.025n

.meas tran vdout1_127ck470 FIND v(dout1_127) AT=240.025n

.meas tran vdout1_0ck480 FIND v(dout1_0) AT=245.025n

.meas tran vdout1_1ck480 FIND v(dout1_1) AT=245.025n

.meas tran vdout1_2ck480 FIND v(dout1_2) AT=245.025n

.meas tran vdout1_3ck480 FIND v(dout1_3) AT=245.025n

.meas tran vdout1_4ck480 FIND v(dout1_4) AT=245.025n

.meas tran vdout1_5ck480 FIND v(dout1_5) AT=245.025n

.meas tran vdout1_6ck480 FIND v(dout1_6) AT=245.025n

.meas tran vdout1_7ck480 FIND v(dout1_7) AT=245.025n

.meas tran vdout1_8ck480 FIND v(dout1_8) AT=245.025n

.meas tran vdout1_9ck480 FIND v(dout1_9) AT=245.025n

.meas tran vdout1_10ck480 FIND v(dout1_10) AT=245.025n

.meas tran vdout1_11ck480 FIND v(dout1_11) AT=245.025n

.meas tran vdout1_12ck480 FIND v(dout1_12) AT=245.025n

.meas tran vdout1_13ck480 FIND v(dout1_13) AT=245.025n

.meas tran vdout1_14ck480 FIND v(dout1_14) AT=245.025n

.meas tran vdout1_15ck480 FIND v(dout1_15) AT=245.025n

.meas tran vdout1_16ck480 FIND v(dout1_16) AT=245.025n

.meas tran vdout1_17ck480 FIND v(dout1_17) AT=245.025n

.meas tran vdout1_18ck480 FIND v(dout1_18) AT=245.025n

.meas tran vdout1_19ck480 FIND v(dout1_19) AT=245.025n

.meas tran vdout1_20ck480 FIND v(dout1_20) AT=245.025n

.meas tran vdout1_21ck480 FIND v(dout1_21) AT=245.025n

.meas tran vdout1_22ck480 FIND v(dout1_22) AT=245.025n

.meas tran vdout1_23ck480 FIND v(dout1_23) AT=245.025n

.meas tran vdout1_24ck480 FIND v(dout1_24) AT=245.025n

.meas tran vdout1_25ck480 FIND v(dout1_25) AT=245.025n

.meas tran vdout1_26ck480 FIND v(dout1_26) AT=245.025n

.meas tran vdout1_27ck480 FIND v(dout1_27) AT=245.025n

.meas tran vdout1_28ck480 FIND v(dout1_28) AT=245.025n

.meas tran vdout1_29ck480 FIND v(dout1_29) AT=245.025n

.meas tran vdout1_30ck480 FIND v(dout1_30) AT=245.025n

.meas tran vdout1_31ck480 FIND v(dout1_31) AT=245.025n

.meas tran vdout1_32ck480 FIND v(dout1_32) AT=245.025n

.meas tran vdout1_33ck480 FIND v(dout1_33) AT=245.025n

.meas tran vdout1_34ck480 FIND v(dout1_34) AT=245.025n

.meas tran vdout1_35ck480 FIND v(dout1_35) AT=245.025n

.meas tran vdout1_36ck480 FIND v(dout1_36) AT=245.025n

.meas tran vdout1_37ck480 FIND v(dout1_37) AT=245.025n

.meas tran vdout1_38ck480 FIND v(dout1_38) AT=245.025n

.meas tran vdout1_39ck480 FIND v(dout1_39) AT=245.025n

.meas tran vdout1_40ck480 FIND v(dout1_40) AT=245.025n

.meas tran vdout1_41ck480 FIND v(dout1_41) AT=245.025n

.meas tran vdout1_42ck480 FIND v(dout1_42) AT=245.025n

.meas tran vdout1_43ck480 FIND v(dout1_43) AT=245.025n

.meas tran vdout1_44ck480 FIND v(dout1_44) AT=245.025n

.meas tran vdout1_45ck480 FIND v(dout1_45) AT=245.025n

.meas tran vdout1_46ck480 FIND v(dout1_46) AT=245.025n

.meas tran vdout1_47ck480 FIND v(dout1_47) AT=245.025n

.meas tran vdout1_48ck480 FIND v(dout1_48) AT=245.025n

.meas tran vdout1_49ck480 FIND v(dout1_49) AT=245.025n

.meas tran vdout1_50ck480 FIND v(dout1_50) AT=245.025n

.meas tran vdout1_51ck480 FIND v(dout1_51) AT=245.025n

.meas tran vdout1_52ck480 FIND v(dout1_52) AT=245.025n

.meas tran vdout1_53ck480 FIND v(dout1_53) AT=245.025n

.meas tran vdout1_54ck480 FIND v(dout1_54) AT=245.025n

.meas tran vdout1_55ck480 FIND v(dout1_55) AT=245.025n

.meas tran vdout1_56ck480 FIND v(dout1_56) AT=245.025n

.meas tran vdout1_57ck480 FIND v(dout1_57) AT=245.025n

.meas tran vdout1_58ck480 FIND v(dout1_58) AT=245.025n

.meas tran vdout1_59ck480 FIND v(dout1_59) AT=245.025n

.meas tran vdout1_60ck480 FIND v(dout1_60) AT=245.025n

.meas tran vdout1_61ck480 FIND v(dout1_61) AT=245.025n

.meas tran vdout1_62ck480 FIND v(dout1_62) AT=245.025n

.meas tran vdout1_63ck480 FIND v(dout1_63) AT=245.025n

.meas tran vdout1_64ck480 FIND v(dout1_64) AT=245.025n

.meas tran vdout1_65ck480 FIND v(dout1_65) AT=245.025n

.meas tran vdout1_66ck480 FIND v(dout1_66) AT=245.025n

.meas tran vdout1_67ck480 FIND v(dout1_67) AT=245.025n

.meas tran vdout1_68ck480 FIND v(dout1_68) AT=245.025n

.meas tran vdout1_69ck480 FIND v(dout1_69) AT=245.025n

.meas tran vdout1_70ck480 FIND v(dout1_70) AT=245.025n

.meas tran vdout1_71ck480 FIND v(dout1_71) AT=245.025n

.meas tran vdout1_72ck480 FIND v(dout1_72) AT=245.025n

.meas tran vdout1_73ck480 FIND v(dout1_73) AT=245.025n

.meas tran vdout1_74ck480 FIND v(dout1_74) AT=245.025n

.meas tran vdout1_75ck480 FIND v(dout1_75) AT=245.025n

.meas tran vdout1_76ck480 FIND v(dout1_76) AT=245.025n

.meas tran vdout1_77ck480 FIND v(dout1_77) AT=245.025n

.meas tran vdout1_78ck480 FIND v(dout1_78) AT=245.025n

.meas tran vdout1_79ck480 FIND v(dout1_79) AT=245.025n

.meas tran vdout1_80ck480 FIND v(dout1_80) AT=245.025n

.meas tran vdout1_81ck480 FIND v(dout1_81) AT=245.025n

.meas tran vdout1_82ck480 FIND v(dout1_82) AT=245.025n

.meas tran vdout1_83ck480 FIND v(dout1_83) AT=245.025n

.meas tran vdout1_84ck480 FIND v(dout1_84) AT=245.025n

.meas tran vdout1_85ck480 FIND v(dout1_85) AT=245.025n

.meas tran vdout1_86ck480 FIND v(dout1_86) AT=245.025n

.meas tran vdout1_87ck480 FIND v(dout1_87) AT=245.025n

.meas tran vdout1_88ck480 FIND v(dout1_88) AT=245.025n

.meas tran vdout1_89ck480 FIND v(dout1_89) AT=245.025n

.meas tran vdout1_90ck480 FIND v(dout1_90) AT=245.025n

.meas tran vdout1_91ck480 FIND v(dout1_91) AT=245.025n

.meas tran vdout1_92ck480 FIND v(dout1_92) AT=245.025n

.meas tran vdout1_93ck480 FIND v(dout1_93) AT=245.025n

.meas tran vdout1_94ck480 FIND v(dout1_94) AT=245.025n

.meas tran vdout1_95ck480 FIND v(dout1_95) AT=245.025n

.meas tran vdout1_96ck480 FIND v(dout1_96) AT=245.025n

.meas tran vdout1_97ck480 FIND v(dout1_97) AT=245.025n

.meas tran vdout1_98ck480 FIND v(dout1_98) AT=245.025n

.meas tran vdout1_99ck480 FIND v(dout1_99) AT=245.025n

.meas tran vdout1_100ck480 FIND v(dout1_100) AT=245.025n

.meas tran vdout1_101ck480 FIND v(dout1_101) AT=245.025n

.meas tran vdout1_102ck480 FIND v(dout1_102) AT=245.025n

.meas tran vdout1_103ck480 FIND v(dout1_103) AT=245.025n

.meas tran vdout1_104ck480 FIND v(dout1_104) AT=245.025n

.meas tran vdout1_105ck480 FIND v(dout1_105) AT=245.025n

.meas tran vdout1_106ck480 FIND v(dout1_106) AT=245.025n

.meas tran vdout1_107ck480 FIND v(dout1_107) AT=245.025n

.meas tran vdout1_108ck480 FIND v(dout1_108) AT=245.025n

.meas tran vdout1_109ck480 FIND v(dout1_109) AT=245.025n

.meas tran vdout1_110ck480 FIND v(dout1_110) AT=245.025n

.meas tran vdout1_111ck480 FIND v(dout1_111) AT=245.025n

.meas tran vdout1_112ck480 FIND v(dout1_112) AT=245.025n

.meas tran vdout1_113ck480 FIND v(dout1_113) AT=245.025n

.meas tran vdout1_114ck480 FIND v(dout1_114) AT=245.025n

.meas tran vdout1_115ck480 FIND v(dout1_115) AT=245.025n

.meas tran vdout1_116ck480 FIND v(dout1_116) AT=245.025n

.meas tran vdout1_117ck480 FIND v(dout1_117) AT=245.025n

.meas tran vdout1_118ck480 FIND v(dout1_118) AT=245.025n

.meas tran vdout1_119ck480 FIND v(dout1_119) AT=245.025n

.meas tran vdout1_120ck480 FIND v(dout1_120) AT=245.025n

.meas tran vdout1_121ck480 FIND v(dout1_121) AT=245.025n

.meas tran vdout1_122ck480 FIND v(dout1_122) AT=245.025n

.meas tran vdout1_123ck480 FIND v(dout1_123) AT=245.025n

.meas tran vdout1_124ck480 FIND v(dout1_124) AT=245.025n

.meas tran vdout1_125ck480 FIND v(dout1_125) AT=245.025n

.meas tran vdout1_126ck480 FIND v(dout1_126) AT=245.025n

.meas tran vdout1_127ck480 FIND v(dout1_127) AT=245.025n

.meas tran vdout1_0ck510 FIND v(dout1_0) AT=260.025n

.meas tran vdout1_1ck510 FIND v(dout1_1) AT=260.025n

.meas tran vdout1_2ck510 FIND v(dout1_2) AT=260.025n

.meas tran vdout1_3ck510 FIND v(dout1_3) AT=260.025n

.meas tran vdout1_4ck510 FIND v(dout1_4) AT=260.025n

.meas tran vdout1_5ck510 FIND v(dout1_5) AT=260.025n

.meas tran vdout1_6ck510 FIND v(dout1_6) AT=260.025n

.meas tran vdout1_7ck510 FIND v(dout1_7) AT=260.025n

.meas tran vdout1_8ck510 FIND v(dout1_8) AT=260.025n

.meas tran vdout1_9ck510 FIND v(dout1_9) AT=260.025n

.meas tran vdout1_10ck510 FIND v(dout1_10) AT=260.025n

.meas tran vdout1_11ck510 FIND v(dout1_11) AT=260.025n

.meas tran vdout1_12ck510 FIND v(dout1_12) AT=260.025n

.meas tran vdout1_13ck510 FIND v(dout1_13) AT=260.025n

.meas tran vdout1_14ck510 FIND v(dout1_14) AT=260.025n

.meas tran vdout1_15ck510 FIND v(dout1_15) AT=260.025n

.meas tran vdout1_16ck510 FIND v(dout1_16) AT=260.025n

.meas tran vdout1_17ck510 FIND v(dout1_17) AT=260.025n

.meas tran vdout1_18ck510 FIND v(dout1_18) AT=260.025n

.meas tran vdout1_19ck510 FIND v(dout1_19) AT=260.025n

.meas tran vdout1_20ck510 FIND v(dout1_20) AT=260.025n

.meas tran vdout1_21ck510 FIND v(dout1_21) AT=260.025n

.meas tran vdout1_22ck510 FIND v(dout1_22) AT=260.025n

.meas tran vdout1_23ck510 FIND v(dout1_23) AT=260.025n

.meas tran vdout1_24ck510 FIND v(dout1_24) AT=260.025n

.meas tran vdout1_25ck510 FIND v(dout1_25) AT=260.025n

.meas tran vdout1_26ck510 FIND v(dout1_26) AT=260.025n

.meas tran vdout1_27ck510 FIND v(dout1_27) AT=260.025n

.meas tran vdout1_28ck510 FIND v(dout1_28) AT=260.025n

.meas tran vdout1_29ck510 FIND v(dout1_29) AT=260.025n

.meas tran vdout1_30ck510 FIND v(dout1_30) AT=260.025n

.meas tran vdout1_31ck510 FIND v(dout1_31) AT=260.025n

.meas tran vdout1_32ck510 FIND v(dout1_32) AT=260.025n

.meas tran vdout1_33ck510 FIND v(dout1_33) AT=260.025n

.meas tran vdout1_34ck510 FIND v(dout1_34) AT=260.025n

.meas tran vdout1_35ck510 FIND v(dout1_35) AT=260.025n

.meas tran vdout1_36ck510 FIND v(dout1_36) AT=260.025n

.meas tran vdout1_37ck510 FIND v(dout1_37) AT=260.025n

.meas tran vdout1_38ck510 FIND v(dout1_38) AT=260.025n

.meas tran vdout1_39ck510 FIND v(dout1_39) AT=260.025n

.meas tran vdout1_40ck510 FIND v(dout1_40) AT=260.025n

.meas tran vdout1_41ck510 FIND v(dout1_41) AT=260.025n

.meas tran vdout1_42ck510 FIND v(dout1_42) AT=260.025n

.meas tran vdout1_43ck510 FIND v(dout1_43) AT=260.025n

.meas tran vdout1_44ck510 FIND v(dout1_44) AT=260.025n

.meas tran vdout1_45ck510 FIND v(dout1_45) AT=260.025n

.meas tran vdout1_46ck510 FIND v(dout1_46) AT=260.025n

.meas tran vdout1_47ck510 FIND v(dout1_47) AT=260.025n

.meas tran vdout1_48ck510 FIND v(dout1_48) AT=260.025n

.meas tran vdout1_49ck510 FIND v(dout1_49) AT=260.025n

.meas tran vdout1_50ck510 FIND v(dout1_50) AT=260.025n

.meas tran vdout1_51ck510 FIND v(dout1_51) AT=260.025n

.meas tran vdout1_52ck510 FIND v(dout1_52) AT=260.025n

.meas tran vdout1_53ck510 FIND v(dout1_53) AT=260.025n

.meas tran vdout1_54ck510 FIND v(dout1_54) AT=260.025n

.meas tran vdout1_55ck510 FIND v(dout1_55) AT=260.025n

.meas tran vdout1_56ck510 FIND v(dout1_56) AT=260.025n

.meas tran vdout1_57ck510 FIND v(dout1_57) AT=260.025n

.meas tran vdout1_58ck510 FIND v(dout1_58) AT=260.025n

.meas tran vdout1_59ck510 FIND v(dout1_59) AT=260.025n

.meas tran vdout1_60ck510 FIND v(dout1_60) AT=260.025n

.meas tran vdout1_61ck510 FIND v(dout1_61) AT=260.025n

.meas tran vdout1_62ck510 FIND v(dout1_62) AT=260.025n

.meas tran vdout1_63ck510 FIND v(dout1_63) AT=260.025n

.meas tran vdout1_64ck510 FIND v(dout1_64) AT=260.025n

.meas tran vdout1_65ck510 FIND v(dout1_65) AT=260.025n

.meas tran vdout1_66ck510 FIND v(dout1_66) AT=260.025n

.meas tran vdout1_67ck510 FIND v(dout1_67) AT=260.025n

.meas tran vdout1_68ck510 FIND v(dout1_68) AT=260.025n

.meas tran vdout1_69ck510 FIND v(dout1_69) AT=260.025n

.meas tran vdout1_70ck510 FIND v(dout1_70) AT=260.025n

.meas tran vdout1_71ck510 FIND v(dout1_71) AT=260.025n

.meas tran vdout1_72ck510 FIND v(dout1_72) AT=260.025n

.meas tran vdout1_73ck510 FIND v(dout1_73) AT=260.025n

.meas tran vdout1_74ck510 FIND v(dout1_74) AT=260.025n

.meas tran vdout1_75ck510 FIND v(dout1_75) AT=260.025n

.meas tran vdout1_76ck510 FIND v(dout1_76) AT=260.025n

.meas tran vdout1_77ck510 FIND v(dout1_77) AT=260.025n

.meas tran vdout1_78ck510 FIND v(dout1_78) AT=260.025n

.meas tran vdout1_79ck510 FIND v(dout1_79) AT=260.025n

.meas tran vdout1_80ck510 FIND v(dout1_80) AT=260.025n

.meas tran vdout1_81ck510 FIND v(dout1_81) AT=260.025n

.meas tran vdout1_82ck510 FIND v(dout1_82) AT=260.025n

.meas tran vdout1_83ck510 FIND v(dout1_83) AT=260.025n

.meas tran vdout1_84ck510 FIND v(dout1_84) AT=260.025n

.meas tran vdout1_85ck510 FIND v(dout1_85) AT=260.025n

.meas tran vdout1_86ck510 FIND v(dout1_86) AT=260.025n

.meas tran vdout1_87ck510 FIND v(dout1_87) AT=260.025n

.meas tran vdout1_88ck510 FIND v(dout1_88) AT=260.025n

.meas tran vdout1_89ck510 FIND v(dout1_89) AT=260.025n

.meas tran vdout1_90ck510 FIND v(dout1_90) AT=260.025n

.meas tran vdout1_91ck510 FIND v(dout1_91) AT=260.025n

.meas tran vdout1_92ck510 FIND v(dout1_92) AT=260.025n

.meas tran vdout1_93ck510 FIND v(dout1_93) AT=260.025n

.meas tran vdout1_94ck510 FIND v(dout1_94) AT=260.025n

.meas tran vdout1_95ck510 FIND v(dout1_95) AT=260.025n

.meas tran vdout1_96ck510 FIND v(dout1_96) AT=260.025n

.meas tran vdout1_97ck510 FIND v(dout1_97) AT=260.025n

.meas tran vdout1_98ck510 FIND v(dout1_98) AT=260.025n

.meas tran vdout1_99ck510 FIND v(dout1_99) AT=260.025n

.meas tran vdout1_100ck510 FIND v(dout1_100) AT=260.025n

.meas tran vdout1_101ck510 FIND v(dout1_101) AT=260.025n

.meas tran vdout1_102ck510 FIND v(dout1_102) AT=260.025n

.meas tran vdout1_103ck510 FIND v(dout1_103) AT=260.025n

.meas tran vdout1_104ck510 FIND v(dout1_104) AT=260.025n

.meas tran vdout1_105ck510 FIND v(dout1_105) AT=260.025n

.meas tran vdout1_106ck510 FIND v(dout1_106) AT=260.025n

.meas tran vdout1_107ck510 FIND v(dout1_107) AT=260.025n

.meas tran vdout1_108ck510 FIND v(dout1_108) AT=260.025n

.meas tran vdout1_109ck510 FIND v(dout1_109) AT=260.025n

.meas tran vdout1_110ck510 FIND v(dout1_110) AT=260.025n

.meas tran vdout1_111ck510 FIND v(dout1_111) AT=260.025n

.meas tran vdout1_112ck510 FIND v(dout1_112) AT=260.025n

.meas tran vdout1_113ck510 FIND v(dout1_113) AT=260.025n

.meas tran vdout1_114ck510 FIND v(dout1_114) AT=260.025n

.meas tran vdout1_115ck510 FIND v(dout1_115) AT=260.025n

.meas tran vdout1_116ck510 FIND v(dout1_116) AT=260.025n

.meas tran vdout1_117ck510 FIND v(dout1_117) AT=260.025n

.meas tran vdout1_118ck510 FIND v(dout1_118) AT=260.025n

.meas tran vdout1_119ck510 FIND v(dout1_119) AT=260.025n

.meas tran vdout1_120ck510 FIND v(dout1_120) AT=260.025n

.meas tran vdout1_121ck510 FIND v(dout1_121) AT=260.025n

.meas tran vdout1_122ck510 FIND v(dout1_122) AT=260.025n

.meas tran vdout1_123ck510 FIND v(dout1_123) AT=260.025n

.meas tran vdout1_124ck510 FIND v(dout1_124) AT=260.025n

.meas tran vdout1_125ck510 FIND v(dout1_125) AT=260.025n

.meas tran vdout1_126ck510 FIND v(dout1_126) AT=260.025n

.meas tran vdout1_127ck510 FIND v(dout1_127) AT=260.025n

.meas tran vdout1_0ck540 FIND v(dout1_0) AT=275.025n

.meas tran vdout1_1ck540 FIND v(dout1_1) AT=275.025n

.meas tran vdout1_2ck540 FIND v(dout1_2) AT=275.025n

.meas tran vdout1_3ck540 FIND v(dout1_3) AT=275.025n

.meas tran vdout1_4ck540 FIND v(dout1_4) AT=275.025n

.meas tran vdout1_5ck540 FIND v(dout1_5) AT=275.025n

.meas tran vdout1_6ck540 FIND v(dout1_6) AT=275.025n

.meas tran vdout1_7ck540 FIND v(dout1_7) AT=275.025n

.meas tran vdout1_8ck540 FIND v(dout1_8) AT=275.025n

.meas tran vdout1_9ck540 FIND v(dout1_9) AT=275.025n

.meas tran vdout1_10ck540 FIND v(dout1_10) AT=275.025n

.meas tran vdout1_11ck540 FIND v(dout1_11) AT=275.025n

.meas tran vdout1_12ck540 FIND v(dout1_12) AT=275.025n

.meas tran vdout1_13ck540 FIND v(dout1_13) AT=275.025n

.meas tran vdout1_14ck540 FIND v(dout1_14) AT=275.025n

.meas tran vdout1_15ck540 FIND v(dout1_15) AT=275.025n

.meas tran vdout1_16ck540 FIND v(dout1_16) AT=275.025n

.meas tran vdout1_17ck540 FIND v(dout1_17) AT=275.025n

.meas tran vdout1_18ck540 FIND v(dout1_18) AT=275.025n

.meas tran vdout1_19ck540 FIND v(dout1_19) AT=275.025n

.meas tran vdout1_20ck540 FIND v(dout1_20) AT=275.025n

.meas tran vdout1_21ck540 FIND v(dout1_21) AT=275.025n

.meas tran vdout1_22ck540 FIND v(dout1_22) AT=275.025n

.meas tran vdout1_23ck540 FIND v(dout1_23) AT=275.025n

.meas tran vdout1_24ck540 FIND v(dout1_24) AT=275.025n

.meas tran vdout1_25ck540 FIND v(dout1_25) AT=275.025n

.meas tran vdout1_26ck540 FIND v(dout1_26) AT=275.025n

.meas tran vdout1_27ck540 FIND v(dout1_27) AT=275.025n

.meas tran vdout1_28ck540 FIND v(dout1_28) AT=275.025n

.meas tran vdout1_29ck540 FIND v(dout1_29) AT=275.025n

.meas tran vdout1_30ck540 FIND v(dout1_30) AT=275.025n

.meas tran vdout1_31ck540 FIND v(dout1_31) AT=275.025n

.meas tran vdout1_32ck540 FIND v(dout1_32) AT=275.025n

.meas tran vdout1_33ck540 FIND v(dout1_33) AT=275.025n

.meas tran vdout1_34ck540 FIND v(dout1_34) AT=275.025n

.meas tran vdout1_35ck540 FIND v(dout1_35) AT=275.025n

.meas tran vdout1_36ck540 FIND v(dout1_36) AT=275.025n

.meas tran vdout1_37ck540 FIND v(dout1_37) AT=275.025n

.meas tran vdout1_38ck540 FIND v(dout1_38) AT=275.025n

.meas tran vdout1_39ck540 FIND v(dout1_39) AT=275.025n

.meas tran vdout1_40ck540 FIND v(dout1_40) AT=275.025n

.meas tran vdout1_41ck540 FIND v(dout1_41) AT=275.025n

.meas tran vdout1_42ck540 FIND v(dout1_42) AT=275.025n

.meas tran vdout1_43ck540 FIND v(dout1_43) AT=275.025n

.meas tran vdout1_44ck540 FIND v(dout1_44) AT=275.025n

.meas tran vdout1_45ck540 FIND v(dout1_45) AT=275.025n

.meas tran vdout1_46ck540 FIND v(dout1_46) AT=275.025n

.meas tran vdout1_47ck540 FIND v(dout1_47) AT=275.025n

.meas tran vdout1_48ck540 FIND v(dout1_48) AT=275.025n

.meas tran vdout1_49ck540 FIND v(dout1_49) AT=275.025n

.meas tran vdout1_50ck540 FIND v(dout1_50) AT=275.025n

.meas tran vdout1_51ck540 FIND v(dout1_51) AT=275.025n

.meas tran vdout1_52ck540 FIND v(dout1_52) AT=275.025n

.meas tran vdout1_53ck540 FIND v(dout1_53) AT=275.025n

.meas tran vdout1_54ck540 FIND v(dout1_54) AT=275.025n

.meas tran vdout1_55ck540 FIND v(dout1_55) AT=275.025n

.meas tran vdout1_56ck540 FIND v(dout1_56) AT=275.025n

.meas tran vdout1_57ck540 FIND v(dout1_57) AT=275.025n

.meas tran vdout1_58ck540 FIND v(dout1_58) AT=275.025n

.meas tran vdout1_59ck540 FIND v(dout1_59) AT=275.025n

.meas tran vdout1_60ck540 FIND v(dout1_60) AT=275.025n

.meas tran vdout1_61ck540 FIND v(dout1_61) AT=275.025n

.meas tran vdout1_62ck540 FIND v(dout1_62) AT=275.025n

.meas tran vdout1_63ck540 FIND v(dout1_63) AT=275.025n

.meas tran vdout1_64ck540 FIND v(dout1_64) AT=275.025n

.meas tran vdout1_65ck540 FIND v(dout1_65) AT=275.025n

.meas tran vdout1_66ck540 FIND v(dout1_66) AT=275.025n

.meas tran vdout1_67ck540 FIND v(dout1_67) AT=275.025n

.meas tran vdout1_68ck540 FIND v(dout1_68) AT=275.025n

.meas tran vdout1_69ck540 FIND v(dout1_69) AT=275.025n

.meas tran vdout1_70ck540 FIND v(dout1_70) AT=275.025n

.meas tran vdout1_71ck540 FIND v(dout1_71) AT=275.025n

.meas tran vdout1_72ck540 FIND v(dout1_72) AT=275.025n

.meas tran vdout1_73ck540 FIND v(dout1_73) AT=275.025n

.meas tran vdout1_74ck540 FIND v(dout1_74) AT=275.025n

.meas tran vdout1_75ck540 FIND v(dout1_75) AT=275.025n

.meas tran vdout1_76ck540 FIND v(dout1_76) AT=275.025n

.meas tran vdout1_77ck540 FIND v(dout1_77) AT=275.025n

.meas tran vdout1_78ck540 FIND v(dout1_78) AT=275.025n

.meas tran vdout1_79ck540 FIND v(dout1_79) AT=275.025n

.meas tran vdout1_80ck540 FIND v(dout1_80) AT=275.025n

.meas tran vdout1_81ck540 FIND v(dout1_81) AT=275.025n

.meas tran vdout1_82ck540 FIND v(dout1_82) AT=275.025n

.meas tran vdout1_83ck540 FIND v(dout1_83) AT=275.025n

.meas tran vdout1_84ck540 FIND v(dout1_84) AT=275.025n

.meas tran vdout1_85ck540 FIND v(dout1_85) AT=275.025n

.meas tran vdout1_86ck540 FIND v(dout1_86) AT=275.025n

.meas tran vdout1_87ck540 FIND v(dout1_87) AT=275.025n

.meas tran vdout1_88ck540 FIND v(dout1_88) AT=275.025n

.meas tran vdout1_89ck540 FIND v(dout1_89) AT=275.025n

.meas tran vdout1_90ck540 FIND v(dout1_90) AT=275.025n

.meas tran vdout1_91ck540 FIND v(dout1_91) AT=275.025n

.meas tran vdout1_92ck540 FIND v(dout1_92) AT=275.025n

.meas tran vdout1_93ck540 FIND v(dout1_93) AT=275.025n

.meas tran vdout1_94ck540 FIND v(dout1_94) AT=275.025n

.meas tran vdout1_95ck540 FIND v(dout1_95) AT=275.025n

.meas tran vdout1_96ck540 FIND v(dout1_96) AT=275.025n

.meas tran vdout1_97ck540 FIND v(dout1_97) AT=275.025n

.meas tran vdout1_98ck540 FIND v(dout1_98) AT=275.025n

.meas tran vdout1_99ck540 FIND v(dout1_99) AT=275.025n

.meas tran vdout1_100ck540 FIND v(dout1_100) AT=275.025n

.meas tran vdout1_101ck540 FIND v(dout1_101) AT=275.025n

.meas tran vdout1_102ck540 FIND v(dout1_102) AT=275.025n

.meas tran vdout1_103ck540 FIND v(dout1_103) AT=275.025n

.meas tran vdout1_104ck540 FIND v(dout1_104) AT=275.025n

.meas tran vdout1_105ck540 FIND v(dout1_105) AT=275.025n

.meas tran vdout1_106ck540 FIND v(dout1_106) AT=275.025n

.meas tran vdout1_107ck540 FIND v(dout1_107) AT=275.025n

.meas tran vdout1_108ck540 FIND v(dout1_108) AT=275.025n

.meas tran vdout1_109ck540 FIND v(dout1_109) AT=275.025n

.meas tran vdout1_110ck540 FIND v(dout1_110) AT=275.025n

.meas tran vdout1_111ck540 FIND v(dout1_111) AT=275.025n

.meas tran vdout1_112ck540 FIND v(dout1_112) AT=275.025n

.meas tran vdout1_113ck540 FIND v(dout1_113) AT=275.025n

.meas tran vdout1_114ck540 FIND v(dout1_114) AT=275.025n

.meas tran vdout1_115ck540 FIND v(dout1_115) AT=275.025n

.meas tran vdout1_116ck540 FIND v(dout1_116) AT=275.025n

.meas tran vdout1_117ck540 FIND v(dout1_117) AT=275.025n

.meas tran vdout1_118ck540 FIND v(dout1_118) AT=275.025n

.meas tran vdout1_119ck540 FIND v(dout1_119) AT=275.025n

.meas tran vdout1_120ck540 FIND v(dout1_120) AT=275.025n

.meas tran vdout1_121ck540 FIND v(dout1_121) AT=275.025n

.meas tran vdout1_122ck540 FIND v(dout1_122) AT=275.025n

.meas tran vdout1_123ck540 FIND v(dout1_123) AT=275.025n

.meas tran vdout1_124ck540 FIND v(dout1_124) AT=275.025n

.meas tran vdout1_125ck540 FIND v(dout1_125) AT=275.025n

.meas tran vdout1_126ck540 FIND v(dout1_126) AT=275.025n

.meas tran vdout1_127ck540 FIND v(dout1_127) AT=275.025n

.meas tran vdout1_0ck610 FIND v(dout1_0) AT=310.025n

.meas tran vdout1_1ck610 FIND v(dout1_1) AT=310.025n

.meas tran vdout1_2ck610 FIND v(dout1_2) AT=310.025n

.meas tran vdout1_3ck610 FIND v(dout1_3) AT=310.025n

.meas tran vdout1_4ck610 FIND v(dout1_4) AT=310.025n

.meas tran vdout1_5ck610 FIND v(dout1_5) AT=310.025n

.meas tran vdout1_6ck610 FIND v(dout1_6) AT=310.025n

.meas tran vdout1_7ck610 FIND v(dout1_7) AT=310.025n

.meas tran vdout1_8ck610 FIND v(dout1_8) AT=310.025n

.meas tran vdout1_9ck610 FIND v(dout1_9) AT=310.025n

.meas tran vdout1_10ck610 FIND v(dout1_10) AT=310.025n

.meas tran vdout1_11ck610 FIND v(dout1_11) AT=310.025n

.meas tran vdout1_12ck610 FIND v(dout1_12) AT=310.025n

.meas tran vdout1_13ck610 FIND v(dout1_13) AT=310.025n

.meas tran vdout1_14ck610 FIND v(dout1_14) AT=310.025n

.meas tran vdout1_15ck610 FIND v(dout1_15) AT=310.025n

.meas tran vdout1_16ck610 FIND v(dout1_16) AT=310.025n

.meas tran vdout1_17ck610 FIND v(dout1_17) AT=310.025n

.meas tran vdout1_18ck610 FIND v(dout1_18) AT=310.025n

.meas tran vdout1_19ck610 FIND v(dout1_19) AT=310.025n

.meas tran vdout1_20ck610 FIND v(dout1_20) AT=310.025n

.meas tran vdout1_21ck610 FIND v(dout1_21) AT=310.025n

.meas tran vdout1_22ck610 FIND v(dout1_22) AT=310.025n

.meas tran vdout1_23ck610 FIND v(dout1_23) AT=310.025n

.meas tran vdout1_24ck610 FIND v(dout1_24) AT=310.025n

.meas tran vdout1_25ck610 FIND v(dout1_25) AT=310.025n

.meas tran vdout1_26ck610 FIND v(dout1_26) AT=310.025n

.meas tran vdout1_27ck610 FIND v(dout1_27) AT=310.025n

.meas tran vdout1_28ck610 FIND v(dout1_28) AT=310.025n

.meas tran vdout1_29ck610 FIND v(dout1_29) AT=310.025n

.meas tran vdout1_30ck610 FIND v(dout1_30) AT=310.025n

.meas tran vdout1_31ck610 FIND v(dout1_31) AT=310.025n

.meas tran vdout1_32ck610 FIND v(dout1_32) AT=310.025n

.meas tran vdout1_33ck610 FIND v(dout1_33) AT=310.025n

.meas tran vdout1_34ck610 FIND v(dout1_34) AT=310.025n

.meas tran vdout1_35ck610 FIND v(dout1_35) AT=310.025n

.meas tran vdout1_36ck610 FIND v(dout1_36) AT=310.025n

.meas tran vdout1_37ck610 FIND v(dout1_37) AT=310.025n

.meas tran vdout1_38ck610 FIND v(dout1_38) AT=310.025n

.meas tran vdout1_39ck610 FIND v(dout1_39) AT=310.025n

.meas tran vdout1_40ck610 FIND v(dout1_40) AT=310.025n

.meas tran vdout1_41ck610 FIND v(dout1_41) AT=310.025n

.meas tran vdout1_42ck610 FIND v(dout1_42) AT=310.025n

.meas tran vdout1_43ck610 FIND v(dout1_43) AT=310.025n

.meas tran vdout1_44ck610 FIND v(dout1_44) AT=310.025n

.meas tran vdout1_45ck610 FIND v(dout1_45) AT=310.025n

.meas tran vdout1_46ck610 FIND v(dout1_46) AT=310.025n

.meas tran vdout1_47ck610 FIND v(dout1_47) AT=310.025n

.meas tran vdout1_48ck610 FIND v(dout1_48) AT=310.025n

.meas tran vdout1_49ck610 FIND v(dout1_49) AT=310.025n

.meas tran vdout1_50ck610 FIND v(dout1_50) AT=310.025n

.meas tran vdout1_51ck610 FIND v(dout1_51) AT=310.025n

.meas tran vdout1_52ck610 FIND v(dout1_52) AT=310.025n

.meas tran vdout1_53ck610 FIND v(dout1_53) AT=310.025n

.meas tran vdout1_54ck610 FIND v(dout1_54) AT=310.025n

.meas tran vdout1_55ck610 FIND v(dout1_55) AT=310.025n

.meas tran vdout1_56ck610 FIND v(dout1_56) AT=310.025n

.meas tran vdout1_57ck610 FIND v(dout1_57) AT=310.025n

.meas tran vdout1_58ck610 FIND v(dout1_58) AT=310.025n

.meas tran vdout1_59ck610 FIND v(dout1_59) AT=310.025n

.meas tran vdout1_60ck610 FIND v(dout1_60) AT=310.025n

.meas tran vdout1_61ck610 FIND v(dout1_61) AT=310.025n

.meas tran vdout1_62ck610 FIND v(dout1_62) AT=310.025n

.meas tran vdout1_63ck610 FIND v(dout1_63) AT=310.025n

.meas tran vdout1_64ck610 FIND v(dout1_64) AT=310.025n

.meas tran vdout1_65ck610 FIND v(dout1_65) AT=310.025n

.meas tran vdout1_66ck610 FIND v(dout1_66) AT=310.025n

.meas tran vdout1_67ck610 FIND v(dout1_67) AT=310.025n

.meas tran vdout1_68ck610 FIND v(dout1_68) AT=310.025n

.meas tran vdout1_69ck610 FIND v(dout1_69) AT=310.025n

.meas tran vdout1_70ck610 FIND v(dout1_70) AT=310.025n

.meas tran vdout1_71ck610 FIND v(dout1_71) AT=310.025n

.meas tran vdout1_72ck610 FIND v(dout1_72) AT=310.025n

.meas tran vdout1_73ck610 FIND v(dout1_73) AT=310.025n

.meas tran vdout1_74ck610 FIND v(dout1_74) AT=310.025n

.meas tran vdout1_75ck610 FIND v(dout1_75) AT=310.025n

.meas tran vdout1_76ck610 FIND v(dout1_76) AT=310.025n

.meas tran vdout1_77ck610 FIND v(dout1_77) AT=310.025n

.meas tran vdout1_78ck610 FIND v(dout1_78) AT=310.025n

.meas tran vdout1_79ck610 FIND v(dout1_79) AT=310.025n

.meas tran vdout1_80ck610 FIND v(dout1_80) AT=310.025n

.meas tran vdout1_81ck610 FIND v(dout1_81) AT=310.025n

.meas tran vdout1_82ck610 FIND v(dout1_82) AT=310.025n

.meas tran vdout1_83ck610 FIND v(dout1_83) AT=310.025n

.meas tran vdout1_84ck610 FIND v(dout1_84) AT=310.025n

.meas tran vdout1_85ck610 FIND v(dout1_85) AT=310.025n

.meas tran vdout1_86ck610 FIND v(dout1_86) AT=310.025n

.meas tran vdout1_87ck610 FIND v(dout1_87) AT=310.025n

.meas tran vdout1_88ck610 FIND v(dout1_88) AT=310.025n

.meas tran vdout1_89ck610 FIND v(dout1_89) AT=310.025n

.meas tran vdout1_90ck610 FIND v(dout1_90) AT=310.025n

.meas tran vdout1_91ck610 FIND v(dout1_91) AT=310.025n

.meas tran vdout1_92ck610 FIND v(dout1_92) AT=310.025n

.meas tran vdout1_93ck610 FIND v(dout1_93) AT=310.025n

.meas tran vdout1_94ck610 FIND v(dout1_94) AT=310.025n

.meas tran vdout1_95ck610 FIND v(dout1_95) AT=310.025n

.meas tran vdout1_96ck610 FIND v(dout1_96) AT=310.025n

.meas tran vdout1_97ck610 FIND v(dout1_97) AT=310.025n

.meas tran vdout1_98ck610 FIND v(dout1_98) AT=310.025n

.meas tran vdout1_99ck610 FIND v(dout1_99) AT=310.025n

.meas tran vdout1_100ck610 FIND v(dout1_100) AT=310.025n

.meas tran vdout1_101ck610 FIND v(dout1_101) AT=310.025n

.meas tran vdout1_102ck610 FIND v(dout1_102) AT=310.025n

.meas tran vdout1_103ck610 FIND v(dout1_103) AT=310.025n

.meas tran vdout1_104ck610 FIND v(dout1_104) AT=310.025n

.meas tran vdout1_105ck610 FIND v(dout1_105) AT=310.025n

.meas tran vdout1_106ck610 FIND v(dout1_106) AT=310.025n

.meas tran vdout1_107ck610 FIND v(dout1_107) AT=310.025n

.meas tran vdout1_108ck610 FIND v(dout1_108) AT=310.025n

.meas tran vdout1_109ck610 FIND v(dout1_109) AT=310.025n

.meas tran vdout1_110ck610 FIND v(dout1_110) AT=310.025n

.meas tran vdout1_111ck610 FIND v(dout1_111) AT=310.025n

.meas tran vdout1_112ck610 FIND v(dout1_112) AT=310.025n

.meas tran vdout1_113ck610 FIND v(dout1_113) AT=310.025n

.meas tran vdout1_114ck610 FIND v(dout1_114) AT=310.025n

.meas tran vdout1_115ck610 FIND v(dout1_115) AT=310.025n

.meas tran vdout1_116ck610 FIND v(dout1_116) AT=310.025n

.meas tran vdout1_117ck610 FIND v(dout1_117) AT=310.025n

.meas tran vdout1_118ck610 FIND v(dout1_118) AT=310.025n

.meas tran vdout1_119ck610 FIND v(dout1_119) AT=310.025n

.meas tran vdout1_120ck610 FIND v(dout1_120) AT=310.025n

.meas tran vdout1_121ck610 FIND v(dout1_121) AT=310.025n

.meas tran vdout1_122ck610 FIND v(dout1_122) AT=310.025n

.meas tran vdout1_123ck610 FIND v(dout1_123) AT=310.025n

.meas tran vdout1_124ck610 FIND v(dout1_124) AT=310.025n

.meas tran vdout1_125ck610 FIND v(dout1_125) AT=310.025n

.meas tran vdout1_126ck610 FIND v(dout1_126) AT=310.025n

.meas tran vdout1_127ck610 FIND v(dout1_127) AT=310.025n

.meas tran vdout1_0ck620 FIND v(dout1_0) AT=315.025n

.meas tran vdout1_1ck620 FIND v(dout1_1) AT=315.025n

.meas tran vdout1_2ck620 FIND v(dout1_2) AT=315.025n

.meas tran vdout1_3ck620 FIND v(dout1_3) AT=315.025n

.meas tran vdout1_4ck620 FIND v(dout1_4) AT=315.025n

.meas tran vdout1_5ck620 FIND v(dout1_5) AT=315.025n

.meas tran vdout1_6ck620 FIND v(dout1_6) AT=315.025n

.meas tran vdout1_7ck620 FIND v(dout1_7) AT=315.025n

.meas tran vdout1_8ck620 FIND v(dout1_8) AT=315.025n

.meas tran vdout1_9ck620 FIND v(dout1_9) AT=315.025n

.meas tran vdout1_10ck620 FIND v(dout1_10) AT=315.025n

.meas tran vdout1_11ck620 FIND v(dout1_11) AT=315.025n

.meas tran vdout1_12ck620 FIND v(dout1_12) AT=315.025n

.meas tran vdout1_13ck620 FIND v(dout1_13) AT=315.025n

.meas tran vdout1_14ck620 FIND v(dout1_14) AT=315.025n

.meas tran vdout1_15ck620 FIND v(dout1_15) AT=315.025n

.meas tran vdout1_16ck620 FIND v(dout1_16) AT=315.025n

.meas tran vdout1_17ck620 FIND v(dout1_17) AT=315.025n

.meas tran vdout1_18ck620 FIND v(dout1_18) AT=315.025n

.meas tran vdout1_19ck620 FIND v(dout1_19) AT=315.025n

.meas tran vdout1_20ck620 FIND v(dout1_20) AT=315.025n

.meas tran vdout1_21ck620 FIND v(dout1_21) AT=315.025n

.meas tran vdout1_22ck620 FIND v(dout1_22) AT=315.025n

.meas tran vdout1_23ck620 FIND v(dout1_23) AT=315.025n

.meas tran vdout1_24ck620 FIND v(dout1_24) AT=315.025n

.meas tran vdout1_25ck620 FIND v(dout1_25) AT=315.025n

.meas tran vdout1_26ck620 FIND v(dout1_26) AT=315.025n

.meas tran vdout1_27ck620 FIND v(dout1_27) AT=315.025n

.meas tran vdout1_28ck620 FIND v(dout1_28) AT=315.025n

.meas tran vdout1_29ck620 FIND v(dout1_29) AT=315.025n

.meas tran vdout1_30ck620 FIND v(dout1_30) AT=315.025n

.meas tran vdout1_31ck620 FIND v(dout1_31) AT=315.025n

.meas tran vdout1_32ck620 FIND v(dout1_32) AT=315.025n

.meas tran vdout1_33ck620 FIND v(dout1_33) AT=315.025n

.meas tran vdout1_34ck620 FIND v(dout1_34) AT=315.025n

.meas tran vdout1_35ck620 FIND v(dout1_35) AT=315.025n

.meas tran vdout1_36ck620 FIND v(dout1_36) AT=315.025n

.meas tran vdout1_37ck620 FIND v(dout1_37) AT=315.025n

.meas tran vdout1_38ck620 FIND v(dout1_38) AT=315.025n

.meas tran vdout1_39ck620 FIND v(dout1_39) AT=315.025n

.meas tran vdout1_40ck620 FIND v(dout1_40) AT=315.025n

.meas tran vdout1_41ck620 FIND v(dout1_41) AT=315.025n

.meas tran vdout1_42ck620 FIND v(dout1_42) AT=315.025n

.meas tran vdout1_43ck620 FIND v(dout1_43) AT=315.025n

.meas tran vdout1_44ck620 FIND v(dout1_44) AT=315.025n

.meas tran vdout1_45ck620 FIND v(dout1_45) AT=315.025n

.meas tran vdout1_46ck620 FIND v(dout1_46) AT=315.025n

.meas tran vdout1_47ck620 FIND v(dout1_47) AT=315.025n

.meas tran vdout1_48ck620 FIND v(dout1_48) AT=315.025n

.meas tran vdout1_49ck620 FIND v(dout1_49) AT=315.025n

.meas tran vdout1_50ck620 FIND v(dout1_50) AT=315.025n

.meas tran vdout1_51ck620 FIND v(dout1_51) AT=315.025n

.meas tran vdout1_52ck620 FIND v(dout1_52) AT=315.025n

.meas tran vdout1_53ck620 FIND v(dout1_53) AT=315.025n

.meas tran vdout1_54ck620 FIND v(dout1_54) AT=315.025n

.meas tran vdout1_55ck620 FIND v(dout1_55) AT=315.025n

.meas tran vdout1_56ck620 FIND v(dout1_56) AT=315.025n

.meas tran vdout1_57ck620 FIND v(dout1_57) AT=315.025n

.meas tran vdout1_58ck620 FIND v(dout1_58) AT=315.025n

.meas tran vdout1_59ck620 FIND v(dout1_59) AT=315.025n

.meas tran vdout1_60ck620 FIND v(dout1_60) AT=315.025n

.meas tran vdout1_61ck620 FIND v(dout1_61) AT=315.025n

.meas tran vdout1_62ck620 FIND v(dout1_62) AT=315.025n

.meas tran vdout1_63ck620 FIND v(dout1_63) AT=315.025n

.meas tran vdout1_64ck620 FIND v(dout1_64) AT=315.025n

.meas tran vdout1_65ck620 FIND v(dout1_65) AT=315.025n

.meas tran vdout1_66ck620 FIND v(dout1_66) AT=315.025n

.meas tran vdout1_67ck620 FIND v(dout1_67) AT=315.025n

.meas tran vdout1_68ck620 FIND v(dout1_68) AT=315.025n

.meas tran vdout1_69ck620 FIND v(dout1_69) AT=315.025n

.meas tran vdout1_70ck620 FIND v(dout1_70) AT=315.025n

.meas tran vdout1_71ck620 FIND v(dout1_71) AT=315.025n

.meas tran vdout1_72ck620 FIND v(dout1_72) AT=315.025n

.meas tran vdout1_73ck620 FIND v(dout1_73) AT=315.025n

.meas tran vdout1_74ck620 FIND v(dout1_74) AT=315.025n

.meas tran vdout1_75ck620 FIND v(dout1_75) AT=315.025n

.meas tran vdout1_76ck620 FIND v(dout1_76) AT=315.025n

.meas tran vdout1_77ck620 FIND v(dout1_77) AT=315.025n

.meas tran vdout1_78ck620 FIND v(dout1_78) AT=315.025n

.meas tran vdout1_79ck620 FIND v(dout1_79) AT=315.025n

.meas tran vdout1_80ck620 FIND v(dout1_80) AT=315.025n

.meas tran vdout1_81ck620 FIND v(dout1_81) AT=315.025n

.meas tran vdout1_82ck620 FIND v(dout1_82) AT=315.025n

.meas tran vdout1_83ck620 FIND v(dout1_83) AT=315.025n

.meas tran vdout1_84ck620 FIND v(dout1_84) AT=315.025n

.meas tran vdout1_85ck620 FIND v(dout1_85) AT=315.025n

.meas tran vdout1_86ck620 FIND v(dout1_86) AT=315.025n

.meas tran vdout1_87ck620 FIND v(dout1_87) AT=315.025n

.meas tran vdout1_88ck620 FIND v(dout1_88) AT=315.025n

.meas tran vdout1_89ck620 FIND v(dout1_89) AT=315.025n

.meas tran vdout1_90ck620 FIND v(dout1_90) AT=315.025n

.meas tran vdout1_91ck620 FIND v(dout1_91) AT=315.025n

.meas tran vdout1_92ck620 FIND v(dout1_92) AT=315.025n

.meas tran vdout1_93ck620 FIND v(dout1_93) AT=315.025n

.meas tran vdout1_94ck620 FIND v(dout1_94) AT=315.025n

.meas tran vdout1_95ck620 FIND v(dout1_95) AT=315.025n

.meas tran vdout1_96ck620 FIND v(dout1_96) AT=315.025n

.meas tran vdout1_97ck620 FIND v(dout1_97) AT=315.025n

.meas tran vdout1_98ck620 FIND v(dout1_98) AT=315.025n

.meas tran vdout1_99ck620 FIND v(dout1_99) AT=315.025n

.meas tran vdout1_100ck620 FIND v(dout1_100) AT=315.025n

.meas tran vdout1_101ck620 FIND v(dout1_101) AT=315.025n

.meas tran vdout1_102ck620 FIND v(dout1_102) AT=315.025n

.meas tran vdout1_103ck620 FIND v(dout1_103) AT=315.025n

.meas tran vdout1_104ck620 FIND v(dout1_104) AT=315.025n

.meas tran vdout1_105ck620 FIND v(dout1_105) AT=315.025n

.meas tran vdout1_106ck620 FIND v(dout1_106) AT=315.025n

.meas tran vdout1_107ck620 FIND v(dout1_107) AT=315.025n

.meas tran vdout1_108ck620 FIND v(dout1_108) AT=315.025n

.meas tran vdout1_109ck620 FIND v(dout1_109) AT=315.025n

.meas tran vdout1_110ck620 FIND v(dout1_110) AT=315.025n

.meas tran vdout1_111ck620 FIND v(dout1_111) AT=315.025n

.meas tran vdout1_112ck620 FIND v(dout1_112) AT=315.025n

.meas tran vdout1_113ck620 FIND v(dout1_113) AT=315.025n

.meas tran vdout1_114ck620 FIND v(dout1_114) AT=315.025n

.meas tran vdout1_115ck620 FIND v(dout1_115) AT=315.025n

.meas tran vdout1_116ck620 FIND v(dout1_116) AT=315.025n

.meas tran vdout1_117ck620 FIND v(dout1_117) AT=315.025n

.meas tran vdout1_118ck620 FIND v(dout1_118) AT=315.025n

.meas tran vdout1_119ck620 FIND v(dout1_119) AT=315.025n

.meas tran vdout1_120ck620 FIND v(dout1_120) AT=315.025n

.meas tran vdout1_121ck620 FIND v(dout1_121) AT=315.025n

.meas tran vdout1_122ck620 FIND v(dout1_122) AT=315.025n

.meas tran vdout1_123ck620 FIND v(dout1_123) AT=315.025n

.meas tran vdout1_124ck620 FIND v(dout1_124) AT=315.025n

.meas tran vdout1_125ck620 FIND v(dout1_125) AT=315.025n

.meas tran vdout1_126ck620 FIND v(dout1_126) AT=315.025n

.meas tran vdout1_127ck620 FIND v(dout1_127) AT=315.025n

.meas tran vdout1_0ck640 FIND v(dout1_0) AT=325.025n

.meas tran vdout1_1ck640 FIND v(dout1_1) AT=325.025n

.meas tran vdout1_2ck640 FIND v(dout1_2) AT=325.025n

.meas tran vdout1_3ck640 FIND v(dout1_3) AT=325.025n

.meas tran vdout1_4ck640 FIND v(dout1_4) AT=325.025n

.meas tran vdout1_5ck640 FIND v(dout1_5) AT=325.025n

.meas tran vdout1_6ck640 FIND v(dout1_6) AT=325.025n

.meas tran vdout1_7ck640 FIND v(dout1_7) AT=325.025n

.meas tran vdout1_8ck640 FIND v(dout1_8) AT=325.025n

.meas tran vdout1_9ck640 FIND v(dout1_9) AT=325.025n

.meas tran vdout1_10ck640 FIND v(dout1_10) AT=325.025n

.meas tran vdout1_11ck640 FIND v(dout1_11) AT=325.025n

.meas tran vdout1_12ck640 FIND v(dout1_12) AT=325.025n

.meas tran vdout1_13ck640 FIND v(dout1_13) AT=325.025n

.meas tran vdout1_14ck640 FIND v(dout1_14) AT=325.025n

.meas tran vdout1_15ck640 FIND v(dout1_15) AT=325.025n

.meas tran vdout1_16ck640 FIND v(dout1_16) AT=325.025n

.meas tran vdout1_17ck640 FIND v(dout1_17) AT=325.025n

.meas tran vdout1_18ck640 FIND v(dout1_18) AT=325.025n

.meas tran vdout1_19ck640 FIND v(dout1_19) AT=325.025n

.meas tran vdout1_20ck640 FIND v(dout1_20) AT=325.025n

.meas tran vdout1_21ck640 FIND v(dout1_21) AT=325.025n

.meas tran vdout1_22ck640 FIND v(dout1_22) AT=325.025n

.meas tran vdout1_23ck640 FIND v(dout1_23) AT=325.025n

.meas tran vdout1_24ck640 FIND v(dout1_24) AT=325.025n

.meas tran vdout1_25ck640 FIND v(dout1_25) AT=325.025n

.meas tran vdout1_26ck640 FIND v(dout1_26) AT=325.025n

.meas tran vdout1_27ck640 FIND v(dout1_27) AT=325.025n

.meas tran vdout1_28ck640 FIND v(dout1_28) AT=325.025n

.meas tran vdout1_29ck640 FIND v(dout1_29) AT=325.025n

.meas tran vdout1_30ck640 FIND v(dout1_30) AT=325.025n

.meas tran vdout1_31ck640 FIND v(dout1_31) AT=325.025n

.meas tran vdout1_32ck640 FIND v(dout1_32) AT=325.025n

.meas tran vdout1_33ck640 FIND v(dout1_33) AT=325.025n

.meas tran vdout1_34ck640 FIND v(dout1_34) AT=325.025n

.meas tran vdout1_35ck640 FIND v(dout1_35) AT=325.025n

.meas tran vdout1_36ck640 FIND v(dout1_36) AT=325.025n

.meas tran vdout1_37ck640 FIND v(dout1_37) AT=325.025n

.meas tran vdout1_38ck640 FIND v(dout1_38) AT=325.025n

.meas tran vdout1_39ck640 FIND v(dout1_39) AT=325.025n

.meas tran vdout1_40ck640 FIND v(dout1_40) AT=325.025n

.meas tran vdout1_41ck640 FIND v(dout1_41) AT=325.025n

.meas tran vdout1_42ck640 FIND v(dout1_42) AT=325.025n

.meas tran vdout1_43ck640 FIND v(dout1_43) AT=325.025n

.meas tran vdout1_44ck640 FIND v(dout1_44) AT=325.025n

.meas tran vdout1_45ck640 FIND v(dout1_45) AT=325.025n

.meas tran vdout1_46ck640 FIND v(dout1_46) AT=325.025n

.meas tran vdout1_47ck640 FIND v(dout1_47) AT=325.025n

.meas tran vdout1_48ck640 FIND v(dout1_48) AT=325.025n

.meas tran vdout1_49ck640 FIND v(dout1_49) AT=325.025n

.meas tran vdout1_50ck640 FIND v(dout1_50) AT=325.025n

.meas tran vdout1_51ck640 FIND v(dout1_51) AT=325.025n

.meas tran vdout1_52ck640 FIND v(dout1_52) AT=325.025n

.meas tran vdout1_53ck640 FIND v(dout1_53) AT=325.025n

.meas tran vdout1_54ck640 FIND v(dout1_54) AT=325.025n

.meas tran vdout1_55ck640 FIND v(dout1_55) AT=325.025n

.meas tran vdout1_56ck640 FIND v(dout1_56) AT=325.025n

.meas tran vdout1_57ck640 FIND v(dout1_57) AT=325.025n

.meas tran vdout1_58ck640 FIND v(dout1_58) AT=325.025n

.meas tran vdout1_59ck640 FIND v(dout1_59) AT=325.025n

.meas tran vdout1_60ck640 FIND v(dout1_60) AT=325.025n

.meas tran vdout1_61ck640 FIND v(dout1_61) AT=325.025n

.meas tran vdout1_62ck640 FIND v(dout1_62) AT=325.025n

.meas tran vdout1_63ck640 FIND v(dout1_63) AT=325.025n

.meas tran vdout1_64ck640 FIND v(dout1_64) AT=325.025n

.meas tran vdout1_65ck640 FIND v(dout1_65) AT=325.025n

.meas tran vdout1_66ck640 FIND v(dout1_66) AT=325.025n

.meas tran vdout1_67ck640 FIND v(dout1_67) AT=325.025n

.meas tran vdout1_68ck640 FIND v(dout1_68) AT=325.025n

.meas tran vdout1_69ck640 FIND v(dout1_69) AT=325.025n

.meas tran vdout1_70ck640 FIND v(dout1_70) AT=325.025n

.meas tran vdout1_71ck640 FIND v(dout1_71) AT=325.025n

.meas tran vdout1_72ck640 FIND v(dout1_72) AT=325.025n

.meas tran vdout1_73ck640 FIND v(dout1_73) AT=325.025n

.meas tran vdout1_74ck640 FIND v(dout1_74) AT=325.025n

.meas tran vdout1_75ck640 FIND v(dout1_75) AT=325.025n

.meas tran vdout1_76ck640 FIND v(dout1_76) AT=325.025n

.meas tran vdout1_77ck640 FIND v(dout1_77) AT=325.025n

.meas tran vdout1_78ck640 FIND v(dout1_78) AT=325.025n

.meas tran vdout1_79ck640 FIND v(dout1_79) AT=325.025n

.meas tran vdout1_80ck640 FIND v(dout1_80) AT=325.025n

.meas tran vdout1_81ck640 FIND v(dout1_81) AT=325.025n

.meas tran vdout1_82ck640 FIND v(dout1_82) AT=325.025n

.meas tran vdout1_83ck640 FIND v(dout1_83) AT=325.025n

.meas tran vdout1_84ck640 FIND v(dout1_84) AT=325.025n

.meas tran vdout1_85ck640 FIND v(dout1_85) AT=325.025n

.meas tran vdout1_86ck640 FIND v(dout1_86) AT=325.025n

.meas tran vdout1_87ck640 FIND v(dout1_87) AT=325.025n

.meas tran vdout1_88ck640 FIND v(dout1_88) AT=325.025n

.meas tran vdout1_89ck640 FIND v(dout1_89) AT=325.025n

.meas tran vdout1_90ck640 FIND v(dout1_90) AT=325.025n

.meas tran vdout1_91ck640 FIND v(dout1_91) AT=325.025n

.meas tran vdout1_92ck640 FIND v(dout1_92) AT=325.025n

.meas tran vdout1_93ck640 FIND v(dout1_93) AT=325.025n

.meas tran vdout1_94ck640 FIND v(dout1_94) AT=325.025n

.meas tran vdout1_95ck640 FIND v(dout1_95) AT=325.025n

.meas tran vdout1_96ck640 FIND v(dout1_96) AT=325.025n

.meas tran vdout1_97ck640 FIND v(dout1_97) AT=325.025n

.meas tran vdout1_98ck640 FIND v(dout1_98) AT=325.025n

.meas tran vdout1_99ck640 FIND v(dout1_99) AT=325.025n

.meas tran vdout1_100ck640 FIND v(dout1_100) AT=325.025n

.meas tran vdout1_101ck640 FIND v(dout1_101) AT=325.025n

.meas tran vdout1_102ck640 FIND v(dout1_102) AT=325.025n

.meas tran vdout1_103ck640 FIND v(dout1_103) AT=325.025n

.meas tran vdout1_104ck640 FIND v(dout1_104) AT=325.025n

.meas tran vdout1_105ck640 FIND v(dout1_105) AT=325.025n

.meas tran vdout1_106ck640 FIND v(dout1_106) AT=325.025n

.meas tran vdout1_107ck640 FIND v(dout1_107) AT=325.025n

.meas tran vdout1_108ck640 FIND v(dout1_108) AT=325.025n

.meas tran vdout1_109ck640 FIND v(dout1_109) AT=325.025n

.meas tran vdout1_110ck640 FIND v(dout1_110) AT=325.025n

.meas tran vdout1_111ck640 FIND v(dout1_111) AT=325.025n

.meas tran vdout1_112ck640 FIND v(dout1_112) AT=325.025n

.meas tran vdout1_113ck640 FIND v(dout1_113) AT=325.025n

.meas tran vdout1_114ck640 FIND v(dout1_114) AT=325.025n

.meas tran vdout1_115ck640 FIND v(dout1_115) AT=325.025n

.meas tran vdout1_116ck640 FIND v(dout1_116) AT=325.025n

.meas tran vdout1_117ck640 FIND v(dout1_117) AT=325.025n

.meas tran vdout1_118ck640 FIND v(dout1_118) AT=325.025n

.meas tran vdout1_119ck640 FIND v(dout1_119) AT=325.025n

.meas tran vdout1_120ck640 FIND v(dout1_120) AT=325.025n

.meas tran vdout1_121ck640 FIND v(dout1_121) AT=325.025n

.meas tran vdout1_122ck640 FIND v(dout1_122) AT=325.025n

.meas tran vdout1_123ck640 FIND v(dout1_123) AT=325.025n

.meas tran vdout1_124ck640 FIND v(dout1_124) AT=325.025n

.meas tran vdout1_125ck640 FIND v(dout1_125) AT=325.025n

.meas tran vdout1_126ck640 FIND v(dout1_126) AT=325.025n

.meas tran vdout1_127ck640 FIND v(dout1_127) AT=325.025n

.meas tran vdout1_0ck680 FIND v(dout1_0) AT=345.025n

.meas tran vdout1_1ck680 FIND v(dout1_1) AT=345.025n

.meas tran vdout1_2ck680 FIND v(dout1_2) AT=345.025n

.meas tran vdout1_3ck680 FIND v(dout1_3) AT=345.025n

.meas tran vdout1_4ck680 FIND v(dout1_4) AT=345.025n

.meas tran vdout1_5ck680 FIND v(dout1_5) AT=345.025n

.meas tran vdout1_6ck680 FIND v(dout1_6) AT=345.025n

.meas tran vdout1_7ck680 FIND v(dout1_7) AT=345.025n

.meas tran vdout1_8ck680 FIND v(dout1_8) AT=345.025n

.meas tran vdout1_9ck680 FIND v(dout1_9) AT=345.025n

.meas tran vdout1_10ck680 FIND v(dout1_10) AT=345.025n

.meas tran vdout1_11ck680 FIND v(dout1_11) AT=345.025n

.meas tran vdout1_12ck680 FIND v(dout1_12) AT=345.025n

.meas tran vdout1_13ck680 FIND v(dout1_13) AT=345.025n

.meas tran vdout1_14ck680 FIND v(dout1_14) AT=345.025n

.meas tran vdout1_15ck680 FIND v(dout1_15) AT=345.025n

.meas tran vdout1_16ck680 FIND v(dout1_16) AT=345.025n

.meas tran vdout1_17ck680 FIND v(dout1_17) AT=345.025n

.meas tran vdout1_18ck680 FIND v(dout1_18) AT=345.025n

.meas tran vdout1_19ck680 FIND v(dout1_19) AT=345.025n

.meas tran vdout1_20ck680 FIND v(dout1_20) AT=345.025n

.meas tran vdout1_21ck680 FIND v(dout1_21) AT=345.025n

.meas tran vdout1_22ck680 FIND v(dout1_22) AT=345.025n

.meas tran vdout1_23ck680 FIND v(dout1_23) AT=345.025n

.meas tran vdout1_24ck680 FIND v(dout1_24) AT=345.025n

.meas tran vdout1_25ck680 FIND v(dout1_25) AT=345.025n

.meas tran vdout1_26ck680 FIND v(dout1_26) AT=345.025n

.meas tran vdout1_27ck680 FIND v(dout1_27) AT=345.025n

.meas tran vdout1_28ck680 FIND v(dout1_28) AT=345.025n

.meas tran vdout1_29ck680 FIND v(dout1_29) AT=345.025n

.meas tran vdout1_30ck680 FIND v(dout1_30) AT=345.025n

.meas tran vdout1_31ck680 FIND v(dout1_31) AT=345.025n

.meas tran vdout1_32ck680 FIND v(dout1_32) AT=345.025n

.meas tran vdout1_33ck680 FIND v(dout1_33) AT=345.025n

.meas tran vdout1_34ck680 FIND v(dout1_34) AT=345.025n

.meas tran vdout1_35ck680 FIND v(dout1_35) AT=345.025n

.meas tran vdout1_36ck680 FIND v(dout1_36) AT=345.025n

.meas tran vdout1_37ck680 FIND v(dout1_37) AT=345.025n

.meas tran vdout1_38ck680 FIND v(dout1_38) AT=345.025n

.meas tran vdout1_39ck680 FIND v(dout1_39) AT=345.025n

.meas tran vdout1_40ck680 FIND v(dout1_40) AT=345.025n

.meas tran vdout1_41ck680 FIND v(dout1_41) AT=345.025n

.meas tran vdout1_42ck680 FIND v(dout1_42) AT=345.025n

.meas tran vdout1_43ck680 FIND v(dout1_43) AT=345.025n

.meas tran vdout1_44ck680 FIND v(dout1_44) AT=345.025n

.meas tran vdout1_45ck680 FIND v(dout1_45) AT=345.025n

.meas tran vdout1_46ck680 FIND v(dout1_46) AT=345.025n

.meas tran vdout1_47ck680 FIND v(dout1_47) AT=345.025n

.meas tran vdout1_48ck680 FIND v(dout1_48) AT=345.025n

.meas tran vdout1_49ck680 FIND v(dout1_49) AT=345.025n

.meas tran vdout1_50ck680 FIND v(dout1_50) AT=345.025n

.meas tran vdout1_51ck680 FIND v(dout1_51) AT=345.025n

.meas tran vdout1_52ck680 FIND v(dout1_52) AT=345.025n

.meas tran vdout1_53ck680 FIND v(dout1_53) AT=345.025n

.meas tran vdout1_54ck680 FIND v(dout1_54) AT=345.025n

.meas tran vdout1_55ck680 FIND v(dout1_55) AT=345.025n

.meas tran vdout1_56ck680 FIND v(dout1_56) AT=345.025n

.meas tran vdout1_57ck680 FIND v(dout1_57) AT=345.025n

.meas tran vdout1_58ck680 FIND v(dout1_58) AT=345.025n

.meas tran vdout1_59ck680 FIND v(dout1_59) AT=345.025n

.meas tran vdout1_60ck680 FIND v(dout1_60) AT=345.025n

.meas tran vdout1_61ck680 FIND v(dout1_61) AT=345.025n

.meas tran vdout1_62ck680 FIND v(dout1_62) AT=345.025n

.meas tran vdout1_63ck680 FIND v(dout1_63) AT=345.025n

.meas tran vdout1_64ck680 FIND v(dout1_64) AT=345.025n

.meas tran vdout1_65ck680 FIND v(dout1_65) AT=345.025n

.meas tran vdout1_66ck680 FIND v(dout1_66) AT=345.025n

.meas tran vdout1_67ck680 FIND v(dout1_67) AT=345.025n

.meas tran vdout1_68ck680 FIND v(dout1_68) AT=345.025n

.meas tran vdout1_69ck680 FIND v(dout1_69) AT=345.025n

.meas tran vdout1_70ck680 FIND v(dout1_70) AT=345.025n

.meas tran vdout1_71ck680 FIND v(dout1_71) AT=345.025n

.meas tran vdout1_72ck680 FIND v(dout1_72) AT=345.025n

.meas tran vdout1_73ck680 FIND v(dout1_73) AT=345.025n

.meas tran vdout1_74ck680 FIND v(dout1_74) AT=345.025n

.meas tran vdout1_75ck680 FIND v(dout1_75) AT=345.025n

.meas tran vdout1_76ck680 FIND v(dout1_76) AT=345.025n

.meas tran vdout1_77ck680 FIND v(dout1_77) AT=345.025n

.meas tran vdout1_78ck680 FIND v(dout1_78) AT=345.025n

.meas tran vdout1_79ck680 FIND v(dout1_79) AT=345.025n

.meas tran vdout1_80ck680 FIND v(dout1_80) AT=345.025n

.meas tran vdout1_81ck680 FIND v(dout1_81) AT=345.025n

.meas tran vdout1_82ck680 FIND v(dout1_82) AT=345.025n

.meas tran vdout1_83ck680 FIND v(dout1_83) AT=345.025n

.meas tran vdout1_84ck680 FIND v(dout1_84) AT=345.025n

.meas tran vdout1_85ck680 FIND v(dout1_85) AT=345.025n

.meas tran vdout1_86ck680 FIND v(dout1_86) AT=345.025n

.meas tran vdout1_87ck680 FIND v(dout1_87) AT=345.025n

.meas tran vdout1_88ck680 FIND v(dout1_88) AT=345.025n

.meas tran vdout1_89ck680 FIND v(dout1_89) AT=345.025n

.meas tran vdout1_90ck680 FIND v(dout1_90) AT=345.025n

.meas tran vdout1_91ck680 FIND v(dout1_91) AT=345.025n

.meas tran vdout1_92ck680 FIND v(dout1_92) AT=345.025n

.meas tran vdout1_93ck680 FIND v(dout1_93) AT=345.025n

.meas tran vdout1_94ck680 FIND v(dout1_94) AT=345.025n

.meas tran vdout1_95ck680 FIND v(dout1_95) AT=345.025n

.meas tran vdout1_96ck680 FIND v(dout1_96) AT=345.025n

.meas tran vdout1_97ck680 FIND v(dout1_97) AT=345.025n

.meas tran vdout1_98ck680 FIND v(dout1_98) AT=345.025n

.meas tran vdout1_99ck680 FIND v(dout1_99) AT=345.025n

.meas tran vdout1_100ck680 FIND v(dout1_100) AT=345.025n

.meas tran vdout1_101ck680 FIND v(dout1_101) AT=345.025n

.meas tran vdout1_102ck680 FIND v(dout1_102) AT=345.025n

.meas tran vdout1_103ck680 FIND v(dout1_103) AT=345.025n

.meas tran vdout1_104ck680 FIND v(dout1_104) AT=345.025n

.meas tran vdout1_105ck680 FIND v(dout1_105) AT=345.025n

.meas tran vdout1_106ck680 FIND v(dout1_106) AT=345.025n

.meas tran vdout1_107ck680 FIND v(dout1_107) AT=345.025n

.meas tran vdout1_108ck680 FIND v(dout1_108) AT=345.025n

.meas tran vdout1_109ck680 FIND v(dout1_109) AT=345.025n

.meas tran vdout1_110ck680 FIND v(dout1_110) AT=345.025n

.meas tran vdout1_111ck680 FIND v(dout1_111) AT=345.025n

.meas tran vdout1_112ck680 FIND v(dout1_112) AT=345.025n

.meas tran vdout1_113ck680 FIND v(dout1_113) AT=345.025n

.meas tran vdout1_114ck680 FIND v(dout1_114) AT=345.025n

.meas tran vdout1_115ck680 FIND v(dout1_115) AT=345.025n

.meas tran vdout1_116ck680 FIND v(dout1_116) AT=345.025n

.meas tran vdout1_117ck680 FIND v(dout1_117) AT=345.025n

.meas tran vdout1_118ck680 FIND v(dout1_118) AT=345.025n

.meas tran vdout1_119ck680 FIND v(dout1_119) AT=345.025n

.meas tran vdout1_120ck680 FIND v(dout1_120) AT=345.025n

.meas tran vdout1_121ck680 FIND v(dout1_121) AT=345.025n

.meas tran vdout1_122ck680 FIND v(dout1_122) AT=345.025n

.meas tran vdout1_123ck680 FIND v(dout1_123) AT=345.025n

.meas tran vdout1_124ck680 FIND v(dout1_124) AT=345.025n

.meas tran vdout1_125ck680 FIND v(dout1_125) AT=345.025n

.meas tran vdout1_126ck680 FIND v(dout1_126) AT=345.025n

.meas tran vdout1_127ck680 FIND v(dout1_127) AT=345.025n

.meas tran vdout1_0ck700 FIND v(dout1_0) AT=355.025n

.meas tran vdout1_1ck700 FIND v(dout1_1) AT=355.025n

.meas tran vdout1_2ck700 FIND v(dout1_2) AT=355.025n

.meas tran vdout1_3ck700 FIND v(dout1_3) AT=355.025n

.meas tran vdout1_4ck700 FIND v(dout1_4) AT=355.025n

.meas tran vdout1_5ck700 FIND v(dout1_5) AT=355.025n

.meas tran vdout1_6ck700 FIND v(dout1_6) AT=355.025n

.meas tran vdout1_7ck700 FIND v(dout1_7) AT=355.025n

.meas tran vdout1_8ck700 FIND v(dout1_8) AT=355.025n

.meas tran vdout1_9ck700 FIND v(dout1_9) AT=355.025n

.meas tran vdout1_10ck700 FIND v(dout1_10) AT=355.025n

.meas tran vdout1_11ck700 FIND v(dout1_11) AT=355.025n

.meas tran vdout1_12ck700 FIND v(dout1_12) AT=355.025n

.meas tran vdout1_13ck700 FIND v(dout1_13) AT=355.025n

.meas tran vdout1_14ck700 FIND v(dout1_14) AT=355.025n

.meas tran vdout1_15ck700 FIND v(dout1_15) AT=355.025n

.meas tran vdout1_16ck700 FIND v(dout1_16) AT=355.025n

.meas tran vdout1_17ck700 FIND v(dout1_17) AT=355.025n

.meas tran vdout1_18ck700 FIND v(dout1_18) AT=355.025n

.meas tran vdout1_19ck700 FIND v(dout1_19) AT=355.025n

.meas tran vdout1_20ck700 FIND v(dout1_20) AT=355.025n

.meas tran vdout1_21ck700 FIND v(dout1_21) AT=355.025n

.meas tran vdout1_22ck700 FIND v(dout1_22) AT=355.025n

.meas tran vdout1_23ck700 FIND v(dout1_23) AT=355.025n

.meas tran vdout1_24ck700 FIND v(dout1_24) AT=355.025n

.meas tran vdout1_25ck700 FIND v(dout1_25) AT=355.025n

.meas tran vdout1_26ck700 FIND v(dout1_26) AT=355.025n

.meas tran vdout1_27ck700 FIND v(dout1_27) AT=355.025n

.meas tran vdout1_28ck700 FIND v(dout1_28) AT=355.025n

.meas tran vdout1_29ck700 FIND v(dout1_29) AT=355.025n

.meas tran vdout1_30ck700 FIND v(dout1_30) AT=355.025n

.meas tran vdout1_31ck700 FIND v(dout1_31) AT=355.025n

.meas tran vdout1_32ck700 FIND v(dout1_32) AT=355.025n

.meas tran vdout1_33ck700 FIND v(dout1_33) AT=355.025n

.meas tran vdout1_34ck700 FIND v(dout1_34) AT=355.025n

.meas tran vdout1_35ck700 FIND v(dout1_35) AT=355.025n

.meas tran vdout1_36ck700 FIND v(dout1_36) AT=355.025n

.meas tran vdout1_37ck700 FIND v(dout1_37) AT=355.025n

.meas tran vdout1_38ck700 FIND v(dout1_38) AT=355.025n

.meas tran vdout1_39ck700 FIND v(dout1_39) AT=355.025n

.meas tran vdout1_40ck700 FIND v(dout1_40) AT=355.025n

.meas tran vdout1_41ck700 FIND v(dout1_41) AT=355.025n

.meas tran vdout1_42ck700 FIND v(dout1_42) AT=355.025n

.meas tran vdout1_43ck700 FIND v(dout1_43) AT=355.025n

.meas tran vdout1_44ck700 FIND v(dout1_44) AT=355.025n

.meas tran vdout1_45ck700 FIND v(dout1_45) AT=355.025n

.meas tran vdout1_46ck700 FIND v(dout1_46) AT=355.025n

.meas tran vdout1_47ck700 FIND v(dout1_47) AT=355.025n

.meas tran vdout1_48ck700 FIND v(dout1_48) AT=355.025n

.meas tran vdout1_49ck700 FIND v(dout1_49) AT=355.025n

.meas tran vdout1_50ck700 FIND v(dout1_50) AT=355.025n

.meas tran vdout1_51ck700 FIND v(dout1_51) AT=355.025n

.meas tran vdout1_52ck700 FIND v(dout1_52) AT=355.025n

.meas tran vdout1_53ck700 FIND v(dout1_53) AT=355.025n

.meas tran vdout1_54ck700 FIND v(dout1_54) AT=355.025n

.meas tran vdout1_55ck700 FIND v(dout1_55) AT=355.025n

.meas tran vdout1_56ck700 FIND v(dout1_56) AT=355.025n

.meas tran vdout1_57ck700 FIND v(dout1_57) AT=355.025n

.meas tran vdout1_58ck700 FIND v(dout1_58) AT=355.025n

.meas tran vdout1_59ck700 FIND v(dout1_59) AT=355.025n

.meas tran vdout1_60ck700 FIND v(dout1_60) AT=355.025n

.meas tran vdout1_61ck700 FIND v(dout1_61) AT=355.025n

.meas tran vdout1_62ck700 FIND v(dout1_62) AT=355.025n

.meas tran vdout1_63ck700 FIND v(dout1_63) AT=355.025n

.meas tran vdout1_64ck700 FIND v(dout1_64) AT=355.025n

.meas tran vdout1_65ck700 FIND v(dout1_65) AT=355.025n

.meas tran vdout1_66ck700 FIND v(dout1_66) AT=355.025n

.meas tran vdout1_67ck700 FIND v(dout1_67) AT=355.025n

.meas tran vdout1_68ck700 FIND v(dout1_68) AT=355.025n

.meas tran vdout1_69ck700 FIND v(dout1_69) AT=355.025n

.meas tran vdout1_70ck700 FIND v(dout1_70) AT=355.025n

.meas tran vdout1_71ck700 FIND v(dout1_71) AT=355.025n

.meas tran vdout1_72ck700 FIND v(dout1_72) AT=355.025n

.meas tran vdout1_73ck700 FIND v(dout1_73) AT=355.025n

.meas tran vdout1_74ck700 FIND v(dout1_74) AT=355.025n

.meas tran vdout1_75ck700 FIND v(dout1_75) AT=355.025n

.meas tran vdout1_76ck700 FIND v(dout1_76) AT=355.025n

.meas tran vdout1_77ck700 FIND v(dout1_77) AT=355.025n

.meas tran vdout1_78ck700 FIND v(dout1_78) AT=355.025n

.meas tran vdout1_79ck700 FIND v(dout1_79) AT=355.025n

.meas tran vdout1_80ck700 FIND v(dout1_80) AT=355.025n

.meas tran vdout1_81ck700 FIND v(dout1_81) AT=355.025n

.meas tran vdout1_82ck700 FIND v(dout1_82) AT=355.025n

.meas tran vdout1_83ck700 FIND v(dout1_83) AT=355.025n

.meas tran vdout1_84ck700 FIND v(dout1_84) AT=355.025n

.meas tran vdout1_85ck700 FIND v(dout1_85) AT=355.025n

.meas tran vdout1_86ck700 FIND v(dout1_86) AT=355.025n

.meas tran vdout1_87ck700 FIND v(dout1_87) AT=355.025n

.meas tran vdout1_88ck700 FIND v(dout1_88) AT=355.025n

.meas tran vdout1_89ck700 FIND v(dout1_89) AT=355.025n

.meas tran vdout1_90ck700 FIND v(dout1_90) AT=355.025n

.meas tran vdout1_91ck700 FIND v(dout1_91) AT=355.025n

.meas tran vdout1_92ck700 FIND v(dout1_92) AT=355.025n

.meas tran vdout1_93ck700 FIND v(dout1_93) AT=355.025n

.meas tran vdout1_94ck700 FIND v(dout1_94) AT=355.025n

.meas tran vdout1_95ck700 FIND v(dout1_95) AT=355.025n

.meas tran vdout1_96ck700 FIND v(dout1_96) AT=355.025n

.meas tran vdout1_97ck700 FIND v(dout1_97) AT=355.025n

.meas tran vdout1_98ck700 FIND v(dout1_98) AT=355.025n

.meas tran vdout1_99ck700 FIND v(dout1_99) AT=355.025n

.meas tran vdout1_100ck700 FIND v(dout1_100) AT=355.025n

.meas tran vdout1_101ck700 FIND v(dout1_101) AT=355.025n

.meas tran vdout1_102ck700 FIND v(dout1_102) AT=355.025n

.meas tran vdout1_103ck700 FIND v(dout1_103) AT=355.025n

.meas tran vdout1_104ck700 FIND v(dout1_104) AT=355.025n

.meas tran vdout1_105ck700 FIND v(dout1_105) AT=355.025n

.meas tran vdout1_106ck700 FIND v(dout1_106) AT=355.025n

.meas tran vdout1_107ck700 FIND v(dout1_107) AT=355.025n

.meas tran vdout1_108ck700 FIND v(dout1_108) AT=355.025n

.meas tran vdout1_109ck700 FIND v(dout1_109) AT=355.025n

.meas tran vdout1_110ck700 FIND v(dout1_110) AT=355.025n

.meas tran vdout1_111ck700 FIND v(dout1_111) AT=355.025n

.meas tran vdout1_112ck700 FIND v(dout1_112) AT=355.025n

.meas tran vdout1_113ck700 FIND v(dout1_113) AT=355.025n

.meas tran vdout1_114ck700 FIND v(dout1_114) AT=355.025n

.meas tran vdout1_115ck700 FIND v(dout1_115) AT=355.025n

.meas tran vdout1_116ck700 FIND v(dout1_116) AT=355.025n

.meas tran vdout1_117ck700 FIND v(dout1_117) AT=355.025n

.meas tran vdout1_118ck700 FIND v(dout1_118) AT=355.025n

.meas tran vdout1_119ck700 FIND v(dout1_119) AT=355.025n

.meas tran vdout1_120ck700 FIND v(dout1_120) AT=355.025n

.meas tran vdout1_121ck700 FIND v(dout1_121) AT=355.025n

.meas tran vdout1_122ck700 FIND v(dout1_122) AT=355.025n

.meas tran vdout1_123ck700 FIND v(dout1_123) AT=355.025n

.meas tran vdout1_124ck700 FIND v(dout1_124) AT=355.025n

.meas tran vdout1_125ck700 FIND v(dout1_125) AT=355.025n

.meas tran vdout1_126ck700 FIND v(dout1_126) AT=355.025n

.meas tran vdout1_127ck700 FIND v(dout1_127) AT=355.025n

.meas tran vdout1_0ck710 FIND v(dout1_0) AT=360.025n

.meas tran vdout1_1ck710 FIND v(dout1_1) AT=360.025n

.meas tran vdout1_2ck710 FIND v(dout1_2) AT=360.025n

.meas tran vdout1_3ck710 FIND v(dout1_3) AT=360.025n

.meas tran vdout1_4ck710 FIND v(dout1_4) AT=360.025n

.meas tran vdout1_5ck710 FIND v(dout1_5) AT=360.025n

.meas tran vdout1_6ck710 FIND v(dout1_6) AT=360.025n

.meas tran vdout1_7ck710 FIND v(dout1_7) AT=360.025n

.meas tran vdout1_8ck710 FIND v(dout1_8) AT=360.025n

.meas tran vdout1_9ck710 FIND v(dout1_9) AT=360.025n

.meas tran vdout1_10ck710 FIND v(dout1_10) AT=360.025n

.meas tran vdout1_11ck710 FIND v(dout1_11) AT=360.025n

.meas tran vdout1_12ck710 FIND v(dout1_12) AT=360.025n

.meas tran vdout1_13ck710 FIND v(dout1_13) AT=360.025n

.meas tran vdout1_14ck710 FIND v(dout1_14) AT=360.025n

.meas tran vdout1_15ck710 FIND v(dout1_15) AT=360.025n

.meas tran vdout1_16ck710 FIND v(dout1_16) AT=360.025n

.meas tran vdout1_17ck710 FIND v(dout1_17) AT=360.025n

.meas tran vdout1_18ck710 FIND v(dout1_18) AT=360.025n

.meas tran vdout1_19ck710 FIND v(dout1_19) AT=360.025n

.meas tran vdout1_20ck710 FIND v(dout1_20) AT=360.025n

.meas tran vdout1_21ck710 FIND v(dout1_21) AT=360.025n

.meas tran vdout1_22ck710 FIND v(dout1_22) AT=360.025n

.meas tran vdout1_23ck710 FIND v(dout1_23) AT=360.025n

.meas tran vdout1_24ck710 FIND v(dout1_24) AT=360.025n

.meas tran vdout1_25ck710 FIND v(dout1_25) AT=360.025n

.meas tran vdout1_26ck710 FIND v(dout1_26) AT=360.025n

.meas tran vdout1_27ck710 FIND v(dout1_27) AT=360.025n

.meas tran vdout1_28ck710 FIND v(dout1_28) AT=360.025n

.meas tran vdout1_29ck710 FIND v(dout1_29) AT=360.025n

.meas tran vdout1_30ck710 FIND v(dout1_30) AT=360.025n

.meas tran vdout1_31ck710 FIND v(dout1_31) AT=360.025n

.meas tran vdout1_32ck710 FIND v(dout1_32) AT=360.025n

.meas tran vdout1_33ck710 FIND v(dout1_33) AT=360.025n

.meas tran vdout1_34ck710 FIND v(dout1_34) AT=360.025n

.meas tran vdout1_35ck710 FIND v(dout1_35) AT=360.025n

.meas tran vdout1_36ck710 FIND v(dout1_36) AT=360.025n

.meas tran vdout1_37ck710 FIND v(dout1_37) AT=360.025n

.meas tran vdout1_38ck710 FIND v(dout1_38) AT=360.025n

.meas tran vdout1_39ck710 FIND v(dout1_39) AT=360.025n

.meas tran vdout1_40ck710 FIND v(dout1_40) AT=360.025n

.meas tran vdout1_41ck710 FIND v(dout1_41) AT=360.025n

.meas tran vdout1_42ck710 FIND v(dout1_42) AT=360.025n

.meas tran vdout1_43ck710 FIND v(dout1_43) AT=360.025n

.meas tran vdout1_44ck710 FIND v(dout1_44) AT=360.025n

.meas tran vdout1_45ck710 FIND v(dout1_45) AT=360.025n

.meas tran vdout1_46ck710 FIND v(dout1_46) AT=360.025n

.meas tran vdout1_47ck710 FIND v(dout1_47) AT=360.025n

.meas tran vdout1_48ck710 FIND v(dout1_48) AT=360.025n

.meas tran vdout1_49ck710 FIND v(dout1_49) AT=360.025n

.meas tran vdout1_50ck710 FIND v(dout1_50) AT=360.025n

.meas tran vdout1_51ck710 FIND v(dout1_51) AT=360.025n

.meas tran vdout1_52ck710 FIND v(dout1_52) AT=360.025n

.meas tran vdout1_53ck710 FIND v(dout1_53) AT=360.025n

.meas tran vdout1_54ck710 FIND v(dout1_54) AT=360.025n

.meas tran vdout1_55ck710 FIND v(dout1_55) AT=360.025n

.meas tran vdout1_56ck710 FIND v(dout1_56) AT=360.025n

.meas tran vdout1_57ck710 FIND v(dout1_57) AT=360.025n

.meas tran vdout1_58ck710 FIND v(dout1_58) AT=360.025n

.meas tran vdout1_59ck710 FIND v(dout1_59) AT=360.025n

.meas tran vdout1_60ck710 FIND v(dout1_60) AT=360.025n

.meas tran vdout1_61ck710 FIND v(dout1_61) AT=360.025n

.meas tran vdout1_62ck710 FIND v(dout1_62) AT=360.025n

.meas tran vdout1_63ck710 FIND v(dout1_63) AT=360.025n

.meas tran vdout1_64ck710 FIND v(dout1_64) AT=360.025n

.meas tran vdout1_65ck710 FIND v(dout1_65) AT=360.025n

.meas tran vdout1_66ck710 FIND v(dout1_66) AT=360.025n

.meas tran vdout1_67ck710 FIND v(dout1_67) AT=360.025n

.meas tran vdout1_68ck710 FIND v(dout1_68) AT=360.025n

.meas tran vdout1_69ck710 FIND v(dout1_69) AT=360.025n

.meas tran vdout1_70ck710 FIND v(dout1_70) AT=360.025n

.meas tran vdout1_71ck710 FIND v(dout1_71) AT=360.025n

.meas tran vdout1_72ck710 FIND v(dout1_72) AT=360.025n

.meas tran vdout1_73ck710 FIND v(dout1_73) AT=360.025n

.meas tran vdout1_74ck710 FIND v(dout1_74) AT=360.025n

.meas tran vdout1_75ck710 FIND v(dout1_75) AT=360.025n

.meas tran vdout1_76ck710 FIND v(dout1_76) AT=360.025n

.meas tran vdout1_77ck710 FIND v(dout1_77) AT=360.025n

.meas tran vdout1_78ck710 FIND v(dout1_78) AT=360.025n

.meas tran vdout1_79ck710 FIND v(dout1_79) AT=360.025n

.meas tran vdout1_80ck710 FIND v(dout1_80) AT=360.025n

.meas tran vdout1_81ck710 FIND v(dout1_81) AT=360.025n

.meas tran vdout1_82ck710 FIND v(dout1_82) AT=360.025n

.meas tran vdout1_83ck710 FIND v(dout1_83) AT=360.025n

.meas tran vdout1_84ck710 FIND v(dout1_84) AT=360.025n

.meas tran vdout1_85ck710 FIND v(dout1_85) AT=360.025n

.meas tran vdout1_86ck710 FIND v(dout1_86) AT=360.025n

.meas tran vdout1_87ck710 FIND v(dout1_87) AT=360.025n

.meas tran vdout1_88ck710 FIND v(dout1_88) AT=360.025n

.meas tran vdout1_89ck710 FIND v(dout1_89) AT=360.025n

.meas tran vdout1_90ck710 FIND v(dout1_90) AT=360.025n

.meas tran vdout1_91ck710 FIND v(dout1_91) AT=360.025n

.meas tran vdout1_92ck710 FIND v(dout1_92) AT=360.025n

.meas tran vdout1_93ck710 FIND v(dout1_93) AT=360.025n

.meas tran vdout1_94ck710 FIND v(dout1_94) AT=360.025n

.meas tran vdout1_95ck710 FIND v(dout1_95) AT=360.025n

.meas tran vdout1_96ck710 FIND v(dout1_96) AT=360.025n

.meas tran vdout1_97ck710 FIND v(dout1_97) AT=360.025n

.meas tran vdout1_98ck710 FIND v(dout1_98) AT=360.025n

.meas tran vdout1_99ck710 FIND v(dout1_99) AT=360.025n

.meas tran vdout1_100ck710 FIND v(dout1_100) AT=360.025n

.meas tran vdout1_101ck710 FIND v(dout1_101) AT=360.025n

.meas tran vdout1_102ck710 FIND v(dout1_102) AT=360.025n

.meas tran vdout1_103ck710 FIND v(dout1_103) AT=360.025n

.meas tran vdout1_104ck710 FIND v(dout1_104) AT=360.025n

.meas tran vdout1_105ck710 FIND v(dout1_105) AT=360.025n

.meas tran vdout1_106ck710 FIND v(dout1_106) AT=360.025n

.meas tran vdout1_107ck710 FIND v(dout1_107) AT=360.025n

.meas tran vdout1_108ck710 FIND v(dout1_108) AT=360.025n

.meas tran vdout1_109ck710 FIND v(dout1_109) AT=360.025n

.meas tran vdout1_110ck710 FIND v(dout1_110) AT=360.025n

.meas tran vdout1_111ck710 FIND v(dout1_111) AT=360.025n

.meas tran vdout1_112ck710 FIND v(dout1_112) AT=360.025n

.meas tran vdout1_113ck710 FIND v(dout1_113) AT=360.025n

.meas tran vdout1_114ck710 FIND v(dout1_114) AT=360.025n

.meas tran vdout1_115ck710 FIND v(dout1_115) AT=360.025n

.meas tran vdout1_116ck710 FIND v(dout1_116) AT=360.025n

.meas tran vdout1_117ck710 FIND v(dout1_117) AT=360.025n

.meas tran vdout1_118ck710 FIND v(dout1_118) AT=360.025n

.meas tran vdout1_119ck710 FIND v(dout1_119) AT=360.025n

.meas tran vdout1_120ck710 FIND v(dout1_120) AT=360.025n

.meas tran vdout1_121ck710 FIND v(dout1_121) AT=360.025n

.meas tran vdout1_122ck710 FIND v(dout1_122) AT=360.025n

.meas tran vdout1_123ck710 FIND v(dout1_123) AT=360.025n

.meas tran vdout1_124ck710 FIND v(dout1_124) AT=360.025n

.meas tran vdout1_125ck710 FIND v(dout1_125) AT=360.025n

.meas tran vdout1_126ck710 FIND v(dout1_126) AT=360.025n

.meas tran vdout1_127ck710 FIND v(dout1_127) AT=360.025n

.meas tran vdout1_0ck760 FIND v(dout1_0) AT=385.025n

.meas tran vdout1_1ck760 FIND v(dout1_1) AT=385.025n

.meas tran vdout1_2ck760 FIND v(dout1_2) AT=385.025n

.meas tran vdout1_3ck760 FIND v(dout1_3) AT=385.025n

.meas tran vdout1_4ck760 FIND v(dout1_4) AT=385.025n

.meas tran vdout1_5ck760 FIND v(dout1_5) AT=385.025n

.meas tran vdout1_6ck760 FIND v(dout1_6) AT=385.025n

.meas tran vdout1_7ck760 FIND v(dout1_7) AT=385.025n

.meas tran vdout1_8ck760 FIND v(dout1_8) AT=385.025n

.meas tran vdout1_9ck760 FIND v(dout1_9) AT=385.025n

.meas tran vdout1_10ck760 FIND v(dout1_10) AT=385.025n

.meas tran vdout1_11ck760 FIND v(dout1_11) AT=385.025n

.meas tran vdout1_12ck760 FIND v(dout1_12) AT=385.025n

.meas tran vdout1_13ck760 FIND v(dout1_13) AT=385.025n

.meas tran vdout1_14ck760 FIND v(dout1_14) AT=385.025n

.meas tran vdout1_15ck760 FIND v(dout1_15) AT=385.025n

.meas tran vdout1_16ck760 FIND v(dout1_16) AT=385.025n

.meas tran vdout1_17ck760 FIND v(dout1_17) AT=385.025n

.meas tran vdout1_18ck760 FIND v(dout1_18) AT=385.025n

.meas tran vdout1_19ck760 FIND v(dout1_19) AT=385.025n

.meas tran vdout1_20ck760 FIND v(dout1_20) AT=385.025n

.meas tran vdout1_21ck760 FIND v(dout1_21) AT=385.025n

.meas tran vdout1_22ck760 FIND v(dout1_22) AT=385.025n

.meas tran vdout1_23ck760 FIND v(dout1_23) AT=385.025n

.meas tran vdout1_24ck760 FIND v(dout1_24) AT=385.025n

.meas tran vdout1_25ck760 FIND v(dout1_25) AT=385.025n

.meas tran vdout1_26ck760 FIND v(dout1_26) AT=385.025n

.meas tran vdout1_27ck760 FIND v(dout1_27) AT=385.025n

.meas tran vdout1_28ck760 FIND v(dout1_28) AT=385.025n

.meas tran vdout1_29ck760 FIND v(dout1_29) AT=385.025n

.meas tran vdout1_30ck760 FIND v(dout1_30) AT=385.025n

.meas tran vdout1_31ck760 FIND v(dout1_31) AT=385.025n

.meas tran vdout1_32ck760 FIND v(dout1_32) AT=385.025n

.meas tran vdout1_33ck760 FIND v(dout1_33) AT=385.025n

.meas tran vdout1_34ck760 FIND v(dout1_34) AT=385.025n

.meas tran vdout1_35ck760 FIND v(dout1_35) AT=385.025n

.meas tran vdout1_36ck760 FIND v(dout1_36) AT=385.025n

.meas tran vdout1_37ck760 FIND v(dout1_37) AT=385.025n

.meas tran vdout1_38ck760 FIND v(dout1_38) AT=385.025n

.meas tran vdout1_39ck760 FIND v(dout1_39) AT=385.025n

.meas tran vdout1_40ck760 FIND v(dout1_40) AT=385.025n

.meas tran vdout1_41ck760 FIND v(dout1_41) AT=385.025n

.meas tran vdout1_42ck760 FIND v(dout1_42) AT=385.025n

.meas tran vdout1_43ck760 FIND v(dout1_43) AT=385.025n

.meas tran vdout1_44ck760 FIND v(dout1_44) AT=385.025n

.meas tran vdout1_45ck760 FIND v(dout1_45) AT=385.025n

.meas tran vdout1_46ck760 FIND v(dout1_46) AT=385.025n

.meas tran vdout1_47ck760 FIND v(dout1_47) AT=385.025n

.meas tran vdout1_48ck760 FIND v(dout1_48) AT=385.025n

.meas tran vdout1_49ck760 FIND v(dout1_49) AT=385.025n

.meas tran vdout1_50ck760 FIND v(dout1_50) AT=385.025n

.meas tran vdout1_51ck760 FIND v(dout1_51) AT=385.025n

.meas tran vdout1_52ck760 FIND v(dout1_52) AT=385.025n

.meas tran vdout1_53ck760 FIND v(dout1_53) AT=385.025n

.meas tran vdout1_54ck760 FIND v(dout1_54) AT=385.025n

.meas tran vdout1_55ck760 FIND v(dout1_55) AT=385.025n

.meas tran vdout1_56ck760 FIND v(dout1_56) AT=385.025n

.meas tran vdout1_57ck760 FIND v(dout1_57) AT=385.025n

.meas tran vdout1_58ck760 FIND v(dout1_58) AT=385.025n

.meas tran vdout1_59ck760 FIND v(dout1_59) AT=385.025n

.meas tran vdout1_60ck760 FIND v(dout1_60) AT=385.025n

.meas tran vdout1_61ck760 FIND v(dout1_61) AT=385.025n

.meas tran vdout1_62ck760 FIND v(dout1_62) AT=385.025n

.meas tran vdout1_63ck760 FIND v(dout1_63) AT=385.025n

.meas tran vdout1_64ck760 FIND v(dout1_64) AT=385.025n

.meas tran vdout1_65ck760 FIND v(dout1_65) AT=385.025n

.meas tran vdout1_66ck760 FIND v(dout1_66) AT=385.025n

.meas tran vdout1_67ck760 FIND v(dout1_67) AT=385.025n

.meas tran vdout1_68ck760 FIND v(dout1_68) AT=385.025n

.meas tran vdout1_69ck760 FIND v(dout1_69) AT=385.025n

.meas tran vdout1_70ck760 FIND v(dout1_70) AT=385.025n

.meas tran vdout1_71ck760 FIND v(dout1_71) AT=385.025n

.meas tran vdout1_72ck760 FIND v(dout1_72) AT=385.025n

.meas tran vdout1_73ck760 FIND v(dout1_73) AT=385.025n

.meas tran vdout1_74ck760 FIND v(dout1_74) AT=385.025n

.meas tran vdout1_75ck760 FIND v(dout1_75) AT=385.025n

.meas tran vdout1_76ck760 FIND v(dout1_76) AT=385.025n

.meas tran vdout1_77ck760 FIND v(dout1_77) AT=385.025n

.meas tran vdout1_78ck760 FIND v(dout1_78) AT=385.025n

.meas tran vdout1_79ck760 FIND v(dout1_79) AT=385.025n

.meas tran vdout1_80ck760 FIND v(dout1_80) AT=385.025n

.meas tran vdout1_81ck760 FIND v(dout1_81) AT=385.025n

.meas tran vdout1_82ck760 FIND v(dout1_82) AT=385.025n

.meas tran vdout1_83ck760 FIND v(dout1_83) AT=385.025n

.meas tran vdout1_84ck760 FIND v(dout1_84) AT=385.025n

.meas tran vdout1_85ck760 FIND v(dout1_85) AT=385.025n

.meas tran vdout1_86ck760 FIND v(dout1_86) AT=385.025n

.meas tran vdout1_87ck760 FIND v(dout1_87) AT=385.025n

.meas tran vdout1_88ck760 FIND v(dout1_88) AT=385.025n

.meas tran vdout1_89ck760 FIND v(dout1_89) AT=385.025n

.meas tran vdout1_90ck760 FIND v(dout1_90) AT=385.025n

.meas tran vdout1_91ck760 FIND v(dout1_91) AT=385.025n

.meas tran vdout1_92ck760 FIND v(dout1_92) AT=385.025n

.meas tran vdout1_93ck760 FIND v(dout1_93) AT=385.025n

.meas tran vdout1_94ck760 FIND v(dout1_94) AT=385.025n

.meas tran vdout1_95ck760 FIND v(dout1_95) AT=385.025n

.meas tran vdout1_96ck760 FIND v(dout1_96) AT=385.025n

.meas tran vdout1_97ck760 FIND v(dout1_97) AT=385.025n

.meas tran vdout1_98ck760 FIND v(dout1_98) AT=385.025n

.meas tran vdout1_99ck760 FIND v(dout1_99) AT=385.025n

.meas tran vdout1_100ck760 FIND v(dout1_100) AT=385.025n

.meas tran vdout1_101ck760 FIND v(dout1_101) AT=385.025n

.meas tran vdout1_102ck760 FIND v(dout1_102) AT=385.025n

.meas tran vdout1_103ck760 FIND v(dout1_103) AT=385.025n

.meas tran vdout1_104ck760 FIND v(dout1_104) AT=385.025n

.meas tran vdout1_105ck760 FIND v(dout1_105) AT=385.025n

.meas tran vdout1_106ck760 FIND v(dout1_106) AT=385.025n

.meas tran vdout1_107ck760 FIND v(dout1_107) AT=385.025n

.meas tran vdout1_108ck760 FIND v(dout1_108) AT=385.025n

.meas tran vdout1_109ck760 FIND v(dout1_109) AT=385.025n

.meas tran vdout1_110ck760 FIND v(dout1_110) AT=385.025n

.meas tran vdout1_111ck760 FIND v(dout1_111) AT=385.025n

.meas tran vdout1_112ck760 FIND v(dout1_112) AT=385.025n

.meas tran vdout1_113ck760 FIND v(dout1_113) AT=385.025n

.meas tran vdout1_114ck760 FIND v(dout1_114) AT=385.025n

.meas tran vdout1_115ck760 FIND v(dout1_115) AT=385.025n

.meas tran vdout1_116ck760 FIND v(dout1_116) AT=385.025n

.meas tran vdout1_117ck760 FIND v(dout1_117) AT=385.025n

.meas tran vdout1_118ck760 FIND v(dout1_118) AT=385.025n

.meas tran vdout1_119ck760 FIND v(dout1_119) AT=385.025n

.meas tran vdout1_120ck760 FIND v(dout1_120) AT=385.025n

.meas tran vdout1_121ck760 FIND v(dout1_121) AT=385.025n

.meas tran vdout1_122ck760 FIND v(dout1_122) AT=385.025n

.meas tran vdout1_123ck760 FIND v(dout1_123) AT=385.025n

.meas tran vdout1_124ck760 FIND v(dout1_124) AT=385.025n

.meas tran vdout1_125ck760 FIND v(dout1_125) AT=385.025n

.meas tran vdout1_126ck760 FIND v(dout1_126) AT=385.025n

.meas tran vdout1_127ck760 FIND v(dout1_127) AT=385.025n

.meas tran vdout1_0ck780 FIND v(dout1_0) AT=395.025n

.meas tran vdout1_1ck780 FIND v(dout1_1) AT=395.025n

.meas tran vdout1_2ck780 FIND v(dout1_2) AT=395.025n

.meas tran vdout1_3ck780 FIND v(dout1_3) AT=395.025n

.meas tran vdout1_4ck780 FIND v(dout1_4) AT=395.025n

.meas tran vdout1_5ck780 FIND v(dout1_5) AT=395.025n

.meas tran vdout1_6ck780 FIND v(dout1_6) AT=395.025n

.meas tran vdout1_7ck780 FIND v(dout1_7) AT=395.025n

.meas tran vdout1_8ck780 FIND v(dout1_8) AT=395.025n

.meas tran vdout1_9ck780 FIND v(dout1_9) AT=395.025n

.meas tran vdout1_10ck780 FIND v(dout1_10) AT=395.025n

.meas tran vdout1_11ck780 FIND v(dout1_11) AT=395.025n

.meas tran vdout1_12ck780 FIND v(dout1_12) AT=395.025n

.meas tran vdout1_13ck780 FIND v(dout1_13) AT=395.025n

.meas tran vdout1_14ck780 FIND v(dout1_14) AT=395.025n

.meas tran vdout1_15ck780 FIND v(dout1_15) AT=395.025n

.meas tran vdout1_16ck780 FIND v(dout1_16) AT=395.025n

.meas tran vdout1_17ck780 FIND v(dout1_17) AT=395.025n

.meas tran vdout1_18ck780 FIND v(dout1_18) AT=395.025n

.meas tran vdout1_19ck780 FIND v(dout1_19) AT=395.025n

.meas tran vdout1_20ck780 FIND v(dout1_20) AT=395.025n

.meas tran vdout1_21ck780 FIND v(dout1_21) AT=395.025n

.meas tran vdout1_22ck780 FIND v(dout1_22) AT=395.025n

.meas tran vdout1_23ck780 FIND v(dout1_23) AT=395.025n

.meas tran vdout1_24ck780 FIND v(dout1_24) AT=395.025n

.meas tran vdout1_25ck780 FIND v(dout1_25) AT=395.025n

.meas tran vdout1_26ck780 FIND v(dout1_26) AT=395.025n

.meas tran vdout1_27ck780 FIND v(dout1_27) AT=395.025n

.meas tran vdout1_28ck780 FIND v(dout1_28) AT=395.025n

.meas tran vdout1_29ck780 FIND v(dout1_29) AT=395.025n

.meas tran vdout1_30ck780 FIND v(dout1_30) AT=395.025n

.meas tran vdout1_31ck780 FIND v(dout1_31) AT=395.025n

.meas tran vdout1_32ck780 FIND v(dout1_32) AT=395.025n

.meas tran vdout1_33ck780 FIND v(dout1_33) AT=395.025n

.meas tran vdout1_34ck780 FIND v(dout1_34) AT=395.025n

.meas tran vdout1_35ck780 FIND v(dout1_35) AT=395.025n

.meas tran vdout1_36ck780 FIND v(dout1_36) AT=395.025n

.meas tran vdout1_37ck780 FIND v(dout1_37) AT=395.025n

.meas tran vdout1_38ck780 FIND v(dout1_38) AT=395.025n

.meas tran vdout1_39ck780 FIND v(dout1_39) AT=395.025n

.meas tran vdout1_40ck780 FIND v(dout1_40) AT=395.025n

.meas tran vdout1_41ck780 FIND v(dout1_41) AT=395.025n

.meas tran vdout1_42ck780 FIND v(dout1_42) AT=395.025n

.meas tran vdout1_43ck780 FIND v(dout1_43) AT=395.025n

.meas tran vdout1_44ck780 FIND v(dout1_44) AT=395.025n

.meas tran vdout1_45ck780 FIND v(dout1_45) AT=395.025n

.meas tran vdout1_46ck780 FIND v(dout1_46) AT=395.025n

.meas tran vdout1_47ck780 FIND v(dout1_47) AT=395.025n

.meas tran vdout1_48ck780 FIND v(dout1_48) AT=395.025n

.meas tran vdout1_49ck780 FIND v(dout1_49) AT=395.025n

.meas tran vdout1_50ck780 FIND v(dout1_50) AT=395.025n

.meas tran vdout1_51ck780 FIND v(dout1_51) AT=395.025n

.meas tran vdout1_52ck780 FIND v(dout1_52) AT=395.025n

.meas tran vdout1_53ck780 FIND v(dout1_53) AT=395.025n

.meas tran vdout1_54ck780 FIND v(dout1_54) AT=395.025n

.meas tran vdout1_55ck780 FIND v(dout1_55) AT=395.025n

.meas tran vdout1_56ck780 FIND v(dout1_56) AT=395.025n

.meas tran vdout1_57ck780 FIND v(dout1_57) AT=395.025n

.meas tran vdout1_58ck780 FIND v(dout1_58) AT=395.025n

.meas tran vdout1_59ck780 FIND v(dout1_59) AT=395.025n

.meas tran vdout1_60ck780 FIND v(dout1_60) AT=395.025n

.meas tran vdout1_61ck780 FIND v(dout1_61) AT=395.025n

.meas tran vdout1_62ck780 FIND v(dout1_62) AT=395.025n

.meas tran vdout1_63ck780 FIND v(dout1_63) AT=395.025n

.meas tran vdout1_64ck780 FIND v(dout1_64) AT=395.025n

.meas tran vdout1_65ck780 FIND v(dout1_65) AT=395.025n

.meas tran vdout1_66ck780 FIND v(dout1_66) AT=395.025n

.meas tran vdout1_67ck780 FIND v(dout1_67) AT=395.025n

.meas tran vdout1_68ck780 FIND v(dout1_68) AT=395.025n

.meas tran vdout1_69ck780 FIND v(dout1_69) AT=395.025n

.meas tran vdout1_70ck780 FIND v(dout1_70) AT=395.025n

.meas tran vdout1_71ck780 FIND v(dout1_71) AT=395.025n

.meas tran vdout1_72ck780 FIND v(dout1_72) AT=395.025n

.meas tran vdout1_73ck780 FIND v(dout1_73) AT=395.025n

.meas tran vdout1_74ck780 FIND v(dout1_74) AT=395.025n

.meas tran vdout1_75ck780 FIND v(dout1_75) AT=395.025n

.meas tran vdout1_76ck780 FIND v(dout1_76) AT=395.025n

.meas tran vdout1_77ck780 FIND v(dout1_77) AT=395.025n

.meas tran vdout1_78ck780 FIND v(dout1_78) AT=395.025n

.meas tran vdout1_79ck780 FIND v(dout1_79) AT=395.025n

.meas tran vdout1_80ck780 FIND v(dout1_80) AT=395.025n

.meas tran vdout1_81ck780 FIND v(dout1_81) AT=395.025n

.meas tran vdout1_82ck780 FIND v(dout1_82) AT=395.025n

.meas tran vdout1_83ck780 FIND v(dout1_83) AT=395.025n

.meas tran vdout1_84ck780 FIND v(dout1_84) AT=395.025n

.meas tran vdout1_85ck780 FIND v(dout1_85) AT=395.025n

.meas tran vdout1_86ck780 FIND v(dout1_86) AT=395.025n

.meas tran vdout1_87ck780 FIND v(dout1_87) AT=395.025n

.meas tran vdout1_88ck780 FIND v(dout1_88) AT=395.025n

.meas tran vdout1_89ck780 FIND v(dout1_89) AT=395.025n

.meas tran vdout1_90ck780 FIND v(dout1_90) AT=395.025n

.meas tran vdout1_91ck780 FIND v(dout1_91) AT=395.025n

.meas tran vdout1_92ck780 FIND v(dout1_92) AT=395.025n

.meas tran vdout1_93ck780 FIND v(dout1_93) AT=395.025n

.meas tran vdout1_94ck780 FIND v(dout1_94) AT=395.025n

.meas tran vdout1_95ck780 FIND v(dout1_95) AT=395.025n

.meas tran vdout1_96ck780 FIND v(dout1_96) AT=395.025n

.meas tran vdout1_97ck780 FIND v(dout1_97) AT=395.025n

.meas tran vdout1_98ck780 FIND v(dout1_98) AT=395.025n

.meas tran vdout1_99ck780 FIND v(dout1_99) AT=395.025n

.meas tran vdout1_100ck780 FIND v(dout1_100) AT=395.025n

.meas tran vdout1_101ck780 FIND v(dout1_101) AT=395.025n

.meas tran vdout1_102ck780 FIND v(dout1_102) AT=395.025n

.meas tran vdout1_103ck780 FIND v(dout1_103) AT=395.025n

.meas tran vdout1_104ck780 FIND v(dout1_104) AT=395.025n

.meas tran vdout1_105ck780 FIND v(dout1_105) AT=395.025n

.meas tran vdout1_106ck780 FIND v(dout1_106) AT=395.025n

.meas tran vdout1_107ck780 FIND v(dout1_107) AT=395.025n

.meas tran vdout1_108ck780 FIND v(dout1_108) AT=395.025n

.meas tran vdout1_109ck780 FIND v(dout1_109) AT=395.025n

.meas tran vdout1_110ck780 FIND v(dout1_110) AT=395.025n

.meas tran vdout1_111ck780 FIND v(dout1_111) AT=395.025n

.meas tran vdout1_112ck780 FIND v(dout1_112) AT=395.025n

.meas tran vdout1_113ck780 FIND v(dout1_113) AT=395.025n

.meas tran vdout1_114ck780 FIND v(dout1_114) AT=395.025n

.meas tran vdout1_115ck780 FIND v(dout1_115) AT=395.025n

.meas tran vdout1_116ck780 FIND v(dout1_116) AT=395.025n

.meas tran vdout1_117ck780 FIND v(dout1_117) AT=395.025n

.meas tran vdout1_118ck780 FIND v(dout1_118) AT=395.025n

.meas tran vdout1_119ck780 FIND v(dout1_119) AT=395.025n

.meas tran vdout1_120ck780 FIND v(dout1_120) AT=395.025n

.meas tran vdout1_121ck780 FIND v(dout1_121) AT=395.025n

.meas tran vdout1_122ck780 FIND v(dout1_122) AT=395.025n

.meas tran vdout1_123ck780 FIND v(dout1_123) AT=395.025n

.meas tran vdout1_124ck780 FIND v(dout1_124) AT=395.025n

.meas tran vdout1_125ck780 FIND v(dout1_125) AT=395.025n

.meas tran vdout1_126ck780 FIND v(dout1_126) AT=395.025n

.meas tran vdout1_127ck780 FIND v(dout1_127) AT=395.025n

.meas tran vdout1_0ck810 FIND v(dout1_0) AT=410.025n

.meas tran vdout1_1ck810 FIND v(dout1_1) AT=410.025n

.meas tran vdout1_2ck810 FIND v(dout1_2) AT=410.025n

.meas tran vdout1_3ck810 FIND v(dout1_3) AT=410.025n

.meas tran vdout1_4ck810 FIND v(dout1_4) AT=410.025n

.meas tran vdout1_5ck810 FIND v(dout1_5) AT=410.025n

.meas tran vdout1_6ck810 FIND v(dout1_6) AT=410.025n

.meas tran vdout1_7ck810 FIND v(dout1_7) AT=410.025n

.meas tran vdout1_8ck810 FIND v(dout1_8) AT=410.025n

.meas tran vdout1_9ck810 FIND v(dout1_9) AT=410.025n

.meas tran vdout1_10ck810 FIND v(dout1_10) AT=410.025n

.meas tran vdout1_11ck810 FIND v(dout1_11) AT=410.025n

.meas tran vdout1_12ck810 FIND v(dout1_12) AT=410.025n

.meas tran vdout1_13ck810 FIND v(dout1_13) AT=410.025n

.meas tran vdout1_14ck810 FIND v(dout1_14) AT=410.025n

.meas tran vdout1_15ck810 FIND v(dout1_15) AT=410.025n

.meas tran vdout1_16ck810 FIND v(dout1_16) AT=410.025n

.meas tran vdout1_17ck810 FIND v(dout1_17) AT=410.025n

.meas tran vdout1_18ck810 FIND v(dout1_18) AT=410.025n

.meas tran vdout1_19ck810 FIND v(dout1_19) AT=410.025n

.meas tran vdout1_20ck810 FIND v(dout1_20) AT=410.025n

.meas tran vdout1_21ck810 FIND v(dout1_21) AT=410.025n

.meas tran vdout1_22ck810 FIND v(dout1_22) AT=410.025n

.meas tran vdout1_23ck810 FIND v(dout1_23) AT=410.025n

.meas tran vdout1_24ck810 FIND v(dout1_24) AT=410.025n

.meas tran vdout1_25ck810 FIND v(dout1_25) AT=410.025n

.meas tran vdout1_26ck810 FIND v(dout1_26) AT=410.025n

.meas tran vdout1_27ck810 FIND v(dout1_27) AT=410.025n

.meas tran vdout1_28ck810 FIND v(dout1_28) AT=410.025n

.meas tran vdout1_29ck810 FIND v(dout1_29) AT=410.025n

.meas tran vdout1_30ck810 FIND v(dout1_30) AT=410.025n

.meas tran vdout1_31ck810 FIND v(dout1_31) AT=410.025n

.meas tran vdout1_32ck810 FIND v(dout1_32) AT=410.025n

.meas tran vdout1_33ck810 FIND v(dout1_33) AT=410.025n

.meas tran vdout1_34ck810 FIND v(dout1_34) AT=410.025n

.meas tran vdout1_35ck810 FIND v(dout1_35) AT=410.025n

.meas tran vdout1_36ck810 FIND v(dout1_36) AT=410.025n

.meas tran vdout1_37ck810 FIND v(dout1_37) AT=410.025n

.meas tran vdout1_38ck810 FIND v(dout1_38) AT=410.025n

.meas tran vdout1_39ck810 FIND v(dout1_39) AT=410.025n

.meas tran vdout1_40ck810 FIND v(dout1_40) AT=410.025n

.meas tran vdout1_41ck810 FIND v(dout1_41) AT=410.025n

.meas tran vdout1_42ck810 FIND v(dout1_42) AT=410.025n

.meas tran vdout1_43ck810 FIND v(dout1_43) AT=410.025n

.meas tran vdout1_44ck810 FIND v(dout1_44) AT=410.025n

.meas tran vdout1_45ck810 FIND v(dout1_45) AT=410.025n

.meas tran vdout1_46ck810 FIND v(dout1_46) AT=410.025n

.meas tran vdout1_47ck810 FIND v(dout1_47) AT=410.025n

.meas tran vdout1_48ck810 FIND v(dout1_48) AT=410.025n

.meas tran vdout1_49ck810 FIND v(dout1_49) AT=410.025n

.meas tran vdout1_50ck810 FIND v(dout1_50) AT=410.025n

.meas tran vdout1_51ck810 FIND v(dout1_51) AT=410.025n

.meas tran vdout1_52ck810 FIND v(dout1_52) AT=410.025n

.meas tran vdout1_53ck810 FIND v(dout1_53) AT=410.025n

.meas tran vdout1_54ck810 FIND v(dout1_54) AT=410.025n

.meas tran vdout1_55ck810 FIND v(dout1_55) AT=410.025n

.meas tran vdout1_56ck810 FIND v(dout1_56) AT=410.025n

.meas tran vdout1_57ck810 FIND v(dout1_57) AT=410.025n

.meas tran vdout1_58ck810 FIND v(dout1_58) AT=410.025n

.meas tran vdout1_59ck810 FIND v(dout1_59) AT=410.025n

.meas tran vdout1_60ck810 FIND v(dout1_60) AT=410.025n

.meas tran vdout1_61ck810 FIND v(dout1_61) AT=410.025n

.meas tran vdout1_62ck810 FIND v(dout1_62) AT=410.025n

.meas tran vdout1_63ck810 FIND v(dout1_63) AT=410.025n

.meas tran vdout1_64ck810 FIND v(dout1_64) AT=410.025n

.meas tran vdout1_65ck810 FIND v(dout1_65) AT=410.025n

.meas tran vdout1_66ck810 FIND v(dout1_66) AT=410.025n

.meas tran vdout1_67ck810 FIND v(dout1_67) AT=410.025n

.meas tran vdout1_68ck810 FIND v(dout1_68) AT=410.025n

.meas tran vdout1_69ck810 FIND v(dout1_69) AT=410.025n

.meas tran vdout1_70ck810 FIND v(dout1_70) AT=410.025n

.meas tran vdout1_71ck810 FIND v(dout1_71) AT=410.025n

.meas tran vdout1_72ck810 FIND v(dout1_72) AT=410.025n

.meas tran vdout1_73ck810 FIND v(dout1_73) AT=410.025n

.meas tran vdout1_74ck810 FIND v(dout1_74) AT=410.025n

.meas tran vdout1_75ck810 FIND v(dout1_75) AT=410.025n

.meas tran vdout1_76ck810 FIND v(dout1_76) AT=410.025n

.meas tran vdout1_77ck810 FIND v(dout1_77) AT=410.025n

.meas tran vdout1_78ck810 FIND v(dout1_78) AT=410.025n

.meas tran vdout1_79ck810 FIND v(dout1_79) AT=410.025n

.meas tran vdout1_80ck810 FIND v(dout1_80) AT=410.025n

.meas tran vdout1_81ck810 FIND v(dout1_81) AT=410.025n

.meas tran vdout1_82ck810 FIND v(dout1_82) AT=410.025n

.meas tran vdout1_83ck810 FIND v(dout1_83) AT=410.025n

.meas tran vdout1_84ck810 FIND v(dout1_84) AT=410.025n

.meas tran vdout1_85ck810 FIND v(dout1_85) AT=410.025n

.meas tran vdout1_86ck810 FIND v(dout1_86) AT=410.025n

.meas tran vdout1_87ck810 FIND v(dout1_87) AT=410.025n

.meas tran vdout1_88ck810 FIND v(dout1_88) AT=410.025n

.meas tran vdout1_89ck810 FIND v(dout1_89) AT=410.025n

.meas tran vdout1_90ck810 FIND v(dout1_90) AT=410.025n

.meas tran vdout1_91ck810 FIND v(dout1_91) AT=410.025n

.meas tran vdout1_92ck810 FIND v(dout1_92) AT=410.025n

.meas tran vdout1_93ck810 FIND v(dout1_93) AT=410.025n

.meas tran vdout1_94ck810 FIND v(dout1_94) AT=410.025n

.meas tran vdout1_95ck810 FIND v(dout1_95) AT=410.025n

.meas tran vdout1_96ck810 FIND v(dout1_96) AT=410.025n

.meas tran vdout1_97ck810 FIND v(dout1_97) AT=410.025n

.meas tran vdout1_98ck810 FIND v(dout1_98) AT=410.025n

.meas tran vdout1_99ck810 FIND v(dout1_99) AT=410.025n

.meas tran vdout1_100ck810 FIND v(dout1_100) AT=410.025n

.meas tran vdout1_101ck810 FIND v(dout1_101) AT=410.025n

.meas tran vdout1_102ck810 FIND v(dout1_102) AT=410.025n

.meas tran vdout1_103ck810 FIND v(dout1_103) AT=410.025n

.meas tran vdout1_104ck810 FIND v(dout1_104) AT=410.025n

.meas tran vdout1_105ck810 FIND v(dout1_105) AT=410.025n

.meas tran vdout1_106ck810 FIND v(dout1_106) AT=410.025n

.meas tran vdout1_107ck810 FIND v(dout1_107) AT=410.025n

.meas tran vdout1_108ck810 FIND v(dout1_108) AT=410.025n

.meas tran vdout1_109ck810 FIND v(dout1_109) AT=410.025n

.meas tran vdout1_110ck810 FIND v(dout1_110) AT=410.025n

.meas tran vdout1_111ck810 FIND v(dout1_111) AT=410.025n

.meas tran vdout1_112ck810 FIND v(dout1_112) AT=410.025n

.meas tran vdout1_113ck810 FIND v(dout1_113) AT=410.025n

.meas tran vdout1_114ck810 FIND v(dout1_114) AT=410.025n

.meas tran vdout1_115ck810 FIND v(dout1_115) AT=410.025n

.meas tran vdout1_116ck810 FIND v(dout1_116) AT=410.025n

.meas tran vdout1_117ck810 FIND v(dout1_117) AT=410.025n

.meas tran vdout1_118ck810 FIND v(dout1_118) AT=410.025n

.meas tran vdout1_119ck810 FIND v(dout1_119) AT=410.025n

.meas tran vdout1_120ck810 FIND v(dout1_120) AT=410.025n

.meas tran vdout1_121ck810 FIND v(dout1_121) AT=410.025n

.meas tran vdout1_122ck810 FIND v(dout1_122) AT=410.025n

.meas tran vdout1_123ck810 FIND v(dout1_123) AT=410.025n

.meas tran vdout1_124ck810 FIND v(dout1_124) AT=410.025n

.meas tran vdout1_125ck810 FIND v(dout1_125) AT=410.025n

.meas tran vdout1_126ck810 FIND v(dout1_126) AT=410.025n

.meas tran vdout1_127ck810 FIND v(dout1_127) AT=410.025n

.meas tran vdout1_0ck830 FIND v(dout1_0) AT=420.025n

.meas tran vdout1_1ck830 FIND v(dout1_1) AT=420.025n

.meas tran vdout1_2ck830 FIND v(dout1_2) AT=420.025n

.meas tran vdout1_3ck830 FIND v(dout1_3) AT=420.025n

.meas tran vdout1_4ck830 FIND v(dout1_4) AT=420.025n

.meas tran vdout1_5ck830 FIND v(dout1_5) AT=420.025n

.meas tran vdout1_6ck830 FIND v(dout1_6) AT=420.025n

.meas tran vdout1_7ck830 FIND v(dout1_7) AT=420.025n

.meas tran vdout1_8ck830 FIND v(dout1_8) AT=420.025n

.meas tran vdout1_9ck830 FIND v(dout1_9) AT=420.025n

.meas tran vdout1_10ck830 FIND v(dout1_10) AT=420.025n

.meas tran vdout1_11ck830 FIND v(dout1_11) AT=420.025n

.meas tran vdout1_12ck830 FIND v(dout1_12) AT=420.025n

.meas tran vdout1_13ck830 FIND v(dout1_13) AT=420.025n

.meas tran vdout1_14ck830 FIND v(dout1_14) AT=420.025n

.meas tran vdout1_15ck830 FIND v(dout1_15) AT=420.025n

.meas tran vdout1_16ck830 FIND v(dout1_16) AT=420.025n

.meas tran vdout1_17ck830 FIND v(dout1_17) AT=420.025n

.meas tran vdout1_18ck830 FIND v(dout1_18) AT=420.025n

.meas tran vdout1_19ck830 FIND v(dout1_19) AT=420.025n

.meas tran vdout1_20ck830 FIND v(dout1_20) AT=420.025n

.meas tran vdout1_21ck830 FIND v(dout1_21) AT=420.025n

.meas tran vdout1_22ck830 FIND v(dout1_22) AT=420.025n

.meas tran vdout1_23ck830 FIND v(dout1_23) AT=420.025n

.meas tran vdout1_24ck830 FIND v(dout1_24) AT=420.025n

.meas tran vdout1_25ck830 FIND v(dout1_25) AT=420.025n

.meas tran vdout1_26ck830 FIND v(dout1_26) AT=420.025n

.meas tran vdout1_27ck830 FIND v(dout1_27) AT=420.025n

.meas tran vdout1_28ck830 FIND v(dout1_28) AT=420.025n

.meas tran vdout1_29ck830 FIND v(dout1_29) AT=420.025n

.meas tran vdout1_30ck830 FIND v(dout1_30) AT=420.025n

.meas tran vdout1_31ck830 FIND v(dout1_31) AT=420.025n

.meas tran vdout1_32ck830 FIND v(dout1_32) AT=420.025n

.meas tran vdout1_33ck830 FIND v(dout1_33) AT=420.025n

.meas tran vdout1_34ck830 FIND v(dout1_34) AT=420.025n

.meas tran vdout1_35ck830 FIND v(dout1_35) AT=420.025n

.meas tran vdout1_36ck830 FIND v(dout1_36) AT=420.025n

.meas tran vdout1_37ck830 FIND v(dout1_37) AT=420.025n

.meas tran vdout1_38ck830 FIND v(dout1_38) AT=420.025n

.meas tran vdout1_39ck830 FIND v(dout1_39) AT=420.025n

.meas tran vdout1_40ck830 FIND v(dout1_40) AT=420.025n

.meas tran vdout1_41ck830 FIND v(dout1_41) AT=420.025n

.meas tran vdout1_42ck830 FIND v(dout1_42) AT=420.025n

.meas tran vdout1_43ck830 FIND v(dout1_43) AT=420.025n

.meas tran vdout1_44ck830 FIND v(dout1_44) AT=420.025n

.meas tran vdout1_45ck830 FIND v(dout1_45) AT=420.025n

.meas tran vdout1_46ck830 FIND v(dout1_46) AT=420.025n

.meas tran vdout1_47ck830 FIND v(dout1_47) AT=420.025n

.meas tran vdout1_48ck830 FIND v(dout1_48) AT=420.025n

.meas tran vdout1_49ck830 FIND v(dout1_49) AT=420.025n

.meas tran vdout1_50ck830 FIND v(dout1_50) AT=420.025n

.meas tran vdout1_51ck830 FIND v(dout1_51) AT=420.025n

.meas tran vdout1_52ck830 FIND v(dout1_52) AT=420.025n

.meas tran vdout1_53ck830 FIND v(dout1_53) AT=420.025n

.meas tran vdout1_54ck830 FIND v(dout1_54) AT=420.025n

.meas tran vdout1_55ck830 FIND v(dout1_55) AT=420.025n

.meas tran vdout1_56ck830 FIND v(dout1_56) AT=420.025n

.meas tran vdout1_57ck830 FIND v(dout1_57) AT=420.025n

.meas tran vdout1_58ck830 FIND v(dout1_58) AT=420.025n

.meas tran vdout1_59ck830 FIND v(dout1_59) AT=420.025n

.meas tran vdout1_60ck830 FIND v(dout1_60) AT=420.025n

.meas tran vdout1_61ck830 FIND v(dout1_61) AT=420.025n

.meas tran vdout1_62ck830 FIND v(dout1_62) AT=420.025n

.meas tran vdout1_63ck830 FIND v(dout1_63) AT=420.025n

.meas tran vdout1_64ck830 FIND v(dout1_64) AT=420.025n

.meas tran vdout1_65ck830 FIND v(dout1_65) AT=420.025n

.meas tran vdout1_66ck830 FIND v(dout1_66) AT=420.025n

.meas tran vdout1_67ck830 FIND v(dout1_67) AT=420.025n

.meas tran vdout1_68ck830 FIND v(dout1_68) AT=420.025n

.meas tran vdout1_69ck830 FIND v(dout1_69) AT=420.025n

.meas tran vdout1_70ck830 FIND v(dout1_70) AT=420.025n

.meas tran vdout1_71ck830 FIND v(dout1_71) AT=420.025n

.meas tran vdout1_72ck830 FIND v(dout1_72) AT=420.025n

.meas tran vdout1_73ck830 FIND v(dout1_73) AT=420.025n

.meas tran vdout1_74ck830 FIND v(dout1_74) AT=420.025n

.meas tran vdout1_75ck830 FIND v(dout1_75) AT=420.025n

.meas tran vdout1_76ck830 FIND v(dout1_76) AT=420.025n

.meas tran vdout1_77ck830 FIND v(dout1_77) AT=420.025n

.meas tran vdout1_78ck830 FIND v(dout1_78) AT=420.025n

.meas tran vdout1_79ck830 FIND v(dout1_79) AT=420.025n

.meas tran vdout1_80ck830 FIND v(dout1_80) AT=420.025n

.meas tran vdout1_81ck830 FIND v(dout1_81) AT=420.025n

.meas tran vdout1_82ck830 FIND v(dout1_82) AT=420.025n

.meas tran vdout1_83ck830 FIND v(dout1_83) AT=420.025n

.meas tran vdout1_84ck830 FIND v(dout1_84) AT=420.025n

.meas tran vdout1_85ck830 FIND v(dout1_85) AT=420.025n

.meas tran vdout1_86ck830 FIND v(dout1_86) AT=420.025n

.meas tran vdout1_87ck830 FIND v(dout1_87) AT=420.025n

.meas tran vdout1_88ck830 FIND v(dout1_88) AT=420.025n

.meas tran vdout1_89ck830 FIND v(dout1_89) AT=420.025n

.meas tran vdout1_90ck830 FIND v(dout1_90) AT=420.025n

.meas tran vdout1_91ck830 FIND v(dout1_91) AT=420.025n

.meas tran vdout1_92ck830 FIND v(dout1_92) AT=420.025n

.meas tran vdout1_93ck830 FIND v(dout1_93) AT=420.025n

.meas tran vdout1_94ck830 FIND v(dout1_94) AT=420.025n

.meas tran vdout1_95ck830 FIND v(dout1_95) AT=420.025n

.meas tran vdout1_96ck830 FIND v(dout1_96) AT=420.025n

.meas tran vdout1_97ck830 FIND v(dout1_97) AT=420.025n

.meas tran vdout1_98ck830 FIND v(dout1_98) AT=420.025n

.meas tran vdout1_99ck830 FIND v(dout1_99) AT=420.025n

.meas tran vdout1_100ck830 FIND v(dout1_100) AT=420.025n

.meas tran vdout1_101ck830 FIND v(dout1_101) AT=420.025n

.meas tran vdout1_102ck830 FIND v(dout1_102) AT=420.025n

.meas tran vdout1_103ck830 FIND v(dout1_103) AT=420.025n

.meas tran vdout1_104ck830 FIND v(dout1_104) AT=420.025n

.meas tran vdout1_105ck830 FIND v(dout1_105) AT=420.025n

.meas tran vdout1_106ck830 FIND v(dout1_106) AT=420.025n

.meas tran vdout1_107ck830 FIND v(dout1_107) AT=420.025n

.meas tran vdout1_108ck830 FIND v(dout1_108) AT=420.025n

.meas tran vdout1_109ck830 FIND v(dout1_109) AT=420.025n

.meas tran vdout1_110ck830 FIND v(dout1_110) AT=420.025n

.meas tran vdout1_111ck830 FIND v(dout1_111) AT=420.025n

.meas tran vdout1_112ck830 FIND v(dout1_112) AT=420.025n

.meas tran vdout1_113ck830 FIND v(dout1_113) AT=420.025n

.meas tran vdout1_114ck830 FIND v(dout1_114) AT=420.025n

.meas tran vdout1_115ck830 FIND v(dout1_115) AT=420.025n

.meas tran vdout1_116ck830 FIND v(dout1_116) AT=420.025n

.meas tran vdout1_117ck830 FIND v(dout1_117) AT=420.025n

.meas tran vdout1_118ck830 FIND v(dout1_118) AT=420.025n

.meas tran vdout1_119ck830 FIND v(dout1_119) AT=420.025n

.meas tran vdout1_120ck830 FIND v(dout1_120) AT=420.025n

.meas tran vdout1_121ck830 FIND v(dout1_121) AT=420.025n

.meas tran vdout1_122ck830 FIND v(dout1_122) AT=420.025n

.meas tran vdout1_123ck830 FIND v(dout1_123) AT=420.025n

.meas tran vdout1_124ck830 FIND v(dout1_124) AT=420.025n

.meas tran vdout1_125ck830 FIND v(dout1_125) AT=420.025n

.meas tran vdout1_126ck830 FIND v(dout1_126) AT=420.025n

.meas tran vdout1_127ck830 FIND v(dout1_127) AT=420.025n

.meas tran vdout1_0ck850 FIND v(dout1_0) AT=430.025n

.meas tran vdout1_1ck850 FIND v(dout1_1) AT=430.025n

.meas tran vdout1_2ck850 FIND v(dout1_2) AT=430.025n

.meas tran vdout1_3ck850 FIND v(dout1_3) AT=430.025n

.meas tran vdout1_4ck850 FIND v(dout1_4) AT=430.025n

.meas tran vdout1_5ck850 FIND v(dout1_5) AT=430.025n

.meas tran vdout1_6ck850 FIND v(dout1_6) AT=430.025n

.meas tran vdout1_7ck850 FIND v(dout1_7) AT=430.025n

.meas tran vdout1_8ck850 FIND v(dout1_8) AT=430.025n

.meas tran vdout1_9ck850 FIND v(dout1_9) AT=430.025n

.meas tran vdout1_10ck850 FIND v(dout1_10) AT=430.025n

.meas tran vdout1_11ck850 FIND v(dout1_11) AT=430.025n

.meas tran vdout1_12ck850 FIND v(dout1_12) AT=430.025n

.meas tran vdout1_13ck850 FIND v(dout1_13) AT=430.025n

.meas tran vdout1_14ck850 FIND v(dout1_14) AT=430.025n

.meas tran vdout1_15ck850 FIND v(dout1_15) AT=430.025n

.meas tran vdout1_16ck850 FIND v(dout1_16) AT=430.025n

.meas tran vdout1_17ck850 FIND v(dout1_17) AT=430.025n

.meas tran vdout1_18ck850 FIND v(dout1_18) AT=430.025n

.meas tran vdout1_19ck850 FIND v(dout1_19) AT=430.025n

.meas tran vdout1_20ck850 FIND v(dout1_20) AT=430.025n

.meas tran vdout1_21ck850 FIND v(dout1_21) AT=430.025n

.meas tran vdout1_22ck850 FIND v(dout1_22) AT=430.025n

.meas tran vdout1_23ck850 FIND v(dout1_23) AT=430.025n

.meas tran vdout1_24ck850 FIND v(dout1_24) AT=430.025n

.meas tran vdout1_25ck850 FIND v(dout1_25) AT=430.025n

.meas tran vdout1_26ck850 FIND v(dout1_26) AT=430.025n

.meas tran vdout1_27ck850 FIND v(dout1_27) AT=430.025n

.meas tran vdout1_28ck850 FIND v(dout1_28) AT=430.025n

.meas tran vdout1_29ck850 FIND v(dout1_29) AT=430.025n

.meas tran vdout1_30ck850 FIND v(dout1_30) AT=430.025n

.meas tran vdout1_31ck850 FIND v(dout1_31) AT=430.025n

.meas tran vdout1_32ck850 FIND v(dout1_32) AT=430.025n

.meas tran vdout1_33ck850 FIND v(dout1_33) AT=430.025n

.meas tran vdout1_34ck850 FIND v(dout1_34) AT=430.025n

.meas tran vdout1_35ck850 FIND v(dout1_35) AT=430.025n

.meas tran vdout1_36ck850 FIND v(dout1_36) AT=430.025n

.meas tran vdout1_37ck850 FIND v(dout1_37) AT=430.025n

.meas tran vdout1_38ck850 FIND v(dout1_38) AT=430.025n

.meas tran vdout1_39ck850 FIND v(dout1_39) AT=430.025n

.meas tran vdout1_40ck850 FIND v(dout1_40) AT=430.025n

.meas tran vdout1_41ck850 FIND v(dout1_41) AT=430.025n

.meas tran vdout1_42ck850 FIND v(dout1_42) AT=430.025n

.meas tran vdout1_43ck850 FIND v(dout1_43) AT=430.025n

.meas tran vdout1_44ck850 FIND v(dout1_44) AT=430.025n

.meas tran vdout1_45ck850 FIND v(dout1_45) AT=430.025n

.meas tran vdout1_46ck850 FIND v(dout1_46) AT=430.025n

.meas tran vdout1_47ck850 FIND v(dout1_47) AT=430.025n

.meas tran vdout1_48ck850 FIND v(dout1_48) AT=430.025n

.meas tran vdout1_49ck850 FIND v(dout1_49) AT=430.025n

.meas tran vdout1_50ck850 FIND v(dout1_50) AT=430.025n

.meas tran vdout1_51ck850 FIND v(dout1_51) AT=430.025n

.meas tran vdout1_52ck850 FIND v(dout1_52) AT=430.025n

.meas tran vdout1_53ck850 FIND v(dout1_53) AT=430.025n

.meas tran vdout1_54ck850 FIND v(dout1_54) AT=430.025n

.meas tran vdout1_55ck850 FIND v(dout1_55) AT=430.025n

.meas tran vdout1_56ck850 FIND v(dout1_56) AT=430.025n

.meas tran vdout1_57ck850 FIND v(dout1_57) AT=430.025n

.meas tran vdout1_58ck850 FIND v(dout1_58) AT=430.025n

.meas tran vdout1_59ck850 FIND v(dout1_59) AT=430.025n

.meas tran vdout1_60ck850 FIND v(dout1_60) AT=430.025n

.meas tran vdout1_61ck850 FIND v(dout1_61) AT=430.025n

.meas tran vdout1_62ck850 FIND v(dout1_62) AT=430.025n

.meas tran vdout1_63ck850 FIND v(dout1_63) AT=430.025n

.meas tran vdout1_64ck850 FIND v(dout1_64) AT=430.025n

.meas tran vdout1_65ck850 FIND v(dout1_65) AT=430.025n

.meas tran vdout1_66ck850 FIND v(dout1_66) AT=430.025n

.meas tran vdout1_67ck850 FIND v(dout1_67) AT=430.025n

.meas tran vdout1_68ck850 FIND v(dout1_68) AT=430.025n

.meas tran vdout1_69ck850 FIND v(dout1_69) AT=430.025n

.meas tran vdout1_70ck850 FIND v(dout1_70) AT=430.025n

.meas tran vdout1_71ck850 FIND v(dout1_71) AT=430.025n

.meas tran vdout1_72ck850 FIND v(dout1_72) AT=430.025n

.meas tran vdout1_73ck850 FIND v(dout1_73) AT=430.025n

.meas tran vdout1_74ck850 FIND v(dout1_74) AT=430.025n

.meas tran vdout1_75ck850 FIND v(dout1_75) AT=430.025n

.meas tran vdout1_76ck850 FIND v(dout1_76) AT=430.025n

.meas tran vdout1_77ck850 FIND v(dout1_77) AT=430.025n

.meas tran vdout1_78ck850 FIND v(dout1_78) AT=430.025n

.meas tran vdout1_79ck850 FIND v(dout1_79) AT=430.025n

.meas tran vdout1_80ck850 FIND v(dout1_80) AT=430.025n

.meas tran vdout1_81ck850 FIND v(dout1_81) AT=430.025n

.meas tran vdout1_82ck850 FIND v(dout1_82) AT=430.025n

.meas tran vdout1_83ck850 FIND v(dout1_83) AT=430.025n

.meas tran vdout1_84ck850 FIND v(dout1_84) AT=430.025n

.meas tran vdout1_85ck850 FIND v(dout1_85) AT=430.025n

.meas tran vdout1_86ck850 FIND v(dout1_86) AT=430.025n

.meas tran vdout1_87ck850 FIND v(dout1_87) AT=430.025n

.meas tran vdout1_88ck850 FIND v(dout1_88) AT=430.025n

.meas tran vdout1_89ck850 FIND v(dout1_89) AT=430.025n

.meas tran vdout1_90ck850 FIND v(dout1_90) AT=430.025n

.meas tran vdout1_91ck850 FIND v(dout1_91) AT=430.025n

.meas tran vdout1_92ck850 FIND v(dout1_92) AT=430.025n

.meas tran vdout1_93ck850 FIND v(dout1_93) AT=430.025n

.meas tran vdout1_94ck850 FIND v(dout1_94) AT=430.025n

.meas tran vdout1_95ck850 FIND v(dout1_95) AT=430.025n

.meas tran vdout1_96ck850 FIND v(dout1_96) AT=430.025n

.meas tran vdout1_97ck850 FIND v(dout1_97) AT=430.025n

.meas tran vdout1_98ck850 FIND v(dout1_98) AT=430.025n

.meas tran vdout1_99ck850 FIND v(dout1_99) AT=430.025n

.meas tran vdout1_100ck850 FIND v(dout1_100) AT=430.025n

.meas tran vdout1_101ck850 FIND v(dout1_101) AT=430.025n

.meas tran vdout1_102ck850 FIND v(dout1_102) AT=430.025n

.meas tran vdout1_103ck850 FIND v(dout1_103) AT=430.025n

.meas tran vdout1_104ck850 FIND v(dout1_104) AT=430.025n

.meas tran vdout1_105ck850 FIND v(dout1_105) AT=430.025n

.meas tran vdout1_106ck850 FIND v(dout1_106) AT=430.025n

.meas tran vdout1_107ck850 FIND v(dout1_107) AT=430.025n

.meas tran vdout1_108ck850 FIND v(dout1_108) AT=430.025n

.meas tran vdout1_109ck850 FIND v(dout1_109) AT=430.025n

.meas tran vdout1_110ck850 FIND v(dout1_110) AT=430.025n

.meas tran vdout1_111ck850 FIND v(dout1_111) AT=430.025n

.meas tran vdout1_112ck850 FIND v(dout1_112) AT=430.025n

.meas tran vdout1_113ck850 FIND v(dout1_113) AT=430.025n

.meas tran vdout1_114ck850 FIND v(dout1_114) AT=430.025n

.meas tran vdout1_115ck850 FIND v(dout1_115) AT=430.025n

.meas tran vdout1_116ck850 FIND v(dout1_116) AT=430.025n

.meas tran vdout1_117ck850 FIND v(dout1_117) AT=430.025n

.meas tran vdout1_118ck850 FIND v(dout1_118) AT=430.025n

.meas tran vdout1_119ck850 FIND v(dout1_119) AT=430.025n

.meas tran vdout1_120ck850 FIND v(dout1_120) AT=430.025n

.meas tran vdout1_121ck850 FIND v(dout1_121) AT=430.025n

.meas tran vdout1_122ck850 FIND v(dout1_122) AT=430.025n

.meas tran vdout1_123ck850 FIND v(dout1_123) AT=430.025n

.meas tran vdout1_124ck850 FIND v(dout1_124) AT=430.025n

.meas tran vdout1_125ck850 FIND v(dout1_125) AT=430.025n

.meas tran vdout1_126ck850 FIND v(dout1_126) AT=430.025n

.meas tran vdout1_127ck850 FIND v(dout1_127) AT=430.025n

.meas tran vdout1_0ck860 FIND v(dout1_0) AT=435.025n

.meas tran vdout1_1ck860 FIND v(dout1_1) AT=435.025n

.meas tran vdout1_2ck860 FIND v(dout1_2) AT=435.025n

.meas tran vdout1_3ck860 FIND v(dout1_3) AT=435.025n

.meas tran vdout1_4ck860 FIND v(dout1_4) AT=435.025n

.meas tran vdout1_5ck860 FIND v(dout1_5) AT=435.025n

.meas tran vdout1_6ck860 FIND v(dout1_6) AT=435.025n

.meas tran vdout1_7ck860 FIND v(dout1_7) AT=435.025n

.meas tran vdout1_8ck860 FIND v(dout1_8) AT=435.025n

.meas tran vdout1_9ck860 FIND v(dout1_9) AT=435.025n

.meas tran vdout1_10ck860 FIND v(dout1_10) AT=435.025n

.meas tran vdout1_11ck860 FIND v(dout1_11) AT=435.025n

.meas tran vdout1_12ck860 FIND v(dout1_12) AT=435.025n

.meas tran vdout1_13ck860 FIND v(dout1_13) AT=435.025n

.meas tran vdout1_14ck860 FIND v(dout1_14) AT=435.025n

.meas tran vdout1_15ck860 FIND v(dout1_15) AT=435.025n

.meas tran vdout1_16ck860 FIND v(dout1_16) AT=435.025n

.meas tran vdout1_17ck860 FIND v(dout1_17) AT=435.025n

.meas tran vdout1_18ck860 FIND v(dout1_18) AT=435.025n

.meas tran vdout1_19ck860 FIND v(dout1_19) AT=435.025n

.meas tran vdout1_20ck860 FIND v(dout1_20) AT=435.025n

.meas tran vdout1_21ck860 FIND v(dout1_21) AT=435.025n

.meas tran vdout1_22ck860 FIND v(dout1_22) AT=435.025n

.meas tran vdout1_23ck860 FIND v(dout1_23) AT=435.025n

.meas tran vdout1_24ck860 FIND v(dout1_24) AT=435.025n

.meas tran vdout1_25ck860 FIND v(dout1_25) AT=435.025n

.meas tran vdout1_26ck860 FIND v(dout1_26) AT=435.025n

.meas tran vdout1_27ck860 FIND v(dout1_27) AT=435.025n

.meas tran vdout1_28ck860 FIND v(dout1_28) AT=435.025n

.meas tran vdout1_29ck860 FIND v(dout1_29) AT=435.025n

.meas tran vdout1_30ck860 FIND v(dout1_30) AT=435.025n

.meas tran vdout1_31ck860 FIND v(dout1_31) AT=435.025n

.meas tran vdout1_32ck860 FIND v(dout1_32) AT=435.025n

.meas tran vdout1_33ck860 FIND v(dout1_33) AT=435.025n

.meas tran vdout1_34ck860 FIND v(dout1_34) AT=435.025n

.meas tran vdout1_35ck860 FIND v(dout1_35) AT=435.025n

.meas tran vdout1_36ck860 FIND v(dout1_36) AT=435.025n

.meas tran vdout1_37ck860 FIND v(dout1_37) AT=435.025n

.meas tran vdout1_38ck860 FIND v(dout1_38) AT=435.025n

.meas tran vdout1_39ck860 FIND v(dout1_39) AT=435.025n

.meas tran vdout1_40ck860 FIND v(dout1_40) AT=435.025n

.meas tran vdout1_41ck860 FIND v(dout1_41) AT=435.025n

.meas tran vdout1_42ck860 FIND v(dout1_42) AT=435.025n

.meas tran vdout1_43ck860 FIND v(dout1_43) AT=435.025n

.meas tran vdout1_44ck860 FIND v(dout1_44) AT=435.025n

.meas tran vdout1_45ck860 FIND v(dout1_45) AT=435.025n

.meas tran vdout1_46ck860 FIND v(dout1_46) AT=435.025n

.meas tran vdout1_47ck860 FIND v(dout1_47) AT=435.025n

.meas tran vdout1_48ck860 FIND v(dout1_48) AT=435.025n

.meas tran vdout1_49ck860 FIND v(dout1_49) AT=435.025n

.meas tran vdout1_50ck860 FIND v(dout1_50) AT=435.025n

.meas tran vdout1_51ck860 FIND v(dout1_51) AT=435.025n

.meas tran vdout1_52ck860 FIND v(dout1_52) AT=435.025n

.meas tran vdout1_53ck860 FIND v(dout1_53) AT=435.025n

.meas tran vdout1_54ck860 FIND v(dout1_54) AT=435.025n

.meas tran vdout1_55ck860 FIND v(dout1_55) AT=435.025n

.meas tran vdout1_56ck860 FIND v(dout1_56) AT=435.025n

.meas tran vdout1_57ck860 FIND v(dout1_57) AT=435.025n

.meas tran vdout1_58ck860 FIND v(dout1_58) AT=435.025n

.meas tran vdout1_59ck860 FIND v(dout1_59) AT=435.025n

.meas tran vdout1_60ck860 FIND v(dout1_60) AT=435.025n

.meas tran vdout1_61ck860 FIND v(dout1_61) AT=435.025n

.meas tran vdout1_62ck860 FIND v(dout1_62) AT=435.025n

.meas tran vdout1_63ck860 FIND v(dout1_63) AT=435.025n

.meas tran vdout1_64ck860 FIND v(dout1_64) AT=435.025n

.meas tran vdout1_65ck860 FIND v(dout1_65) AT=435.025n

.meas tran vdout1_66ck860 FIND v(dout1_66) AT=435.025n

.meas tran vdout1_67ck860 FIND v(dout1_67) AT=435.025n

.meas tran vdout1_68ck860 FIND v(dout1_68) AT=435.025n

.meas tran vdout1_69ck860 FIND v(dout1_69) AT=435.025n

.meas tran vdout1_70ck860 FIND v(dout1_70) AT=435.025n

.meas tran vdout1_71ck860 FIND v(dout1_71) AT=435.025n

.meas tran vdout1_72ck860 FIND v(dout1_72) AT=435.025n

.meas tran vdout1_73ck860 FIND v(dout1_73) AT=435.025n

.meas tran vdout1_74ck860 FIND v(dout1_74) AT=435.025n

.meas tran vdout1_75ck860 FIND v(dout1_75) AT=435.025n

.meas tran vdout1_76ck860 FIND v(dout1_76) AT=435.025n

.meas tran vdout1_77ck860 FIND v(dout1_77) AT=435.025n

.meas tran vdout1_78ck860 FIND v(dout1_78) AT=435.025n

.meas tran vdout1_79ck860 FIND v(dout1_79) AT=435.025n

.meas tran vdout1_80ck860 FIND v(dout1_80) AT=435.025n

.meas tran vdout1_81ck860 FIND v(dout1_81) AT=435.025n

.meas tran vdout1_82ck860 FIND v(dout1_82) AT=435.025n

.meas tran vdout1_83ck860 FIND v(dout1_83) AT=435.025n

.meas tran vdout1_84ck860 FIND v(dout1_84) AT=435.025n

.meas tran vdout1_85ck860 FIND v(dout1_85) AT=435.025n

.meas tran vdout1_86ck860 FIND v(dout1_86) AT=435.025n

.meas tran vdout1_87ck860 FIND v(dout1_87) AT=435.025n

.meas tran vdout1_88ck860 FIND v(dout1_88) AT=435.025n

.meas tran vdout1_89ck860 FIND v(dout1_89) AT=435.025n

.meas tran vdout1_90ck860 FIND v(dout1_90) AT=435.025n

.meas tran vdout1_91ck860 FIND v(dout1_91) AT=435.025n

.meas tran vdout1_92ck860 FIND v(dout1_92) AT=435.025n

.meas tran vdout1_93ck860 FIND v(dout1_93) AT=435.025n

.meas tran vdout1_94ck860 FIND v(dout1_94) AT=435.025n

.meas tran vdout1_95ck860 FIND v(dout1_95) AT=435.025n

.meas tran vdout1_96ck860 FIND v(dout1_96) AT=435.025n

.meas tran vdout1_97ck860 FIND v(dout1_97) AT=435.025n

.meas tran vdout1_98ck860 FIND v(dout1_98) AT=435.025n

.meas tran vdout1_99ck860 FIND v(dout1_99) AT=435.025n

.meas tran vdout1_100ck860 FIND v(dout1_100) AT=435.025n

.meas tran vdout1_101ck860 FIND v(dout1_101) AT=435.025n

.meas tran vdout1_102ck860 FIND v(dout1_102) AT=435.025n

.meas tran vdout1_103ck860 FIND v(dout1_103) AT=435.025n

.meas tran vdout1_104ck860 FIND v(dout1_104) AT=435.025n

.meas tran vdout1_105ck860 FIND v(dout1_105) AT=435.025n

.meas tran vdout1_106ck860 FIND v(dout1_106) AT=435.025n

.meas tran vdout1_107ck860 FIND v(dout1_107) AT=435.025n

.meas tran vdout1_108ck860 FIND v(dout1_108) AT=435.025n

.meas tran vdout1_109ck860 FIND v(dout1_109) AT=435.025n

.meas tran vdout1_110ck860 FIND v(dout1_110) AT=435.025n

.meas tran vdout1_111ck860 FIND v(dout1_111) AT=435.025n

.meas tran vdout1_112ck860 FIND v(dout1_112) AT=435.025n

.meas tran vdout1_113ck860 FIND v(dout1_113) AT=435.025n

.meas tran vdout1_114ck860 FIND v(dout1_114) AT=435.025n

.meas tran vdout1_115ck860 FIND v(dout1_115) AT=435.025n

.meas tran vdout1_116ck860 FIND v(dout1_116) AT=435.025n

.meas tran vdout1_117ck860 FIND v(dout1_117) AT=435.025n

.meas tran vdout1_118ck860 FIND v(dout1_118) AT=435.025n

.meas tran vdout1_119ck860 FIND v(dout1_119) AT=435.025n

.meas tran vdout1_120ck860 FIND v(dout1_120) AT=435.025n

.meas tran vdout1_121ck860 FIND v(dout1_121) AT=435.025n

.meas tran vdout1_122ck860 FIND v(dout1_122) AT=435.025n

.meas tran vdout1_123ck860 FIND v(dout1_123) AT=435.025n

.meas tran vdout1_124ck860 FIND v(dout1_124) AT=435.025n

.meas tran vdout1_125ck860 FIND v(dout1_125) AT=435.025n

.meas tran vdout1_126ck860 FIND v(dout1_126) AT=435.025n

.meas tran vdout1_127ck860 FIND v(dout1_127) AT=435.025n

.meas tran vdout1_0ck880 FIND v(dout1_0) AT=445.025n

.meas tran vdout1_1ck880 FIND v(dout1_1) AT=445.025n

.meas tran vdout1_2ck880 FIND v(dout1_2) AT=445.025n

.meas tran vdout1_3ck880 FIND v(dout1_3) AT=445.025n

.meas tran vdout1_4ck880 FIND v(dout1_4) AT=445.025n

.meas tran vdout1_5ck880 FIND v(dout1_5) AT=445.025n

.meas tran vdout1_6ck880 FIND v(dout1_6) AT=445.025n

.meas tran vdout1_7ck880 FIND v(dout1_7) AT=445.025n

.meas tran vdout1_8ck880 FIND v(dout1_8) AT=445.025n

.meas tran vdout1_9ck880 FIND v(dout1_9) AT=445.025n

.meas tran vdout1_10ck880 FIND v(dout1_10) AT=445.025n

.meas tran vdout1_11ck880 FIND v(dout1_11) AT=445.025n

.meas tran vdout1_12ck880 FIND v(dout1_12) AT=445.025n

.meas tran vdout1_13ck880 FIND v(dout1_13) AT=445.025n

.meas tran vdout1_14ck880 FIND v(dout1_14) AT=445.025n

.meas tran vdout1_15ck880 FIND v(dout1_15) AT=445.025n

.meas tran vdout1_16ck880 FIND v(dout1_16) AT=445.025n

.meas tran vdout1_17ck880 FIND v(dout1_17) AT=445.025n

.meas tran vdout1_18ck880 FIND v(dout1_18) AT=445.025n

.meas tran vdout1_19ck880 FIND v(dout1_19) AT=445.025n

.meas tran vdout1_20ck880 FIND v(dout1_20) AT=445.025n

.meas tran vdout1_21ck880 FIND v(dout1_21) AT=445.025n

.meas tran vdout1_22ck880 FIND v(dout1_22) AT=445.025n

.meas tran vdout1_23ck880 FIND v(dout1_23) AT=445.025n

.meas tran vdout1_24ck880 FIND v(dout1_24) AT=445.025n

.meas tran vdout1_25ck880 FIND v(dout1_25) AT=445.025n

.meas tran vdout1_26ck880 FIND v(dout1_26) AT=445.025n

.meas tran vdout1_27ck880 FIND v(dout1_27) AT=445.025n

.meas tran vdout1_28ck880 FIND v(dout1_28) AT=445.025n

.meas tran vdout1_29ck880 FIND v(dout1_29) AT=445.025n

.meas tran vdout1_30ck880 FIND v(dout1_30) AT=445.025n

.meas tran vdout1_31ck880 FIND v(dout1_31) AT=445.025n

.meas tran vdout1_32ck880 FIND v(dout1_32) AT=445.025n

.meas tran vdout1_33ck880 FIND v(dout1_33) AT=445.025n

.meas tran vdout1_34ck880 FIND v(dout1_34) AT=445.025n

.meas tran vdout1_35ck880 FIND v(dout1_35) AT=445.025n

.meas tran vdout1_36ck880 FIND v(dout1_36) AT=445.025n

.meas tran vdout1_37ck880 FIND v(dout1_37) AT=445.025n

.meas tran vdout1_38ck880 FIND v(dout1_38) AT=445.025n

.meas tran vdout1_39ck880 FIND v(dout1_39) AT=445.025n

.meas tran vdout1_40ck880 FIND v(dout1_40) AT=445.025n

.meas tran vdout1_41ck880 FIND v(dout1_41) AT=445.025n

.meas tran vdout1_42ck880 FIND v(dout1_42) AT=445.025n

.meas tran vdout1_43ck880 FIND v(dout1_43) AT=445.025n

.meas tran vdout1_44ck880 FIND v(dout1_44) AT=445.025n

.meas tran vdout1_45ck880 FIND v(dout1_45) AT=445.025n

.meas tran vdout1_46ck880 FIND v(dout1_46) AT=445.025n

.meas tran vdout1_47ck880 FIND v(dout1_47) AT=445.025n

.meas tran vdout1_48ck880 FIND v(dout1_48) AT=445.025n

.meas tran vdout1_49ck880 FIND v(dout1_49) AT=445.025n

.meas tran vdout1_50ck880 FIND v(dout1_50) AT=445.025n

.meas tran vdout1_51ck880 FIND v(dout1_51) AT=445.025n

.meas tran vdout1_52ck880 FIND v(dout1_52) AT=445.025n

.meas tran vdout1_53ck880 FIND v(dout1_53) AT=445.025n

.meas tran vdout1_54ck880 FIND v(dout1_54) AT=445.025n

.meas tran vdout1_55ck880 FIND v(dout1_55) AT=445.025n

.meas tran vdout1_56ck880 FIND v(dout1_56) AT=445.025n

.meas tran vdout1_57ck880 FIND v(dout1_57) AT=445.025n

.meas tran vdout1_58ck880 FIND v(dout1_58) AT=445.025n

.meas tran vdout1_59ck880 FIND v(dout1_59) AT=445.025n

.meas tran vdout1_60ck880 FIND v(dout1_60) AT=445.025n

.meas tran vdout1_61ck880 FIND v(dout1_61) AT=445.025n

.meas tran vdout1_62ck880 FIND v(dout1_62) AT=445.025n

.meas tran vdout1_63ck880 FIND v(dout1_63) AT=445.025n

.meas tran vdout1_64ck880 FIND v(dout1_64) AT=445.025n

.meas tran vdout1_65ck880 FIND v(dout1_65) AT=445.025n

.meas tran vdout1_66ck880 FIND v(dout1_66) AT=445.025n

.meas tran vdout1_67ck880 FIND v(dout1_67) AT=445.025n

.meas tran vdout1_68ck880 FIND v(dout1_68) AT=445.025n

.meas tran vdout1_69ck880 FIND v(dout1_69) AT=445.025n

.meas tran vdout1_70ck880 FIND v(dout1_70) AT=445.025n

.meas tran vdout1_71ck880 FIND v(dout1_71) AT=445.025n

.meas tran vdout1_72ck880 FIND v(dout1_72) AT=445.025n

.meas tran vdout1_73ck880 FIND v(dout1_73) AT=445.025n

.meas tran vdout1_74ck880 FIND v(dout1_74) AT=445.025n

.meas tran vdout1_75ck880 FIND v(dout1_75) AT=445.025n

.meas tran vdout1_76ck880 FIND v(dout1_76) AT=445.025n

.meas tran vdout1_77ck880 FIND v(dout1_77) AT=445.025n

.meas tran vdout1_78ck880 FIND v(dout1_78) AT=445.025n

.meas tran vdout1_79ck880 FIND v(dout1_79) AT=445.025n

.meas tran vdout1_80ck880 FIND v(dout1_80) AT=445.025n

.meas tran vdout1_81ck880 FIND v(dout1_81) AT=445.025n

.meas tran vdout1_82ck880 FIND v(dout1_82) AT=445.025n

.meas tran vdout1_83ck880 FIND v(dout1_83) AT=445.025n

.meas tran vdout1_84ck880 FIND v(dout1_84) AT=445.025n

.meas tran vdout1_85ck880 FIND v(dout1_85) AT=445.025n

.meas tran vdout1_86ck880 FIND v(dout1_86) AT=445.025n

.meas tran vdout1_87ck880 FIND v(dout1_87) AT=445.025n

.meas tran vdout1_88ck880 FIND v(dout1_88) AT=445.025n

.meas tran vdout1_89ck880 FIND v(dout1_89) AT=445.025n

.meas tran vdout1_90ck880 FIND v(dout1_90) AT=445.025n

.meas tran vdout1_91ck880 FIND v(dout1_91) AT=445.025n

.meas tran vdout1_92ck880 FIND v(dout1_92) AT=445.025n

.meas tran vdout1_93ck880 FIND v(dout1_93) AT=445.025n

.meas tran vdout1_94ck880 FIND v(dout1_94) AT=445.025n

.meas tran vdout1_95ck880 FIND v(dout1_95) AT=445.025n

.meas tran vdout1_96ck880 FIND v(dout1_96) AT=445.025n

.meas tran vdout1_97ck880 FIND v(dout1_97) AT=445.025n

.meas tran vdout1_98ck880 FIND v(dout1_98) AT=445.025n

.meas tran vdout1_99ck880 FIND v(dout1_99) AT=445.025n

.meas tran vdout1_100ck880 FIND v(dout1_100) AT=445.025n

.meas tran vdout1_101ck880 FIND v(dout1_101) AT=445.025n

.meas tran vdout1_102ck880 FIND v(dout1_102) AT=445.025n

.meas tran vdout1_103ck880 FIND v(dout1_103) AT=445.025n

.meas tran vdout1_104ck880 FIND v(dout1_104) AT=445.025n

.meas tran vdout1_105ck880 FIND v(dout1_105) AT=445.025n

.meas tran vdout1_106ck880 FIND v(dout1_106) AT=445.025n

.meas tran vdout1_107ck880 FIND v(dout1_107) AT=445.025n

.meas tran vdout1_108ck880 FIND v(dout1_108) AT=445.025n

.meas tran vdout1_109ck880 FIND v(dout1_109) AT=445.025n

.meas tran vdout1_110ck880 FIND v(dout1_110) AT=445.025n

.meas tran vdout1_111ck880 FIND v(dout1_111) AT=445.025n

.meas tran vdout1_112ck880 FIND v(dout1_112) AT=445.025n

.meas tran vdout1_113ck880 FIND v(dout1_113) AT=445.025n

.meas tran vdout1_114ck880 FIND v(dout1_114) AT=445.025n

.meas tran vdout1_115ck880 FIND v(dout1_115) AT=445.025n

.meas tran vdout1_116ck880 FIND v(dout1_116) AT=445.025n

.meas tran vdout1_117ck880 FIND v(dout1_117) AT=445.025n

.meas tran vdout1_118ck880 FIND v(dout1_118) AT=445.025n

.meas tran vdout1_119ck880 FIND v(dout1_119) AT=445.025n

.meas tran vdout1_120ck880 FIND v(dout1_120) AT=445.025n

.meas tran vdout1_121ck880 FIND v(dout1_121) AT=445.025n

.meas tran vdout1_122ck880 FIND v(dout1_122) AT=445.025n

.meas tran vdout1_123ck880 FIND v(dout1_123) AT=445.025n

.meas tran vdout1_124ck880 FIND v(dout1_124) AT=445.025n

.meas tran vdout1_125ck880 FIND v(dout1_125) AT=445.025n

.meas tran vdout1_126ck880 FIND v(dout1_126) AT=445.025n

.meas tran vdout1_127ck880 FIND v(dout1_127) AT=445.025n

.meas tran vdout1_0ck910 FIND v(dout1_0) AT=460.025n

.meas tran vdout1_1ck910 FIND v(dout1_1) AT=460.025n

.meas tran vdout1_2ck910 FIND v(dout1_2) AT=460.025n

.meas tran vdout1_3ck910 FIND v(dout1_3) AT=460.025n

.meas tran vdout1_4ck910 FIND v(dout1_4) AT=460.025n

.meas tran vdout1_5ck910 FIND v(dout1_5) AT=460.025n

.meas tran vdout1_6ck910 FIND v(dout1_6) AT=460.025n

.meas tran vdout1_7ck910 FIND v(dout1_7) AT=460.025n

.meas tran vdout1_8ck910 FIND v(dout1_8) AT=460.025n

.meas tran vdout1_9ck910 FIND v(dout1_9) AT=460.025n

.meas tran vdout1_10ck910 FIND v(dout1_10) AT=460.025n

.meas tran vdout1_11ck910 FIND v(dout1_11) AT=460.025n

.meas tran vdout1_12ck910 FIND v(dout1_12) AT=460.025n

.meas tran vdout1_13ck910 FIND v(dout1_13) AT=460.025n

.meas tran vdout1_14ck910 FIND v(dout1_14) AT=460.025n

.meas tran vdout1_15ck910 FIND v(dout1_15) AT=460.025n

.meas tran vdout1_16ck910 FIND v(dout1_16) AT=460.025n

.meas tran vdout1_17ck910 FIND v(dout1_17) AT=460.025n

.meas tran vdout1_18ck910 FIND v(dout1_18) AT=460.025n

.meas tran vdout1_19ck910 FIND v(dout1_19) AT=460.025n

.meas tran vdout1_20ck910 FIND v(dout1_20) AT=460.025n

.meas tran vdout1_21ck910 FIND v(dout1_21) AT=460.025n

.meas tran vdout1_22ck910 FIND v(dout1_22) AT=460.025n

.meas tran vdout1_23ck910 FIND v(dout1_23) AT=460.025n

.meas tran vdout1_24ck910 FIND v(dout1_24) AT=460.025n

.meas tran vdout1_25ck910 FIND v(dout1_25) AT=460.025n

.meas tran vdout1_26ck910 FIND v(dout1_26) AT=460.025n

.meas tran vdout1_27ck910 FIND v(dout1_27) AT=460.025n

.meas tran vdout1_28ck910 FIND v(dout1_28) AT=460.025n

.meas tran vdout1_29ck910 FIND v(dout1_29) AT=460.025n

.meas tran vdout1_30ck910 FIND v(dout1_30) AT=460.025n

.meas tran vdout1_31ck910 FIND v(dout1_31) AT=460.025n

.meas tran vdout1_32ck910 FIND v(dout1_32) AT=460.025n

.meas tran vdout1_33ck910 FIND v(dout1_33) AT=460.025n

.meas tran vdout1_34ck910 FIND v(dout1_34) AT=460.025n

.meas tran vdout1_35ck910 FIND v(dout1_35) AT=460.025n

.meas tran vdout1_36ck910 FIND v(dout1_36) AT=460.025n

.meas tran vdout1_37ck910 FIND v(dout1_37) AT=460.025n

.meas tran vdout1_38ck910 FIND v(dout1_38) AT=460.025n

.meas tran vdout1_39ck910 FIND v(dout1_39) AT=460.025n

.meas tran vdout1_40ck910 FIND v(dout1_40) AT=460.025n

.meas tran vdout1_41ck910 FIND v(dout1_41) AT=460.025n

.meas tran vdout1_42ck910 FIND v(dout1_42) AT=460.025n

.meas tran vdout1_43ck910 FIND v(dout1_43) AT=460.025n

.meas tran vdout1_44ck910 FIND v(dout1_44) AT=460.025n

.meas tran vdout1_45ck910 FIND v(dout1_45) AT=460.025n

.meas tran vdout1_46ck910 FIND v(dout1_46) AT=460.025n

.meas tran vdout1_47ck910 FIND v(dout1_47) AT=460.025n

.meas tran vdout1_48ck910 FIND v(dout1_48) AT=460.025n

.meas tran vdout1_49ck910 FIND v(dout1_49) AT=460.025n

.meas tran vdout1_50ck910 FIND v(dout1_50) AT=460.025n

.meas tran vdout1_51ck910 FIND v(dout1_51) AT=460.025n

.meas tran vdout1_52ck910 FIND v(dout1_52) AT=460.025n

.meas tran vdout1_53ck910 FIND v(dout1_53) AT=460.025n

.meas tran vdout1_54ck910 FIND v(dout1_54) AT=460.025n

.meas tran vdout1_55ck910 FIND v(dout1_55) AT=460.025n

.meas tran vdout1_56ck910 FIND v(dout1_56) AT=460.025n

.meas tran vdout1_57ck910 FIND v(dout1_57) AT=460.025n

.meas tran vdout1_58ck910 FIND v(dout1_58) AT=460.025n

.meas tran vdout1_59ck910 FIND v(dout1_59) AT=460.025n

.meas tran vdout1_60ck910 FIND v(dout1_60) AT=460.025n

.meas tran vdout1_61ck910 FIND v(dout1_61) AT=460.025n

.meas tran vdout1_62ck910 FIND v(dout1_62) AT=460.025n

.meas tran vdout1_63ck910 FIND v(dout1_63) AT=460.025n

.meas tran vdout1_64ck910 FIND v(dout1_64) AT=460.025n

.meas tran vdout1_65ck910 FIND v(dout1_65) AT=460.025n

.meas tran vdout1_66ck910 FIND v(dout1_66) AT=460.025n

.meas tran vdout1_67ck910 FIND v(dout1_67) AT=460.025n

.meas tran vdout1_68ck910 FIND v(dout1_68) AT=460.025n

.meas tran vdout1_69ck910 FIND v(dout1_69) AT=460.025n

.meas tran vdout1_70ck910 FIND v(dout1_70) AT=460.025n

.meas tran vdout1_71ck910 FIND v(dout1_71) AT=460.025n

.meas tran vdout1_72ck910 FIND v(dout1_72) AT=460.025n

.meas tran vdout1_73ck910 FIND v(dout1_73) AT=460.025n

.meas tran vdout1_74ck910 FIND v(dout1_74) AT=460.025n

.meas tran vdout1_75ck910 FIND v(dout1_75) AT=460.025n

.meas tran vdout1_76ck910 FIND v(dout1_76) AT=460.025n

.meas tran vdout1_77ck910 FIND v(dout1_77) AT=460.025n

.meas tran vdout1_78ck910 FIND v(dout1_78) AT=460.025n

.meas tran vdout1_79ck910 FIND v(dout1_79) AT=460.025n

.meas tran vdout1_80ck910 FIND v(dout1_80) AT=460.025n

.meas tran vdout1_81ck910 FIND v(dout1_81) AT=460.025n

.meas tran vdout1_82ck910 FIND v(dout1_82) AT=460.025n

.meas tran vdout1_83ck910 FIND v(dout1_83) AT=460.025n

.meas tran vdout1_84ck910 FIND v(dout1_84) AT=460.025n

.meas tran vdout1_85ck910 FIND v(dout1_85) AT=460.025n

.meas tran vdout1_86ck910 FIND v(dout1_86) AT=460.025n

.meas tran vdout1_87ck910 FIND v(dout1_87) AT=460.025n

.meas tran vdout1_88ck910 FIND v(dout1_88) AT=460.025n

.meas tran vdout1_89ck910 FIND v(dout1_89) AT=460.025n

.meas tran vdout1_90ck910 FIND v(dout1_90) AT=460.025n

.meas tran vdout1_91ck910 FIND v(dout1_91) AT=460.025n

.meas tran vdout1_92ck910 FIND v(dout1_92) AT=460.025n

.meas tran vdout1_93ck910 FIND v(dout1_93) AT=460.025n

.meas tran vdout1_94ck910 FIND v(dout1_94) AT=460.025n

.meas tran vdout1_95ck910 FIND v(dout1_95) AT=460.025n

.meas tran vdout1_96ck910 FIND v(dout1_96) AT=460.025n

.meas tran vdout1_97ck910 FIND v(dout1_97) AT=460.025n

.meas tran vdout1_98ck910 FIND v(dout1_98) AT=460.025n

.meas tran vdout1_99ck910 FIND v(dout1_99) AT=460.025n

.meas tran vdout1_100ck910 FIND v(dout1_100) AT=460.025n

.meas tran vdout1_101ck910 FIND v(dout1_101) AT=460.025n

.meas tran vdout1_102ck910 FIND v(dout1_102) AT=460.025n

.meas tran vdout1_103ck910 FIND v(dout1_103) AT=460.025n

.meas tran vdout1_104ck910 FIND v(dout1_104) AT=460.025n

.meas tran vdout1_105ck910 FIND v(dout1_105) AT=460.025n

.meas tran vdout1_106ck910 FIND v(dout1_106) AT=460.025n

.meas tran vdout1_107ck910 FIND v(dout1_107) AT=460.025n

.meas tran vdout1_108ck910 FIND v(dout1_108) AT=460.025n

.meas tran vdout1_109ck910 FIND v(dout1_109) AT=460.025n

.meas tran vdout1_110ck910 FIND v(dout1_110) AT=460.025n

.meas tran vdout1_111ck910 FIND v(dout1_111) AT=460.025n

.meas tran vdout1_112ck910 FIND v(dout1_112) AT=460.025n

.meas tran vdout1_113ck910 FIND v(dout1_113) AT=460.025n

.meas tran vdout1_114ck910 FIND v(dout1_114) AT=460.025n

.meas tran vdout1_115ck910 FIND v(dout1_115) AT=460.025n

.meas tran vdout1_116ck910 FIND v(dout1_116) AT=460.025n

.meas tran vdout1_117ck910 FIND v(dout1_117) AT=460.025n

.meas tran vdout1_118ck910 FIND v(dout1_118) AT=460.025n

.meas tran vdout1_119ck910 FIND v(dout1_119) AT=460.025n

.meas tran vdout1_120ck910 FIND v(dout1_120) AT=460.025n

.meas tran vdout1_121ck910 FIND v(dout1_121) AT=460.025n

.meas tran vdout1_122ck910 FIND v(dout1_122) AT=460.025n

.meas tran vdout1_123ck910 FIND v(dout1_123) AT=460.025n

.meas tran vdout1_124ck910 FIND v(dout1_124) AT=460.025n

.meas tran vdout1_125ck910 FIND v(dout1_125) AT=460.025n

.meas tran vdout1_126ck910 FIND v(dout1_126) AT=460.025n

.meas tran vdout1_127ck910 FIND v(dout1_127) AT=460.025n

.meas tran vdout1_0ck930 FIND v(dout1_0) AT=470.025n

.meas tran vdout1_1ck930 FIND v(dout1_1) AT=470.025n

.meas tran vdout1_2ck930 FIND v(dout1_2) AT=470.025n

.meas tran vdout1_3ck930 FIND v(dout1_3) AT=470.025n

.meas tran vdout1_4ck930 FIND v(dout1_4) AT=470.025n

.meas tran vdout1_5ck930 FIND v(dout1_5) AT=470.025n

.meas tran vdout1_6ck930 FIND v(dout1_6) AT=470.025n

.meas tran vdout1_7ck930 FIND v(dout1_7) AT=470.025n

.meas tran vdout1_8ck930 FIND v(dout1_8) AT=470.025n

.meas tran vdout1_9ck930 FIND v(dout1_9) AT=470.025n

.meas tran vdout1_10ck930 FIND v(dout1_10) AT=470.025n

.meas tran vdout1_11ck930 FIND v(dout1_11) AT=470.025n

.meas tran vdout1_12ck930 FIND v(dout1_12) AT=470.025n

.meas tran vdout1_13ck930 FIND v(dout1_13) AT=470.025n

.meas tran vdout1_14ck930 FIND v(dout1_14) AT=470.025n

.meas tran vdout1_15ck930 FIND v(dout1_15) AT=470.025n

.meas tran vdout1_16ck930 FIND v(dout1_16) AT=470.025n

.meas tran vdout1_17ck930 FIND v(dout1_17) AT=470.025n

.meas tran vdout1_18ck930 FIND v(dout1_18) AT=470.025n

.meas tran vdout1_19ck930 FIND v(dout1_19) AT=470.025n

.meas tran vdout1_20ck930 FIND v(dout1_20) AT=470.025n

.meas tran vdout1_21ck930 FIND v(dout1_21) AT=470.025n

.meas tran vdout1_22ck930 FIND v(dout1_22) AT=470.025n

.meas tran vdout1_23ck930 FIND v(dout1_23) AT=470.025n

.meas tran vdout1_24ck930 FIND v(dout1_24) AT=470.025n

.meas tran vdout1_25ck930 FIND v(dout1_25) AT=470.025n

.meas tran vdout1_26ck930 FIND v(dout1_26) AT=470.025n

.meas tran vdout1_27ck930 FIND v(dout1_27) AT=470.025n

.meas tran vdout1_28ck930 FIND v(dout1_28) AT=470.025n

.meas tran vdout1_29ck930 FIND v(dout1_29) AT=470.025n

.meas tran vdout1_30ck930 FIND v(dout1_30) AT=470.025n

.meas tran vdout1_31ck930 FIND v(dout1_31) AT=470.025n

.meas tran vdout1_32ck930 FIND v(dout1_32) AT=470.025n

.meas tran vdout1_33ck930 FIND v(dout1_33) AT=470.025n

.meas tran vdout1_34ck930 FIND v(dout1_34) AT=470.025n

.meas tran vdout1_35ck930 FIND v(dout1_35) AT=470.025n

.meas tran vdout1_36ck930 FIND v(dout1_36) AT=470.025n

.meas tran vdout1_37ck930 FIND v(dout1_37) AT=470.025n

.meas tran vdout1_38ck930 FIND v(dout1_38) AT=470.025n

.meas tran vdout1_39ck930 FIND v(dout1_39) AT=470.025n

.meas tran vdout1_40ck930 FIND v(dout1_40) AT=470.025n

.meas tran vdout1_41ck930 FIND v(dout1_41) AT=470.025n

.meas tran vdout1_42ck930 FIND v(dout1_42) AT=470.025n

.meas tran vdout1_43ck930 FIND v(dout1_43) AT=470.025n

.meas tran vdout1_44ck930 FIND v(dout1_44) AT=470.025n

.meas tran vdout1_45ck930 FIND v(dout1_45) AT=470.025n

.meas tran vdout1_46ck930 FIND v(dout1_46) AT=470.025n

.meas tran vdout1_47ck930 FIND v(dout1_47) AT=470.025n

.meas tran vdout1_48ck930 FIND v(dout1_48) AT=470.025n

.meas tran vdout1_49ck930 FIND v(dout1_49) AT=470.025n

.meas tran vdout1_50ck930 FIND v(dout1_50) AT=470.025n

.meas tran vdout1_51ck930 FIND v(dout1_51) AT=470.025n

.meas tran vdout1_52ck930 FIND v(dout1_52) AT=470.025n

.meas tran vdout1_53ck930 FIND v(dout1_53) AT=470.025n

.meas tran vdout1_54ck930 FIND v(dout1_54) AT=470.025n

.meas tran vdout1_55ck930 FIND v(dout1_55) AT=470.025n

.meas tran vdout1_56ck930 FIND v(dout1_56) AT=470.025n

.meas tran vdout1_57ck930 FIND v(dout1_57) AT=470.025n

.meas tran vdout1_58ck930 FIND v(dout1_58) AT=470.025n

.meas tran vdout1_59ck930 FIND v(dout1_59) AT=470.025n

.meas tran vdout1_60ck930 FIND v(dout1_60) AT=470.025n

.meas tran vdout1_61ck930 FIND v(dout1_61) AT=470.025n

.meas tran vdout1_62ck930 FIND v(dout1_62) AT=470.025n

.meas tran vdout1_63ck930 FIND v(dout1_63) AT=470.025n

.meas tran vdout1_64ck930 FIND v(dout1_64) AT=470.025n

.meas tran vdout1_65ck930 FIND v(dout1_65) AT=470.025n

.meas tran vdout1_66ck930 FIND v(dout1_66) AT=470.025n

.meas tran vdout1_67ck930 FIND v(dout1_67) AT=470.025n

.meas tran vdout1_68ck930 FIND v(dout1_68) AT=470.025n

.meas tran vdout1_69ck930 FIND v(dout1_69) AT=470.025n

.meas tran vdout1_70ck930 FIND v(dout1_70) AT=470.025n

.meas tran vdout1_71ck930 FIND v(dout1_71) AT=470.025n

.meas tran vdout1_72ck930 FIND v(dout1_72) AT=470.025n

.meas tran vdout1_73ck930 FIND v(dout1_73) AT=470.025n

.meas tran vdout1_74ck930 FIND v(dout1_74) AT=470.025n

.meas tran vdout1_75ck930 FIND v(dout1_75) AT=470.025n

.meas tran vdout1_76ck930 FIND v(dout1_76) AT=470.025n

.meas tran vdout1_77ck930 FIND v(dout1_77) AT=470.025n

.meas tran vdout1_78ck930 FIND v(dout1_78) AT=470.025n

.meas tran vdout1_79ck930 FIND v(dout1_79) AT=470.025n

.meas tran vdout1_80ck930 FIND v(dout1_80) AT=470.025n

.meas tran vdout1_81ck930 FIND v(dout1_81) AT=470.025n

.meas tran vdout1_82ck930 FIND v(dout1_82) AT=470.025n

.meas tran vdout1_83ck930 FIND v(dout1_83) AT=470.025n

.meas tran vdout1_84ck930 FIND v(dout1_84) AT=470.025n

.meas tran vdout1_85ck930 FIND v(dout1_85) AT=470.025n

.meas tran vdout1_86ck930 FIND v(dout1_86) AT=470.025n

.meas tran vdout1_87ck930 FIND v(dout1_87) AT=470.025n

.meas tran vdout1_88ck930 FIND v(dout1_88) AT=470.025n

.meas tran vdout1_89ck930 FIND v(dout1_89) AT=470.025n

.meas tran vdout1_90ck930 FIND v(dout1_90) AT=470.025n

.meas tran vdout1_91ck930 FIND v(dout1_91) AT=470.025n

.meas tran vdout1_92ck930 FIND v(dout1_92) AT=470.025n

.meas tran vdout1_93ck930 FIND v(dout1_93) AT=470.025n

.meas tran vdout1_94ck930 FIND v(dout1_94) AT=470.025n

.meas tran vdout1_95ck930 FIND v(dout1_95) AT=470.025n

.meas tran vdout1_96ck930 FIND v(dout1_96) AT=470.025n

.meas tran vdout1_97ck930 FIND v(dout1_97) AT=470.025n

.meas tran vdout1_98ck930 FIND v(dout1_98) AT=470.025n

.meas tran vdout1_99ck930 FIND v(dout1_99) AT=470.025n

.meas tran vdout1_100ck930 FIND v(dout1_100) AT=470.025n

.meas tran vdout1_101ck930 FIND v(dout1_101) AT=470.025n

.meas tran vdout1_102ck930 FIND v(dout1_102) AT=470.025n

.meas tran vdout1_103ck930 FIND v(dout1_103) AT=470.025n

.meas tran vdout1_104ck930 FIND v(dout1_104) AT=470.025n

.meas tran vdout1_105ck930 FIND v(dout1_105) AT=470.025n

.meas tran vdout1_106ck930 FIND v(dout1_106) AT=470.025n

.meas tran vdout1_107ck930 FIND v(dout1_107) AT=470.025n

.meas tran vdout1_108ck930 FIND v(dout1_108) AT=470.025n

.meas tran vdout1_109ck930 FIND v(dout1_109) AT=470.025n

.meas tran vdout1_110ck930 FIND v(dout1_110) AT=470.025n

.meas tran vdout1_111ck930 FIND v(dout1_111) AT=470.025n

.meas tran vdout1_112ck930 FIND v(dout1_112) AT=470.025n

.meas tran vdout1_113ck930 FIND v(dout1_113) AT=470.025n

.meas tran vdout1_114ck930 FIND v(dout1_114) AT=470.025n

.meas tran vdout1_115ck930 FIND v(dout1_115) AT=470.025n

.meas tran vdout1_116ck930 FIND v(dout1_116) AT=470.025n

.meas tran vdout1_117ck930 FIND v(dout1_117) AT=470.025n

.meas tran vdout1_118ck930 FIND v(dout1_118) AT=470.025n

.meas tran vdout1_119ck930 FIND v(dout1_119) AT=470.025n

.meas tran vdout1_120ck930 FIND v(dout1_120) AT=470.025n

.meas tran vdout1_121ck930 FIND v(dout1_121) AT=470.025n

.meas tran vdout1_122ck930 FIND v(dout1_122) AT=470.025n

.meas tran vdout1_123ck930 FIND v(dout1_123) AT=470.025n

.meas tran vdout1_124ck930 FIND v(dout1_124) AT=470.025n

.meas tran vdout1_125ck930 FIND v(dout1_125) AT=470.025n

.meas tran vdout1_126ck930 FIND v(dout1_126) AT=470.025n

.meas tran vdout1_127ck930 FIND v(dout1_127) AT=470.025n

.meas tran vdout1_0ck940 FIND v(dout1_0) AT=475.025n

.meas tran vdout1_1ck940 FIND v(dout1_1) AT=475.025n

.meas tran vdout1_2ck940 FIND v(dout1_2) AT=475.025n

.meas tran vdout1_3ck940 FIND v(dout1_3) AT=475.025n

.meas tran vdout1_4ck940 FIND v(dout1_4) AT=475.025n

.meas tran vdout1_5ck940 FIND v(dout1_5) AT=475.025n

.meas tran vdout1_6ck940 FIND v(dout1_6) AT=475.025n

.meas tran vdout1_7ck940 FIND v(dout1_7) AT=475.025n

.meas tran vdout1_8ck940 FIND v(dout1_8) AT=475.025n

.meas tran vdout1_9ck940 FIND v(dout1_9) AT=475.025n

.meas tran vdout1_10ck940 FIND v(dout1_10) AT=475.025n

.meas tran vdout1_11ck940 FIND v(dout1_11) AT=475.025n

.meas tran vdout1_12ck940 FIND v(dout1_12) AT=475.025n

.meas tran vdout1_13ck940 FIND v(dout1_13) AT=475.025n

.meas tran vdout1_14ck940 FIND v(dout1_14) AT=475.025n

.meas tran vdout1_15ck940 FIND v(dout1_15) AT=475.025n

.meas tran vdout1_16ck940 FIND v(dout1_16) AT=475.025n

.meas tran vdout1_17ck940 FIND v(dout1_17) AT=475.025n

.meas tran vdout1_18ck940 FIND v(dout1_18) AT=475.025n

.meas tran vdout1_19ck940 FIND v(dout1_19) AT=475.025n

.meas tran vdout1_20ck940 FIND v(dout1_20) AT=475.025n

.meas tran vdout1_21ck940 FIND v(dout1_21) AT=475.025n

.meas tran vdout1_22ck940 FIND v(dout1_22) AT=475.025n

.meas tran vdout1_23ck940 FIND v(dout1_23) AT=475.025n

.meas tran vdout1_24ck940 FIND v(dout1_24) AT=475.025n

.meas tran vdout1_25ck940 FIND v(dout1_25) AT=475.025n

.meas tran vdout1_26ck940 FIND v(dout1_26) AT=475.025n

.meas tran vdout1_27ck940 FIND v(dout1_27) AT=475.025n

.meas tran vdout1_28ck940 FIND v(dout1_28) AT=475.025n

.meas tran vdout1_29ck940 FIND v(dout1_29) AT=475.025n

.meas tran vdout1_30ck940 FIND v(dout1_30) AT=475.025n

.meas tran vdout1_31ck940 FIND v(dout1_31) AT=475.025n

.meas tran vdout1_32ck940 FIND v(dout1_32) AT=475.025n

.meas tran vdout1_33ck940 FIND v(dout1_33) AT=475.025n

.meas tran vdout1_34ck940 FIND v(dout1_34) AT=475.025n

.meas tran vdout1_35ck940 FIND v(dout1_35) AT=475.025n

.meas tran vdout1_36ck940 FIND v(dout1_36) AT=475.025n

.meas tran vdout1_37ck940 FIND v(dout1_37) AT=475.025n

.meas tran vdout1_38ck940 FIND v(dout1_38) AT=475.025n

.meas tran vdout1_39ck940 FIND v(dout1_39) AT=475.025n

.meas tran vdout1_40ck940 FIND v(dout1_40) AT=475.025n

.meas tran vdout1_41ck940 FIND v(dout1_41) AT=475.025n

.meas tran vdout1_42ck940 FIND v(dout1_42) AT=475.025n

.meas tran vdout1_43ck940 FIND v(dout1_43) AT=475.025n

.meas tran vdout1_44ck940 FIND v(dout1_44) AT=475.025n

.meas tran vdout1_45ck940 FIND v(dout1_45) AT=475.025n

.meas tran vdout1_46ck940 FIND v(dout1_46) AT=475.025n

.meas tran vdout1_47ck940 FIND v(dout1_47) AT=475.025n

.meas tran vdout1_48ck940 FIND v(dout1_48) AT=475.025n

.meas tran vdout1_49ck940 FIND v(dout1_49) AT=475.025n

.meas tran vdout1_50ck940 FIND v(dout1_50) AT=475.025n

.meas tran vdout1_51ck940 FIND v(dout1_51) AT=475.025n

.meas tran vdout1_52ck940 FIND v(dout1_52) AT=475.025n

.meas tran vdout1_53ck940 FIND v(dout1_53) AT=475.025n

.meas tran vdout1_54ck940 FIND v(dout1_54) AT=475.025n

.meas tran vdout1_55ck940 FIND v(dout1_55) AT=475.025n

.meas tran vdout1_56ck940 FIND v(dout1_56) AT=475.025n

.meas tran vdout1_57ck940 FIND v(dout1_57) AT=475.025n

.meas tran vdout1_58ck940 FIND v(dout1_58) AT=475.025n

.meas tran vdout1_59ck940 FIND v(dout1_59) AT=475.025n

.meas tran vdout1_60ck940 FIND v(dout1_60) AT=475.025n

.meas tran vdout1_61ck940 FIND v(dout1_61) AT=475.025n

.meas tran vdout1_62ck940 FIND v(dout1_62) AT=475.025n

.meas tran vdout1_63ck940 FIND v(dout1_63) AT=475.025n

.meas tran vdout1_64ck940 FIND v(dout1_64) AT=475.025n

.meas tran vdout1_65ck940 FIND v(dout1_65) AT=475.025n

.meas tran vdout1_66ck940 FIND v(dout1_66) AT=475.025n

.meas tran vdout1_67ck940 FIND v(dout1_67) AT=475.025n

.meas tran vdout1_68ck940 FIND v(dout1_68) AT=475.025n

.meas tran vdout1_69ck940 FIND v(dout1_69) AT=475.025n

.meas tran vdout1_70ck940 FIND v(dout1_70) AT=475.025n

.meas tran vdout1_71ck940 FIND v(dout1_71) AT=475.025n

.meas tran vdout1_72ck940 FIND v(dout1_72) AT=475.025n

.meas tran vdout1_73ck940 FIND v(dout1_73) AT=475.025n

.meas tran vdout1_74ck940 FIND v(dout1_74) AT=475.025n

.meas tran vdout1_75ck940 FIND v(dout1_75) AT=475.025n

.meas tran vdout1_76ck940 FIND v(dout1_76) AT=475.025n

.meas tran vdout1_77ck940 FIND v(dout1_77) AT=475.025n

.meas tran vdout1_78ck940 FIND v(dout1_78) AT=475.025n

.meas tran vdout1_79ck940 FIND v(dout1_79) AT=475.025n

.meas tran vdout1_80ck940 FIND v(dout1_80) AT=475.025n

.meas tran vdout1_81ck940 FIND v(dout1_81) AT=475.025n

.meas tran vdout1_82ck940 FIND v(dout1_82) AT=475.025n

.meas tran vdout1_83ck940 FIND v(dout1_83) AT=475.025n

.meas tran vdout1_84ck940 FIND v(dout1_84) AT=475.025n

.meas tran vdout1_85ck940 FIND v(dout1_85) AT=475.025n

.meas tran vdout1_86ck940 FIND v(dout1_86) AT=475.025n

.meas tran vdout1_87ck940 FIND v(dout1_87) AT=475.025n

.meas tran vdout1_88ck940 FIND v(dout1_88) AT=475.025n

.meas tran vdout1_89ck940 FIND v(dout1_89) AT=475.025n

.meas tran vdout1_90ck940 FIND v(dout1_90) AT=475.025n

.meas tran vdout1_91ck940 FIND v(dout1_91) AT=475.025n

.meas tran vdout1_92ck940 FIND v(dout1_92) AT=475.025n

.meas tran vdout1_93ck940 FIND v(dout1_93) AT=475.025n

.meas tran vdout1_94ck940 FIND v(dout1_94) AT=475.025n

.meas tran vdout1_95ck940 FIND v(dout1_95) AT=475.025n

.meas tran vdout1_96ck940 FIND v(dout1_96) AT=475.025n

.meas tran vdout1_97ck940 FIND v(dout1_97) AT=475.025n

.meas tran vdout1_98ck940 FIND v(dout1_98) AT=475.025n

.meas tran vdout1_99ck940 FIND v(dout1_99) AT=475.025n

.meas tran vdout1_100ck940 FIND v(dout1_100) AT=475.025n

.meas tran vdout1_101ck940 FIND v(dout1_101) AT=475.025n

.meas tran vdout1_102ck940 FIND v(dout1_102) AT=475.025n

.meas tran vdout1_103ck940 FIND v(dout1_103) AT=475.025n

.meas tran vdout1_104ck940 FIND v(dout1_104) AT=475.025n

.meas tran vdout1_105ck940 FIND v(dout1_105) AT=475.025n

.meas tran vdout1_106ck940 FIND v(dout1_106) AT=475.025n

.meas tran vdout1_107ck940 FIND v(dout1_107) AT=475.025n

.meas tran vdout1_108ck940 FIND v(dout1_108) AT=475.025n

.meas tran vdout1_109ck940 FIND v(dout1_109) AT=475.025n

.meas tran vdout1_110ck940 FIND v(dout1_110) AT=475.025n

.meas tran vdout1_111ck940 FIND v(dout1_111) AT=475.025n

.meas tran vdout1_112ck940 FIND v(dout1_112) AT=475.025n

.meas tran vdout1_113ck940 FIND v(dout1_113) AT=475.025n

.meas tran vdout1_114ck940 FIND v(dout1_114) AT=475.025n

.meas tran vdout1_115ck940 FIND v(dout1_115) AT=475.025n

.meas tran vdout1_116ck940 FIND v(dout1_116) AT=475.025n

.meas tran vdout1_117ck940 FIND v(dout1_117) AT=475.025n

.meas tran vdout1_118ck940 FIND v(dout1_118) AT=475.025n

.meas tran vdout1_119ck940 FIND v(dout1_119) AT=475.025n

.meas tran vdout1_120ck940 FIND v(dout1_120) AT=475.025n

.meas tran vdout1_121ck940 FIND v(dout1_121) AT=475.025n

.meas tran vdout1_122ck940 FIND v(dout1_122) AT=475.025n

.meas tran vdout1_123ck940 FIND v(dout1_123) AT=475.025n

.meas tran vdout1_124ck940 FIND v(dout1_124) AT=475.025n

.meas tran vdout1_125ck940 FIND v(dout1_125) AT=475.025n

.meas tran vdout1_126ck940 FIND v(dout1_126) AT=475.025n

.meas tran vdout1_127ck940 FIND v(dout1_127) AT=475.025n

.meas tran vdout1_0ck950 FIND v(dout1_0) AT=480.025n

.meas tran vdout1_1ck950 FIND v(dout1_1) AT=480.025n

.meas tran vdout1_2ck950 FIND v(dout1_2) AT=480.025n

.meas tran vdout1_3ck950 FIND v(dout1_3) AT=480.025n

.meas tran vdout1_4ck950 FIND v(dout1_4) AT=480.025n

.meas tran vdout1_5ck950 FIND v(dout1_5) AT=480.025n

.meas tran vdout1_6ck950 FIND v(dout1_6) AT=480.025n

.meas tran vdout1_7ck950 FIND v(dout1_7) AT=480.025n

.meas tran vdout1_8ck950 FIND v(dout1_8) AT=480.025n

.meas tran vdout1_9ck950 FIND v(dout1_9) AT=480.025n

.meas tran vdout1_10ck950 FIND v(dout1_10) AT=480.025n

.meas tran vdout1_11ck950 FIND v(dout1_11) AT=480.025n

.meas tran vdout1_12ck950 FIND v(dout1_12) AT=480.025n

.meas tran vdout1_13ck950 FIND v(dout1_13) AT=480.025n

.meas tran vdout1_14ck950 FIND v(dout1_14) AT=480.025n

.meas tran vdout1_15ck950 FIND v(dout1_15) AT=480.025n

.meas tran vdout1_16ck950 FIND v(dout1_16) AT=480.025n

.meas tran vdout1_17ck950 FIND v(dout1_17) AT=480.025n

.meas tran vdout1_18ck950 FIND v(dout1_18) AT=480.025n

.meas tran vdout1_19ck950 FIND v(dout1_19) AT=480.025n

.meas tran vdout1_20ck950 FIND v(dout1_20) AT=480.025n

.meas tran vdout1_21ck950 FIND v(dout1_21) AT=480.025n

.meas tran vdout1_22ck950 FIND v(dout1_22) AT=480.025n

.meas tran vdout1_23ck950 FIND v(dout1_23) AT=480.025n

.meas tran vdout1_24ck950 FIND v(dout1_24) AT=480.025n

.meas tran vdout1_25ck950 FIND v(dout1_25) AT=480.025n

.meas tran vdout1_26ck950 FIND v(dout1_26) AT=480.025n

.meas tran vdout1_27ck950 FIND v(dout1_27) AT=480.025n

.meas tran vdout1_28ck950 FIND v(dout1_28) AT=480.025n

.meas tran vdout1_29ck950 FIND v(dout1_29) AT=480.025n

.meas tran vdout1_30ck950 FIND v(dout1_30) AT=480.025n

.meas tran vdout1_31ck950 FIND v(dout1_31) AT=480.025n

.meas tran vdout1_32ck950 FIND v(dout1_32) AT=480.025n

.meas tran vdout1_33ck950 FIND v(dout1_33) AT=480.025n

.meas tran vdout1_34ck950 FIND v(dout1_34) AT=480.025n

.meas tran vdout1_35ck950 FIND v(dout1_35) AT=480.025n

.meas tran vdout1_36ck950 FIND v(dout1_36) AT=480.025n

.meas tran vdout1_37ck950 FIND v(dout1_37) AT=480.025n

.meas tran vdout1_38ck950 FIND v(dout1_38) AT=480.025n

.meas tran vdout1_39ck950 FIND v(dout1_39) AT=480.025n

.meas tran vdout1_40ck950 FIND v(dout1_40) AT=480.025n

.meas tran vdout1_41ck950 FIND v(dout1_41) AT=480.025n

.meas tran vdout1_42ck950 FIND v(dout1_42) AT=480.025n

.meas tran vdout1_43ck950 FIND v(dout1_43) AT=480.025n

.meas tran vdout1_44ck950 FIND v(dout1_44) AT=480.025n

.meas tran vdout1_45ck950 FIND v(dout1_45) AT=480.025n

.meas tran vdout1_46ck950 FIND v(dout1_46) AT=480.025n

.meas tran vdout1_47ck950 FIND v(dout1_47) AT=480.025n

.meas tran vdout1_48ck950 FIND v(dout1_48) AT=480.025n

.meas tran vdout1_49ck950 FIND v(dout1_49) AT=480.025n

.meas tran vdout1_50ck950 FIND v(dout1_50) AT=480.025n

.meas tran vdout1_51ck950 FIND v(dout1_51) AT=480.025n

.meas tran vdout1_52ck950 FIND v(dout1_52) AT=480.025n

.meas tran vdout1_53ck950 FIND v(dout1_53) AT=480.025n

.meas tran vdout1_54ck950 FIND v(dout1_54) AT=480.025n

.meas tran vdout1_55ck950 FIND v(dout1_55) AT=480.025n

.meas tran vdout1_56ck950 FIND v(dout1_56) AT=480.025n

.meas tran vdout1_57ck950 FIND v(dout1_57) AT=480.025n

.meas tran vdout1_58ck950 FIND v(dout1_58) AT=480.025n

.meas tran vdout1_59ck950 FIND v(dout1_59) AT=480.025n

.meas tran vdout1_60ck950 FIND v(dout1_60) AT=480.025n

.meas tran vdout1_61ck950 FIND v(dout1_61) AT=480.025n

.meas tran vdout1_62ck950 FIND v(dout1_62) AT=480.025n

.meas tran vdout1_63ck950 FIND v(dout1_63) AT=480.025n

.meas tran vdout1_64ck950 FIND v(dout1_64) AT=480.025n

.meas tran vdout1_65ck950 FIND v(dout1_65) AT=480.025n

.meas tran vdout1_66ck950 FIND v(dout1_66) AT=480.025n

.meas tran vdout1_67ck950 FIND v(dout1_67) AT=480.025n

.meas tran vdout1_68ck950 FIND v(dout1_68) AT=480.025n

.meas tran vdout1_69ck950 FIND v(dout1_69) AT=480.025n

.meas tran vdout1_70ck950 FIND v(dout1_70) AT=480.025n

.meas tran vdout1_71ck950 FIND v(dout1_71) AT=480.025n

.meas tran vdout1_72ck950 FIND v(dout1_72) AT=480.025n

.meas tran vdout1_73ck950 FIND v(dout1_73) AT=480.025n

.meas tran vdout1_74ck950 FIND v(dout1_74) AT=480.025n

.meas tran vdout1_75ck950 FIND v(dout1_75) AT=480.025n

.meas tran vdout1_76ck950 FIND v(dout1_76) AT=480.025n

.meas tran vdout1_77ck950 FIND v(dout1_77) AT=480.025n

.meas tran vdout1_78ck950 FIND v(dout1_78) AT=480.025n

.meas tran vdout1_79ck950 FIND v(dout1_79) AT=480.025n

.meas tran vdout1_80ck950 FIND v(dout1_80) AT=480.025n

.meas tran vdout1_81ck950 FIND v(dout1_81) AT=480.025n

.meas tran vdout1_82ck950 FIND v(dout1_82) AT=480.025n

.meas tran vdout1_83ck950 FIND v(dout1_83) AT=480.025n

.meas tran vdout1_84ck950 FIND v(dout1_84) AT=480.025n

.meas tran vdout1_85ck950 FIND v(dout1_85) AT=480.025n

.meas tran vdout1_86ck950 FIND v(dout1_86) AT=480.025n

.meas tran vdout1_87ck950 FIND v(dout1_87) AT=480.025n

.meas tran vdout1_88ck950 FIND v(dout1_88) AT=480.025n

.meas tran vdout1_89ck950 FIND v(dout1_89) AT=480.025n

.meas tran vdout1_90ck950 FIND v(dout1_90) AT=480.025n

.meas tran vdout1_91ck950 FIND v(dout1_91) AT=480.025n

.meas tran vdout1_92ck950 FIND v(dout1_92) AT=480.025n

.meas tran vdout1_93ck950 FIND v(dout1_93) AT=480.025n

.meas tran vdout1_94ck950 FIND v(dout1_94) AT=480.025n

.meas tran vdout1_95ck950 FIND v(dout1_95) AT=480.025n

.meas tran vdout1_96ck950 FIND v(dout1_96) AT=480.025n

.meas tran vdout1_97ck950 FIND v(dout1_97) AT=480.025n

.meas tran vdout1_98ck950 FIND v(dout1_98) AT=480.025n

.meas tran vdout1_99ck950 FIND v(dout1_99) AT=480.025n

.meas tran vdout1_100ck950 FIND v(dout1_100) AT=480.025n

.meas tran vdout1_101ck950 FIND v(dout1_101) AT=480.025n

.meas tran vdout1_102ck950 FIND v(dout1_102) AT=480.025n

.meas tran vdout1_103ck950 FIND v(dout1_103) AT=480.025n

.meas tran vdout1_104ck950 FIND v(dout1_104) AT=480.025n

.meas tran vdout1_105ck950 FIND v(dout1_105) AT=480.025n

.meas tran vdout1_106ck950 FIND v(dout1_106) AT=480.025n

.meas tran vdout1_107ck950 FIND v(dout1_107) AT=480.025n

.meas tran vdout1_108ck950 FIND v(dout1_108) AT=480.025n

.meas tran vdout1_109ck950 FIND v(dout1_109) AT=480.025n

.meas tran vdout1_110ck950 FIND v(dout1_110) AT=480.025n

.meas tran vdout1_111ck950 FIND v(dout1_111) AT=480.025n

.meas tran vdout1_112ck950 FIND v(dout1_112) AT=480.025n

.meas tran vdout1_113ck950 FIND v(dout1_113) AT=480.025n

.meas tran vdout1_114ck950 FIND v(dout1_114) AT=480.025n

.meas tran vdout1_115ck950 FIND v(dout1_115) AT=480.025n

.meas tran vdout1_116ck950 FIND v(dout1_116) AT=480.025n

.meas tran vdout1_117ck950 FIND v(dout1_117) AT=480.025n

.meas tran vdout1_118ck950 FIND v(dout1_118) AT=480.025n

.meas tran vdout1_119ck950 FIND v(dout1_119) AT=480.025n

.meas tran vdout1_120ck950 FIND v(dout1_120) AT=480.025n

.meas tran vdout1_121ck950 FIND v(dout1_121) AT=480.025n

.meas tran vdout1_122ck950 FIND v(dout1_122) AT=480.025n

.meas tran vdout1_123ck950 FIND v(dout1_123) AT=480.025n

.meas tran vdout1_124ck950 FIND v(dout1_124) AT=480.025n

.meas tran vdout1_125ck950 FIND v(dout1_125) AT=480.025n

.meas tran vdout1_126ck950 FIND v(dout1_126) AT=480.025n

.meas tran vdout1_127ck950 FIND v(dout1_127) AT=480.025n

.meas tran vdout1_0ck960 FIND v(dout1_0) AT=485.025n

.meas tran vdout1_1ck960 FIND v(dout1_1) AT=485.025n

.meas tran vdout1_2ck960 FIND v(dout1_2) AT=485.025n

.meas tran vdout1_3ck960 FIND v(dout1_3) AT=485.025n

.meas tran vdout1_4ck960 FIND v(dout1_4) AT=485.025n

.meas tran vdout1_5ck960 FIND v(dout1_5) AT=485.025n

.meas tran vdout1_6ck960 FIND v(dout1_6) AT=485.025n

.meas tran vdout1_7ck960 FIND v(dout1_7) AT=485.025n

.meas tran vdout1_8ck960 FIND v(dout1_8) AT=485.025n

.meas tran vdout1_9ck960 FIND v(dout1_9) AT=485.025n

.meas tran vdout1_10ck960 FIND v(dout1_10) AT=485.025n

.meas tran vdout1_11ck960 FIND v(dout1_11) AT=485.025n

.meas tran vdout1_12ck960 FIND v(dout1_12) AT=485.025n

.meas tran vdout1_13ck960 FIND v(dout1_13) AT=485.025n

.meas tran vdout1_14ck960 FIND v(dout1_14) AT=485.025n

.meas tran vdout1_15ck960 FIND v(dout1_15) AT=485.025n

.meas tran vdout1_16ck960 FIND v(dout1_16) AT=485.025n

.meas tran vdout1_17ck960 FIND v(dout1_17) AT=485.025n

.meas tran vdout1_18ck960 FIND v(dout1_18) AT=485.025n

.meas tran vdout1_19ck960 FIND v(dout1_19) AT=485.025n

.meas tran vdout1_20ck960 FIND v(dout1_20) AT=485.025n

.meas tran vdout1_21ck960 FIND v(dout1_21) AT=485.025n

.meas tran vdout1_22ck960 FIND v(dout1_22) AT=485.025n

.meas tran vdout1_23ck960 FIND v(dout1_23) AT=485.025n

.meas tran vdout1_24ck960 FIND v(dout1_24) AT=485.025n

.meas tran vdout1_25ck960 FIND v(dout1_25) AT=485.025n

.meas tran vdout1_26ck960 FIND v(dout1_26) AT=485.025n

.meas tran vdout1_27ck960 FIND v(dout1_27) AT=485.025n

.meas tran vdout1_28ck960 FIND v(dout1_28) AT=485.025n

.meas tran vdout1_29ck960 FIND v(dout1_29) AT=485.025n

.meas tran vdout1_30ck960 FIND v(dout1_30) AT=485.025n

.meas tran vdout1_31ck960 FIND v(dout1_31) AT=485.025n

.meas tran vdout1_32ck960 FIND v(dout1_32) AT=485.025n

.meas tran vdout1_33ck960 FIND v(dout1_33) AT=485.025n

.meas tran vdout1_34ck960 FIND v(dout1_34) AT=485.025n

.meas tran vdout1_35ck960 FIND v(dout1_35) AT=485.025n

.meas tran vdout1_36ck960 FIND v(dout1_36) AT=485.025n

.meas tran vdout1_37ck960 FIND v(dout1_37) AT=485.025n

.meas tran vdout1_38ck960 FIND v(dout1_38) AT=485.025n

.meas tran vdout1_39ck960 FIND v(dout1_39) AT=485.025n

.meas tran vdout1_40ck960 FIND v(dout1_40) AT=485.025n

.meas tran vdout1_41ck960 FIND v(dout1_41) AT=485.025n

.meas tran vdout1_42ck960 FIND v(dout1_42) AT=485.025n

.meas tran vdout1_43ck960 FIND v(dout1_43) AT=485.025n

.meas tran vdout1_44ck960 FIND v(dout1_44) AT=485.025n

.meas tran vdout1_45ck960 FIND v(dout1_45) AT=485.025n

.meas tran vdout1_46ck960 FIND v(dout1_46) AT=485.025n

.meas tran vdout1_47ck960 FIND v(dout1_47) AT=485.025n

.meas tran vdout1_48ck960 FIND v(dout1_48) AT=485.025n

.meas tran vdout1_49ck960 FIND v(dout1_49) AT=485.025n

.meas tran vdout1_50ck960 FIND v(dout1_50) AT=485.025n

.meas tran vdout1_51ck960 FIND v(dout1_51) AT=485.025n

.meas tran vdout1_52ck960 FIND v(dout1_52) AT=485.025n

.meas tran vdout1_53ck960 FIND v(dout1_53) AT=485.025n

.meas tran vdout1_54ck960 FIND v(dout1_54) AT=485.025n

.meas tran vdout1_55ck960 FIND v(dout1_55) AT=485.025n

.meas tran vdout1_56ck960 FIND v(dout1_56) AT=485.025n

.meas tran vdout1_57ck960 FIND v(dout1_57) AT=485.025n

.meas tran vdout1_58ck960 FIND v(dout1_58) AT=485.025n

.meas tran vdout1_59ck960 FIND v(dout1_59) AT=485.025n

.meas tran vdout1_60ck960 FIND v(dout1_60) AT=485.025n

.meas tran vdout1_61ck960 FIND v(dout1_61) AT=485.025n

.meas tran vdout1_62ck960 FIND v(dout1_62) AT=485.025n

.meas tran vdout1_63ck960 FIND v(dout1_63) AT=485.025n

.meas tran vdout1_64ck960 FIND v(dout1_64) AT=485.025n

.meas tran vdout1_65ck960 FIND v(dout1_65) AT=485.025n

.meas tran vdout1_66ck960 FIND v(dout1_66) AT=485.025n

.meas tran vdout1_67ck960 FIND v(dout1_67) AT=485.025n

.meas tran vdout1_68ck960 FIND v(dout1_68) AT=485.025n

.meas tran vdout1_69ck960 FIND v(dout1_69) AT=485.025n

.meas tran vdout1_70ck960 FIND v(dout1_70) AT=485.025n

.meas tran vdout1_71ck960 FIND v(dout1_71) AT=485.025n

.meas tran vdout1_72ck960 FIND v(dout1_72) AT=485.025n

.meas tran vdout1_73ck960 FIND v(dout1_73) AT=485.025n

.meas tran vdout1_74ck960 FIND v(dout1_74) AT=485.025n

.meas tran vdout1_75ck960 FIND v(dout1_75) AT=485.025n

.meas tran vdout1_76ck960 FIND v(dout1_76) AT=485.025n

.meas tran vdout1_77ck960 FIND v(dout1_77) AT=485.025n

.meas tran vdout1_78ck960 FIND v(dout1_78) AT=485.025n

.meas tran vdout1_79ck960 FIND v(dout1_79) AT=485.025n

.meas tran vdout1_80ck960 FIND v(dout1_80) AT=485.025n

.meas tran vdout1_81ck960 FIND v(dout1_81) AT=485.025n

.meas tran vdout1_82ck960 FIND v(dout1_82) AT=485.025n

.meas tran vdout1_83ck960 FIND v(dout1_83) AT=485.025n

.meas tran vdout1_84ck960 FIND v(dout1_84) AT=485.025n

.meas tran vdout1_85ck960 FIND v(dout1_85) AT=485.025n

.meas tran vdout1_86ck960 FIND v(dout1_86) AT=485.025n

.meas tran vdout1_87ck960 FIND v(dout1_87) AT=485.025n

.meas tran vdout1_88ck960 FIND v(dout1_88) AT=485.025n

.meas tran vdout1_89ck960 FIND v(dout1_89) AT=485.025n

.meas tran vdout1_90ck960 FIND v(dout1_90) AT=485.025n

.meas tran vdout1_91ck960 FIND v(dout1_91) AT=485.025n

.meas tran vdout1_92ck960 FIND v(dout1_92) AT=485.025n

.meas tran vdout1_93ck960 FIND v(dout1_93) AT=485.025n

.meas tran vdout1_94ck960 FIND v(dout1_94) AT=485.025n

.meas tran vdout1_95ck960 FIND v(dout1_95) AT=485.025n

.meas tran vdout1_96ck960 FIND v(dout1_96) AT=485.025n

.meas tran vdout1_97ck960 FIND v(dout1_97) AT=485.025n

.meas tran vdout1_98ck960 FIND v(dout1_98) AT=485.025n

.meas tran vdout1_99ck960 FIND v(dout1_99) AT=485.025n

.meas tran vdout1_100ck960 FIND v(dout1_100) AT=485.025n

.meas tran vdout1_101ck960 FIND v(dout1_101) AT=485.025n

.meas tran vdout1_102ck960 FIND v(dout1_102) AT=485.025n

.meas tran vdout1_103ck960 FIND v(dout1_103) AT=485.025n

.meas tran vdout1_104ck960 FIND v(dout1_104) AT=485.025n

.meas tran vdout1_105ck960 FIND v(dout1_105) AT=485.025n

.meas tran vdout1_106ck960 FIND v(dout1_106) AT=485.025n

.meas tran vdout1_107ck960 FIND v(dout1_107) AT=485.025n

.meas tran vdout1_108ck960 FIND v(dout1_108) AT=485.025n

.meas tran vdout1_109ck960 FIND v(dout1_109) AT=485.025n

.meas tran vdout1_110ck960 FIND v(dout1_110) AT=485.025n

.meas tran vdout1_111ck960 FIND v(dout1_111) AT=485.025n

.meas tran vdout1_112ck960 FIND v(dout1_112) AT=485.025n

.meas tran vdout1_113ck960 FIND v(dout1_113) AT=485.025n

.meas tran vdout1_114ck960 FIND v(dout1_114) AT=485.025n

.meas tran vdout1_115ck960 FIND v(dout1_115) AT=485.025n

.meas tran vdout1_116ck960 FIND v(dout1_116) AT=485.025n

.meas tran vdout1_117ck960 FIND v(dout1_117) AT=485.025n

.meas tran vdout1_118ck960 FIND v(dout1_118) AT=485.025n

.meas tran vdout1_119ck960 FIND v(dout1_119) AT=485.025n

.meas tran vdout1_120ck960 FIND v(dout1_120) AT=485.025n

.meas tran vdout1_121ck960 FIND v(dout1_121) AT=485.025n

.meas tran vdout1_122ck960 FIND v(dout1_122) AT=485.025n

.meas tran vdout1_123ck960 FIND v(dout1_123) AT=485.025n

.meas tran vdout1_124ck960 FIND v(dout1_124) AT=485.025n

.meas tran vdout1_125ck960 FIND v(dout1_125) AT=485.025n

.meas tran vdout1_126ck960 FIND v(dout1_126) AT=485.025n

.meas tran vdout1_127ck960 FIND v(dout1_127) AT=485.025n

.meas tran vdout1_0ck970 FIND v(dout1_0) AT=490.025n

.meas tran vdout1_1ck970 FIND v(dout1_1) AT=490.025n

.meas tran vdout1_2ck970 FIND v(dout1_2) AT=490.025n

.meas tran vdout1_3ck970 FIND v(dout1_3) AT=490.025n

.meas tran vdout1_4ck970 FIND v(dout1_4) AT=490.025n

.meas tran vdout1_5ck970 FIND v(dout1_5) AT=490.025n

.meas tran vdout1_6ck970 FIND v(dout1_6) AT=490.025n

.meas tran vdout1_7ck970 FIND v(dout1_7) AT=490.025n

.meas tran vdout1_8ck970 FIND v(dout1_8) AT=490.025n

.meas tran vdout1_9ck970 FIND v(dout1_9) AT=490.025n

.meas tran vdout1_10ck970 FIND v(dout1_10) AT=490.025n

.meas tran vdout1_11ck970 FIND v(dout1_11) AT=490.025n

.meas tran vdout1_12ck970 FIND v(dout1_12) AT=490.025n

.meas tran vdout1_13ck970 FIND v(dout1_13) AT=490.025n

.meas tran vdout1_14ck970 FIND v(dout1_14) AT=490.025n

.meas tran vdout1_15ck970 FIND v(dout1_15) AT=490.025n

.meas tran vdout1_16ck970 FIND v(dout1_16) AT=490.025n

.meas tran vdout1_17ck970 FIND v(dout1_17) AT=490.025n

.meas tran vdout1_18ck970 FIND v(dout1_18) AT=490.025n

.meas tran vdout1_19ck970 FIND v(dout1_19) AT=490.025n

.meas tran vdout1_20ck970 FIND v(dout1_20) AT=490.025n

.meas tran vdout1_21ck970 FIND v(dout1_21) AT=490.025n

.meas tran vdout1_22ck970 FIND v(dout1_22) AT=490.025n

.meas tran vdout1_23ck970 FIND v(dout1_23) AT=490.025n

.meas tran vdout1_24ck970 FIND v(dout1_24) AT=490.025n

.meas tran vdout1_25ck970 FIND v(dout1_25) AT=490.025n

.meas tran vdout1_26ck970 FIND v(dout1_26) AT=490.025n

.meas tran vdout1_27ck970 FIND v(dout1_27) AT=490.025n

.meas tran vdout1_28ck970 FIND v(dout1_28) AT=490.025n

.meas tran vdout1_29ck970 FIND v(dout1_29) AT=490.025n

.meas tran vdout1_30ck970 FIND v(dout1_30) AT=490.025n

.meas tran vdout1_31ck970 FIND v(dout1_31) AT=490.025n

.meas tran vdout1_32ck970 FIND v(dout1_32) AT=490.025n

.meas tran vdout1_33ck970 FIND v(dout1_33) AT=490.025n

.meas tran vdout1_34ck970 FIND v(dout1_34) AT=490.025n

.meas tran vdout1_35ck970 FIND v(dout1_35) AT=490.025n

.meas tran vdout1_36ck970 FIND v(dout1_36) AT=490.025n

.meas tran vdout1_37ck970 FIND v(dout1_37) AT=490.025n

.meas tran vdout1_38ck970 FIND v(dout1_38) AT=490.025n

.meas tran vdout1_39ck970 FIND v(dout1_39) AT=490.025n

.meas tran vdout1_40ck970 FIND v(dout1_40) AT=490.025n

.meas tran vdout1_41ck970 FIND v(dout1_41) AT=490.025n

.meas tran vdout1_42ck970 FIND v(dout1_42) AT=490.025n

.meas tran vdout1_43ck970 FIND v(dout1_43) AT=490.025n

.meas tran vdout1_44ck970 FIND v(dout1_44) AT=490.025n

.meas tran vdout1_45ck970 FIND v(dout1_45) AT=490.025n

.meas tran vdout1_46ck970 FIND v(dout1_46) AT=490.025n

.meas tran vdout1_47ck970 FIND v(dout1_47) AT=490.025n

.meas tran vdout1_48ck970 FIND v(dout1_48) AT=490.025n

.meas tran vdout1_49ck970 FIND v(dout1_49) AT=490.025n

.meas tran vdout1_50ck970 FIND v(dout1_50) AT=490.025n

.meas tran vdout1_51ck970 FIND v(dout1_51) AT=490.025n

.meas tran vdout1_52ck970 FIND v(dout1_52) AT=490.025n

.meas tran vdout1_53ck970 FIND v(dout1_53) AT=490.025n

.meas tran vdout1_54ck970 FIND v(dout1_54) AT=490.025n

.meas tran vdout1_55ck970 FIND v(dout1_55) AT=490.025n

.meas tran vdout1_56ck970 FIND v(dout1_56) AT=490.025n

.meas tran vdout1_57ck970 FIND v(dout1_57) AT=490.025n

.meas tran vdout1_58ck970 FIND v(dout1_58) AT=490.025n

.meas tran vdout1_59ck970 FIND v(dout1_59) AT=490.025n

.meas tran vdout1_60ck970 FIND v(dout1_60) AT=490.025n

.meas tran vdout1_61ck970 FIND v(dout1_61) AT=490.025n

.meas tran vdout1_62ck970 FIND v(dout1_62) AT=490.025n

.meas tran vdout1_63ck970 FIND v(dout1_63) AT=490.025n

.meas tran vdout1_64ck970 FIND v(dout1_64) AT=490.025n

.meas tran vdout1_65ck970 FIND v(dout1_65) AT=490.025n

.meas tran vdout1_66ck970 FIND v(dout1_66) AT=490.025n

.meas tran vdout1_67ck970 FIND v(dout1_67) AT=490.025n

.meas tran vdout1_68ck970 FIND v(dout1_68) AT=490.025n

.meas tran vdout1_69ck970 FIND v(dout1_69) AT=490.025n

.meas tran vdout1_70ck970 FIND v(dout1_70) AT=490.025n

.meas tran vdout1_71ck970 FIND v(dout1_71) AT=490.025n

.meas tran vdout1_72ck970 FIND v(dout1_72) AT=490.025n

.meas tran vdout1_73ck970 FIND v(dout1_73) AT=490.025n

.meas tran vdout1_74ck970 FIND v(dout1_74) AT=490.025n

.meas tran vdout1_75ck970 FIND v(dout1_75) AT=490.025n

.meas tran vdout1_76ck970 FIND v(dout1_76) AT=490.025n

.meas tran vdout1_77ck970 FIND v(dout1_77) AT=490.025n

.meas tran vdout1_78ck970 FIND v(dout1_78) AT=490.025n

.meas tran vdout1_79ck970 FIND v(dout1_79) AT=490.025n

.meas tran vdout1_80ck970 FIND v(dout1_80) AT=490.025n

.meas tran vdout1_81ck970 FIND v(dout1_81) AT=490.025n

.meas tran vdout1_82ck970 FIND v(dout1_82) AT=490.025n

.meas tran vdout1_83ck970 FIND v(dout1_83) AT=490.025n

.meas tran vdout1_84ck970 FIND v(dout1_84) AT=490.025n

.meas tran vdout1_85ck970 FIND v(dout1_85) AT=490.025n

.meas tran vdout1_86ck970 FIND v(dout1_86) AT=490.025n

.meas tran vdout1_87ck970 FIND v(dout1_87) AT=490.025n

.meas tran vdout1_88ck970 FIND v(dout1_88) AT=490.025n

.meas tran vdout1_89ck970 FIND v(dout1_89) AT=490.025n

.meas tran vdout1_90ck970 FIND v(dout1_90) AT=490.025n

.meas tran vdout1_91ck970 FIND v(dout1_91) AT=490.025n

.meas tran vdout1_92ck970 FIND v(dout1_92) AT=490.025n

.meas tran vdout1_93ck970 FIND v(dout1_93) AT=490.025n

.meas tran vdout1_94ck970 FIND v(dout1_94) AT=490.025n

.meas tran vdout1_95ck970 FIND v(dout1_95) AT=490.025n

.meas tran vdout1_96ck970 FIND v(dout1_96) AT=490.025n

.meas tran vdout1_97ck970 FIND v(dout1_97) AT=490.025n

.meas tran vdout1_98ck970 FIND v(dout1_98) AT=490.025n

.meas tran vdout1_99ck970 FIND v(dout1_99) AT=490.025n

.meas tran vdout1_100ck970 FIND v(dout1_100) AT=490.025n

.meas tran vdout1_101ck970 FIND v(dout1_101) AT=490.025n

.meas tran vdout1_102ck970 FIND v(dout1_102) AT=490.025n

.meas tran vdout1_103ck970 FIND v(dout1_103) AT=490.025n

.meas tran vdout1_104ck970 FIND v(dout1_104) AT=490.025n

.meas tran vdout1_105ck970 FIND v(dout1_105) AT=490.025n

.meas tran vdout1_106ck970 FIND v(dout1_106) AT=490.025n

.meas tran vdout1_107ck970 FIND v(dout1_107) AT=490.025n

.meas tran vdout1_108ck970 FIND v(dout1_108) AT=490.025n

.meas tran vdout1_109ck970 FIND v(dout1_109) AT=490.025n

.meas tran vdout1_110ck970 FIND v(dout1_110) AT=490.025n

.meas tran vdout1_111ck970 FIND v(dout1_111) AT=490.025n

.meas tran vdout1_112ck970 FIND v(dout1_112) AT=490.025n

.meas tran vdout1_113ck970 FIND v(dout1_113) AT=490.025n

.meas tran vdout1_114ck970 FIND v(dout1_114) AT=490.025n

.meas tran vdout1_115ck970 FIND v(dout1_115) AT=490.025n

.meas tran vdout1_116ck970 FIND v(dout1_116) AT=490.025n

.meas tran vdout1_117ck970 FIND v(dout1_117) AT=490.025n

.meas tran vdout1_118ck970 FIND v(dout1_118) AT=490.025n

.meas tran vdout1_119ck970 FIND v(dout1_119) AT=490.025n

.meas tran vdout1_120ck970 FIND v(dout1_120) AT=490.025n

.meas tran vdout1_121ck970 FIND v(dout1_121) AT=490.025n

.meas tran vdout1_122ck970 FIND v(dout1_122) AT=490.025n

.meas tran vdout1_123ck970 FIND v(dout1_123) AT=490.025n

.meas tran vdout1_124ck970 FIND v(dout1_124) AT=490.025n

.meas tran vdout1_125ck970 FIND v(dout1_125) AT=490.025n

.meas tran vdout1_126ck970 FIND v(dout1_126) AT=490.025n

.meas tran vdout1_127ck970 FIND v(dout1_127) AT=490.025n

.meas tran vdout1_0ck990 FIND v(dout1_0) AT=500.025n

.meas tran vdout1_1ck990 FIND v(dout1_1) AT=500.025n

.meas tran vdout1_2ck990 FIND v(dout1_2) AT=500.025n

.meas tran vdout1_3ck990 FIND v(dout1_3) AT=500.025n

.meas tran vdout1_4ck990 FIND v(dout1_4) AT=500.025n

.meas tran vdout1_5ck990 FIND v(dout1_5) AT=500.025n

.meas tran vdout1_6ck990 FIND v(dout1_6) AT=500.025n

.meas tran vdout1_7ck990 FIND v(dout1_7) AT=500.025n

.meas tran vdout1_8ck990 FIND v(dout1_8) AT=500.025n

.meas tran vdout1_9ck990 FIND v(dout1_9) AT=500.025n

.meas tran vdout1_10ck990 FIND v(dout1_10) AT=500.025n

.meas tran vdout1_11ck990 FIND v(dout1_11) AT=500.025n

.meas tran vdout1_12ck990 FIND v(dout1_12) AT=500.025n

.meas tran vdout1_13ck990 FIND v(dout1_13) AT=500.025n

.meas tran vdout1_14ck990 FIND v(dout1_14) AT=500.025n

.meas tran vdout1_15ck990 FIND v(dout1_15) AT=500.025n

.meas tran vdout1_16ck990 FIND v(dout1_16) AT=500.025n

.meas tran vdout1_17ck990 FIND v(dout1_17) AT=500.025n

.meas tran vdout1_18ck990 FIND v(dout1_18) AT=500.025n

.meas tran vdout1_19ck990 FIND v(dout1_19) AT=500.025n

.meas tran vdout1_20ck990 FIND v(dout1_20) AT=500.025n

.meas tran vdout1_21ck990 FIND v(dout1_21) AT=500.025n

.meas tran vdout1_22ck990 FIND v(dout1_22) AT=500.025n

.meas tran vdout1_23ck990 FIND v(dout1_23) AT=500.025n

.meas tran vdout1_24ck990 FIND v(dout1_24) AT=500.025n

.meas tran vdout1_25ck990 FIND v(dout1_25) AT=500.025n

.meas tran vdout1_26ck990 FIND v(dout1_26) AT=500.025n

.meas tran vdout1_27ck990 FIND v(dout1_27) AT=500.025n

.meas tran vdout1_28ck990 FIND v(dout1_28) AT=500.025n

.meas tran vdout1_29ck990 FIND v(dout1_29) AT=500.025n

.meas tran vdout1_30ck990 FIND v(dout1_30) AT=500.025n

.meas tran vdout1_31ck990 FIND v(dout1_31) AT=500.025n

.meas tran vdout1_32ck990 FIND v(dout1_32) AT=500.025n

.meas tran vdout1_33ck990 FIND v(dout1_33) AT=500.025n

.meas tran vdout1_34ck990 FIND v(dout1_34) AT=500.025n

.meas tran vdout1_35ck990 FIND v(dout1_35) AT=500.025n

.meas tran vdout1_36ck990 FIND v(dout1_36) AT=500.025n

.meas tran vdout1_37ck990 FIND v(dout1_37) AT=500.025n

.meas tran vdout1_38ck990 FIND v(dout1_38) AT=500.025n

.meas tran vdout1_39ck990 FIND v(dout1_39) AT=500.025n

.meas tran vdout1_40ck990 FIND v(dout1_40) AT=500.025n

.meas tran vdout1_41ck990 FIND v(dout1_41) AT=500.025n

.meas tran vdout1_42ck990 FIND v(dout1_42) AT=500.025n

.meas tran vdout1_43ck990 FIND v(dout1_43) AT=500.025n

.meas tran vdout1_44ck990 FIND v(dout1_44) AT=500.025n

.meas tran vdout1_45ck990 FIND v(dout1_45) AT=500.025n

.meas tran vdout1_46ck990 FIND v(dout1_46) AT=500.025n

.meas tran vdout1_47ck990 FIND v(dout1_47) AT=500.025n

.meas tran vdout1_48ck990 FIND v(dout1_48) AT=500.025n

.meas tran vdout1_49ck990 FIND v(dout1_49) AT=500.025n

.meas tran vdout1_50ck990 FIND v(dout1_50) AT=500.025n

.meas tran vdout1_51ck990 FIND v(dout1_51) AT=500.025n

.meas tran vdout1_52ck990 FIND v(dout1_52) AT=500.025n

.meas tran vdout1_53ck990 FIND v(dout1_53) AT=500.025n

.meas tran vdout1_54ck990 FIND v(dout1_54) AT=500.025n

.meas tran vdout1_55ck990 FIND v(dout1_55) AT=500.025n

.meas tran vdout1_56ck990 FIND v(dout1_56) AT=500.025n

.meas tran vdout1_57ck990 FIND v(dout1_57) AT=500.025n

.meas tran vdout1_58ck990 FIND v(dout1_58) AT=500.025n

.meas tran vdout1_59ck990 FIND v(dout1_59) AT=500.025n

.meas tran vdout1_60ck990 FIND v(dout1_60) AT=500.025n

.meas tran vdout1_61ck990 FIND v(dout1_61) AT=500.025n

.meas tran vdout1_62ck990 FIND v(dout1_62) AT=500.025n

.meas tran vdout1_63ck990 FIND v(dout1_63) AT=500.025n

.meas tran vdout1_64ck990 FIND v(dout1_64) AT=500.025n

.meas tran vdout1_65ck990 FIND v(dout1_65) AT=500.025n

.meas tran vdout1_66ck990 FIND v(dout1_66) AT=500.025n

.meas tran vdout1_67ck990 FIND v(dout1_67) AT=500.025n

.meas tran vdout1_68ck990 FIND v(dout1_68) AT=500.025n

.meas tran vdout1_69ck990 FIND v(dout1_69) AT=500.025n

.meas tran vdout1_70ck990 FIND v(dout1_70) AT=500.025n

.meas tran vdout1_71ck990 FIND v(dout1_71) AT=500.025n

.meas tran vdout1_72ck990 FIND v(dout1_72) AT=500.025n

.meas tran vdout1_73ck990 FIND v(dout1_73) AT=500.025n

.meas tran vdout1_74ck990 FIND v(dout1_74) AT=500.025n

.meas tran vdout1_75ck990 FIND v(dout1_75) AT=500.025n

.meas tran vdout1_76ck990 FIND v(dout1_76) AT=500.025n

.meas tran vdout1_77ck990 FIND v(dout1_77) AT=500.025n

.meas tran vdout1_78ck990 FIND v(dout1_78) AT=500.025n

.meas tran vdout1_79ck990 FIND v(dout1_79) AT=500.025n

.meas tran vdout1_80ck990 FIND v(dout1_80) AT=500.025n

.meas tran vdout1_81ck990 FIND v(dout1_81) AT=500.025n

.meas tran vdout1_82ck990 FIND v(dout1_82) AT=500.025n

.meas tran vdout1_83ck990 FIND v(dout1_83) AT=500.025n

.meas tran vdout1_84ck990 FIND v(dout1_84) AT=500.025n

.meas tran vdout1_85ck990 FIND v(dout1_85) AT=500.025n

.meas tran vdout1_86ck990 FIND v(dout1_86) AT=500.025n

.meas tran vdout1_87ck990 FIND v(dout1_87) AT=500.025n

.meas tran vdout1_88ck990 FIND v(dout1_88) AT=500.025n

.meas tran vdout1_89ck990 FIND v(dout1_89) AT=500.025n

.meas tran vdout1_90ck990 FIND v(dout1_90) AT=500.025n

.meas tran vdout1_91ck990 FIND v(dout1_91) AT=500.025n

.meas tran vdout1_92ck990 FIND v(dout1_92) AT=500.025n

.meas tran vdout1_93ck990 FIND v(dout1_93) AT=500.025n

.meas tran vdout1_94ck990 FIND v(dout1_94) AT=500.025n

.meas tran vdout1_95ck990 FIND v(dout1_95) AT=500.025n

.meas tran vdout1_96ck990 FIND v(dout1_96) AT=500.025n

.meas tran vdout1_97ck990 FIND v(dout1_97) AT=500.025n

.meas tran vdout1_98ck990 FIND v(dout1_98) AT=500.025n

.meas tran vdout1_99ck990 FIND v(dout1_99) AT=500.025n

.meas tran vdout1_100ck990 FIND v(dout1_100) AT=500.025n

.meas tran vdout1_101ck990 FIND v(dout1_101) AT=500.025n

.meas tran vdout1_102ck990 FIND v(dout1_102) AT=500.025n

.meas tran vdout1_103ck990 FIND v(dout1_103) AT=500.025n

.meas tran vdout1_104ck990 FIND v(dout1_104) AT=500.025n

.meas tran vdout1_105ck990 FIND v(dout1_105) AT=500.025n

.meas tran vdout1_106ck990 FIND v(dout1_106) AT=500.025n

.meas tran vdout1_107ck990 FIND v(dout1_107) AT=500.025n

.meas tran vdout1_108ck990 FIND v(dout1_108) AT=500.025n

.meas tran vdout1_109ck990 FIND v(dout1_109) AT=500.025n

.meas tran vdout1_110ck990 FIND v(dout1_110) AT=500.025n

.meas tran vdout1_111ck990 FIND v(dout1_111) AT=500.025n

.meas tran vdout1_112ck990 FIND v(dout1_112) AT=500.025n

.meas tran vdout1_113ck990 FIND v(dout1_113) AT=500.025n

.meas tran vdout1_114ck990 FIND v(dout1_114) AT=500.025n

.meas tran vdout1_115ck990 FIND v(dout1_115) AT=500.025n

.meas tran vdout1_116ck990 FIND v(dout1_116) AT=500.025n

.meas tran vdout1_117ck990 FIND v(dout1_117) AT=500.025n

.meas tran vdout1_118ck990 FIND v(dout1_118) AT=500.025n

.meas tran vdout1_119ck990 FIND v(dout1_119) AT=500.025n

.meas tran vdout1_120ck990 FIND v(dout1_120) AT=500.025n

.meas tran vdout1_121ck990 FIND v(dout1_121) AT=500.025n

.meas tran vdout1_122ck990 FIND v(dout1_122) AT=500.025n

.meas tran vdout1_123ck990 FIND v(dout1_123) AT=500.025n

.meas tran vdout1_124ck990 FIND v(dout1_124) AT=500.025n

.meas tran vdout1_125ck990 FIND v(dout1_125) AT=500.025n

.meas tran vdout1_126ck990 FIND v(dout1_126) AT=500.025n

.meas tran vdout1_127ck990 FIND v(dout1_127) AT=500.025n

.meas tran vdout1_0ck1050 FIND v(dout1_0) AT=530.025n

.meas tran vdout1_1ck1050 FIND v(dout1_1) AT=530.025n

.meas tran vdout1_2ck1050 FIND v(dout1_2) AT=530.025n

.meas tran vdout1_3ck1050 FIND v(dout1_3) AT=530.025n

.meas tran vdout1_4ck1050 FIND v(dout1_4) AT=530.025n

.meas tran vdout1_5ck1050 FIND v(dout1_5) AT=530.025n

.meas tran vdout1_6ck1050 FIND v(dout1_6) AT=530.025n

.meas tran vdout1_7ck1050 FIND v(dout1_7) AT=530.025n

.meas tran vdout1_8ck1050 FIND v(dout1_8) AT=530.025n

.meas tran vdout1_9ck1050 FIND v(dout1_9) AT=530.025n

.meas tran vdout1_10ck1050 FIND v(dout1_10) AT=530.025n

.meas tran vdout1_11ck1050 FIND v(dout1_11) AT=530.025n

.meas tran vdout1_12ck1050 FIND v(dout1_12) AT=530.025n

.meas tran vdout1_13ck1050 FIND v(dout1_13) AT=530.025n

.meas tran vdout1_14ck1050 FIND v(dout1_14) AT=530.025n

.meas tran vdout1_15ck1050 FIND v(dout1_15) AT=530.025n

.meas tran vdout1_16ck1050 FIND v(dout1_16) AT=530.025n

.meas tran vdout1_17ck1050 FIND v(dout1_17) AT=530.025n

.meas tran vdout1_18ck1050 FIND v(dout1_18) AT=530.025n

.meas tran vdout1_19ck1050 FIND v(dout1_19) AT=530.025n

.meas tran vdout1_20ck1050 FIND v(dout1_20) AT=530.025n

.meas tran vdout1_21ck1050 FIND v(dout1_21) AT=530.025n

.meas tran vdout1_22ck1050 FIND v(dout1_22) AT=530.025n

.meas tran vdout1_23ck1050 FIND v(dout1_23) AT=530.025n

.meas tran vdout1_24ck1050 FIND v(dout1_24) AT=530.025n

.meas tran vdout1_25ck1050 FIND v(dout1_25) AT=530.025n

.meas tran vdout1_26ck1050 FIND v(dout1_26) AT=530.025n

.meas tran vdout1_27ck1050 FIND v(dout1_27) AT=530.025n

.meas tran vdout1_28ck1050 FIND v(dout1_28) AT=530.025n

.meas tran vdout1_29ck1050 FIND v(dout1_29) AT=530.025n

.meas tran vdout1_30ck1050 FIND v(dout1_30) AT=530.025n

.meas tran vdout1_31ck1050 FIND v(dout1_31) AT=530.025n

.meas tran vdout1_32ck1050 FIND v(dout1_32) AT=530.025n

.meas tran vdout1_33ck1050 FIND v(dout1_33) AT=530.025n

.meas tran vdout1_34ck1050 FIND v(dout1_34) AT=530.025n

.meas tran vdout1_35ck1050 FIND v(dout1_35) AT=530.025n

.meas tran vdout1_36ck1050 FIND v(dout1_36) AT=530.025n

.meas tran vdout1_37ck1050 FIND v(dout1_37) AT=530.025n

.meas tran vdout1_38ck1050 FIND v(dout1_38) AT=530.025n

.meas tran vdout1_39ck1050 FIND v(dout1_39) AT=530.025n

.meas tran vdout1_40ck1050 FIND v(dout1_40) AT=530.025n

.meas tran vdout1_41ck1050 FIND v(dout1_41) AT=530.025n

.meas tran vdout1_42ck1050 FIND v(dout1_42) AT=530.025n

.meas tran vdout1_43ck1050 FIND v(dout1_43) AT=530.025n

.meas tran vdout1_44ck1050 FIND v(dout1_44) AT=530.025n

.meas tran vdout1_45ck1050 FIND v(dout1_45) AT=530.025n

.meas tran vdout1_46ck1050 FIND v(dout1_46) AT=530.025n

.meas tran vdout1_47ck1050 FIND v(dout1_47) AT=530.025n

.meas tran vdout1_48ck1050 FIND v(dout1_48) AT=530.025n

.meas tran vdout1_49ck1050 FIND v(dout1_49) AT=530.025n

.meas tran vdout1_50ck1050 FIND v(dout1_50) AT=530.025n

.meas tran vdout1_51ck1050 FIND v(dout1_51) AT=530.025n

.meas tran vdout1_52ck1050 FIND v(dout1_52) AT=530.025n

.meas tran vdout1_53ck1050 FIND v(dout1_53) AT=530.025n

.meas tran vdout1_54ck1050 FIND v(dout1_54) AT=530.025n

.meas tran vdout1_55ck1050 FIND v(dout1_55) AT=530.025n

.meas tran vdout1_56ck1050 FIND v(dout1_56) AT=530.025n

.meas tran vdout1_57ck1050 FIND v(dout1_57) AT=530.025n

.meas tran vdout1_58ck1050 FIND v(dout1_58) AT=530.025n

.meas tran vdout1_59ck1050 FIND v(dout1_59) AT=530.025n

.meas tran vdout1_60ck1050 FIND v(dout1_60) AT=530.025n

.meas tran vdout1_61ck1050 FIND v(dout1_61) AT=530.025n

.meas tran vdout1_62ck1050 FIND v(dout1_62) AT=530.025n

.meas tran vdout1_63ck1050 FIND v(dout1_63) AT=530.025n

.meas tran vdout1_64ck1050 FIND v(dout1_64) AT=530.025n

.meas tran vdout1_65ck1050 FIND v(dout1_65) AT=530.025n

.meas tran vdout1_66ck1050 FIND v(dout1_66) AT=530.025n

.meas tran vdout1_67ck1050 FIND v(dout1_67) AT=530.025n

.meas tran vdout1_68ck1050 FIND v(dout1_68) AT=530.025n

.meas tran vdout1_69ck1050 FIND v(dout1_69) AT=530.025n

.meas tran vdout1_70ck1050 FIND v(dout1_70) AT=530.025n

.meas tran vdout1_71ck1050 FIND v(dout1_71) AT=530.025n

.meas tran vdout1_72ck1050 FIND v(dout1_72) AT=530.025n

.meas tran vdout1_73ck1050 FIND v(dout1_73) AT=530.025n

.meas tran vdout1_74ck1050 FIND v(dout1_74) AT=530.025n

.meas tran vdout1_75ck1050 FIND v(dout1_75) AT=530.025n

.meas tran vdout1_76ck1050 FIND v(dout1_76) AT=530.025n

.meas tran vdout1_77ck1050 FIND v(dout1_77) AT=530.025n

.meas tran vdout1_78ck1050 FIND v(dout1_78) AT=530.025n

.meas tran vdout1_79ck1050 FIND v(dout1_79) AT=530.025n

.meas tran vdout1_80ck1050 FIND v(dout1_80) AT=530.025n

.meas tran vdout1_81ck1050 FIND v(dout1_81) AT=530.025n

.meas tran vdout1_82ck1050 FIND v(dout1_82) AT=530.025n

.meas tran vdout1_83ck1050 FIND v(dout1_83) AT=530.025n

.meas tran vdout1_84ck1050 FIND v(dout1_84) AT=530.025n

.meas tran vdout1_85ck1050 FIND v(dout1_85) AT=530.025n

.meas tran vdout1_86ck1050 FIND v(dout1_86) AT=530.025n

.meas tran vdout1_87ck1050 FIND v(dout1_87) AT=530.025n

.meas tran vdout1_88ck1050 FIND v(dout1_88) AT=530.025n

.meas tran vdout1_89ck1050 FIND v(dout1_89) AT=530.025n

.meas tran vdout1_90ck1050 FIND v(dout1_90) AT=530.025n

.meas tran vdout1_91ck1050 FIND v(dout1_91) AT=530.025n

.meas tran vdout1_92ck1050 FIND v(dout1_92) AT=530.025n

.meas tran vdout1_93ck1050 FIND v(dout1_93) AT=530.025n

.meas tran vdout1_94ck1050 FIND v(dout1_94) AT=530.025n

.meas tran vdout1_95ck1050 FIND v(dout1_95) AT=530.025n

.meas tran vdout1_96ck1050 FIND v(dout1_96) AT=530.025n

.meas tran vdout1_97ck1050 FIND v(dout1_97) AT=530.025n

.meas tran vdout1_98ck1050 FIND v(dout1_98) AT=530.025n

.meas tran vdout1_99ck1050 FIND v(dout1_99) AT=530.025n

.meas tran vdout1_100ck1050 FIND v(dout1_100) AT=530.025n

.meas tran vdout1_101ck1050 FIND v(dout1_101) AT=530.025n

.meas tran vdout1_102ck1050 FIND v(dout1_102) AT=530.025n

.meas tran vdout1_103ck1050 FIND v(dout1_103) AT=530.025n

.meas tran vdout1_104ck1050 FIND v(dout1_104) AT=530.025n

.meas tran vdout1_105ck1050 FIND v(dout1_105) AT=530.025n

.meas tran vdout1_106ck1050 FIND v(dout1_106) AT=530.025n

.meas tran vdout1_107ck1050 FIND v(dout1_107) AT=530.025n

.meas tran vdout1_108ck1050 FIND v(dout1_108) AT=530.025n

.meas tran vdout1_109ck1050 FIND v(dout1_109) AT=530.025n

.meas tran vdout1_110ck1050 FIND v(dout1_110) AT=530.025n

.meas tran vdout1_111ck1050 FIND v(dout1_111) AT=530.025n

.meas tran vdout1_112ck1050 FIND v(dout1_112) AT=530.025n

.meas tran vdout1_113ck1050 FIND v(dout1_113) AT=530.025n

.meas tran vdout1_114ck1050 FIND v(dout1_114) AT=530.025n

.meas tran vdout1_115ck1050 FIND v(dout1_115) AT=530.025n

.meas tran vdout1_116ck1050 FIND v(dout1_116) AT=530.025n

.meas tran vdout1_117ck1050 FIND v(dout1_117) AT=530.025n

.meas tran vdout1_118ck1050 FIND v(dout1_118) AT=530.025n

.meas tran vdout1_119ck1050 FIND v(dout1_119) AT=530.025n

.meas tran vdout1_120ck1050 FIND v(dout1_120) AT=530.025n

.meas tran vdout1_121ck1050 FIND v(dout1_121) AT=530.025n

.meas tran vdout1_122ck1050 FIND v(dout1_122) AT=530.025n

.meas tran vdout1_123ck1050 FIND v(dout1_123) AT=530.025n

.meas tran vdout1_124ck1050 FIND v(dout1_124) AT=530.025n

.meas tran vdout1_125ck1050 FIND v(dout1_125) AT=530.025n

.meas tran vdout1_126ck1050 FIND v(dout1_126) AT=530.025n

.meas tran vdout1_127ck1050 FIND v(dout1_127) AT=530.025n

.meas tran vdout1_0ck1080 FIND v(dout1_0) AT=545.025n

.meas tran vdout1_1ck1080 FIND v(dout1_1) AT=545.025n

.meas tran vdout1_2ck1080 FIND v(dout1_2) AT=545.025n

.meas tran vdout1_3ck1080 FIND v(dout1_3) AT=545.025n

.meas tran vdout1_4ck1080 FIND v(dout1_4) AT=545.025n

.meas tran vdout1_5ck1080 FIND v(dout1_5) AT=545.025n

.meas tran vdout1_6ck1080 FIND v(dout1_6) AT=545.025n

.meas tran vdout1_7ck1080 FIND v(dout1_7) AT=545.025n

.meas tran vdout1_8ck1080 FIND v(dout1_8) AT=545.025n

.meas tran vdout1_9ck1080 FIND v(dout1_9) AT=545.025n

.meas tran vdout1_10ck1080 FIND v(dout1_10) AT=545.025n

.meas tran vdout1_11ck1080 FIND v(dout1_11) AT=545.025n

.meas tran vdout1_12ck1080 FIND v(dout1_12) AT=545.025n

.meas tran vdout1_13ck1080 FIND v(dout1_13) AT=545.025n

.meas tran vdout1_14ck1080 FIND v(dout1_14) AT=545.025n

.meas tran vdout1_15ck1080 FIND v(dout1_15) AT=545.025n

.meas tran vdout1_16ck1080 FIND v(dout1_16) AT=545.025n

.meas tran vdout1_17ck1080 FIND v(dout1_17) AT=545.025n

.meas tran vdout1_18ck1080 FIND v(dout1_18) AT=545.025n

.meas tran vdout1_19ck1080 FIND v(dout1_19) AT=545.025n

.meas tran vdout1_20ck1080 FIND v(dout1_20) AT=545.025n

.meas tran vdout1_21ck1080 FIND v(dout1_21) AT=545.025n

.meas tran vdout1_22ck1080 FIND v(dout1_22) AT=545.025n

.meas tran vdout1_23ck1080 FIND v(dout1_23) AT=545.025n

.meas tran vdout1_24ck1080 FIND v(dout1_24) AT=545.025n

.meas tran vdout1_25ck1080 FIND v(dout1_25) AT=545.025n

.meas tran vdout1_26ck1080 FIND v(dout1_26) AT=545.025n

.meas tran vdout1_27ck1080 FIND v(dout1_27) AT=545.025n

.meas tran vdout1_28ck1080 FIND v(dout1_28) AT=545.025n

.meas tran vdout1_29ck1080 FIND v(dout1_29) AT=545.025n

.meas tran vdout1_30ck1080 FIND v(dout1_30) AT=545.025n

.meas tran vdout1_31ck1080 FIND v(dout1_31) AT=545.025n

.meas tran vdout1_32ck1080 FIND v(dout1_32) AT=545.025n

.meas tran vdout1_33ck1080 FIND v(dout1_33) AT=545.025n

.meas tran vdout1_34ck1080 FIND v(dout1_34) AT=545.025n

.meas tran vdout1_35ck1080 FIND v(dout1_35) AT=545.025n

.meas tran vdout1_36ck1080 FIND v(dout1_36) AT=545.025n

.meas tran vdout1_37ck1080 FIND v(dout1_37) AT=545.025n

.meas tran vdout1_38ck1080 FIND v(dout1_38) AT=545.025n

.meas tran vdout1_39ck1080 FIND v(dout1_39) AT=545.025n

.meas tran vdout1_40ck1080 FIND v(dout1_40) AT=545.025n

.meas tran vdout1_41ck1080 FIND v(dout1_41) AT=545.025n

.meas tran vdout1_42ck1080 FIND v(dout1_42) AT=545.025n

.meas tran vdout1_43ck1080 FIND v(dout1_43) AT=545.025n

.meas tran vdout1_44ck1080 FIND v(dout1_44) AT=545.025n

.meas tran vdout1_45ck1080 FIND v(dout1_45) AT=545.025n

.meas tran vdout1_46ck1080 FIND v(dout1_46) AT=545.025n

.meas tran vdout1_47ck1080 FIND v(dout1_47) AT=545.025n

.meas tran vdout1_48ck1080 FIND v(dout1_48) AT=545.025n

.meas tran vdout1_49ck1080 FIND v(dout1_49) AT=545.025n

.meas tran vdout1_50ck1080 FIND v(dout1_50) AT=545.025n

.meas tran vdout1_51ck1080 FIND v(dout1_51) AT=545.025n

.meas tran vdout1_52ck1080 FIND v(dout1_52) AT=545.025n

.meas tran vdout1_53ck1080 FIND v(dout1_53) AT=545.025n

.meas tran vdout1_54ck1080 FIND v(dout1_54) AT=545.025n

.meas tran vdout1_55ck1080 FIND v(dout1_55) AT=545.025n

.meas tran vdout1_56ck1080 FIND v(dout1_56) AT=545.025n

.meas tran vdout1_57ck1080 FIND v(dout1_57) AT=545.025n

.meas tran vdout1_58ck1080 FIND v(dout1_58) AT=545.025n

.meas tran vdout1_59ck1080 FIND v(dout1_59) AT=545.025n

.meas tran vdout1_60ck1080 FIND v(dout1_60) AT=545.025n

.meas tran vdout1_61ck1080 FIND v(dout1_61) AT=545.025n

.meas tran vdout1_62ck1080 FIND v(dout1_62) AT=545.025n

.meas tran vdout1_63ck1080 FIND v(dout1_63) AT=545.025n

.meas tran vdout1_64ck1080 FIND v(dout1_64) AT=545.025n

.meas tran vdout1_65ck1080 FIND v(dout1_65) AT=545.025n

.meas tran vdout1_66ck1080 FIND v(dout1_66) AT=545.025n

.meas tran vdout1_67ck1080 FIND v(dout1_67) AT=545.025n

.meas tran vdout1_68ck1080 FIND v(dout1_68) AT=545.025n

.meas tran vdout1_69ck1080 FIND v(dout1_69) AT=545.025n

.meas tran vdout1_70ck1080 FIND v(dout1_70) AT=545.025n

.meas tran vdout1_71ck1080 FIND v(dout1_71) AT=545.025n

.meas tran vdout1_72ck1080 FIND v(dout1_72) AT=545.025n

.meas tran vdout1_73ck1080 FIND v(dout1_73) AT=545.025n

.meas tran vdout1_74ck1080 FIND v(dout1_74) AT=545.025n

.meas tran vdout1_75ck1080 FIND v(dout1_75) AT=545.025n

.meas tran vdout1_76ck1080 FIND v(dout1_76) AT=545.025n

.meas tran vdout1_77ck1080 FIND v(dout1_77) AT=545.025n

.meas tran vdout1_78ck1080 FIND v(dout1_78) AT=545.025n

.meas tran vdout1_79ck1080 FIND v(dout1_79) AT=545.025n

.meas tran vdout1_80ck1080 FIND v(dout1_80) AT=545.025n

.meas tran vdout1_81ck1080 FIND v(dout1_81) AT=545.025n

.meas tran vdout1_82ck1080 FIND v(dout1_82) AT=545.025n

.meas tran vdout1_83ck1080 FIND v(dout1_83) AT=545.025n

.meas tran vdout1_84ck1080 FIND v(dout1_84) AT=545.025n

.meas tran vdout1_85ck1080 FIND v(dout1_85) AT=545.025n

.meas tran vdout1_86ck1080 FIND v(dout1_86) AT=545.025n

.meas tran vdout1_87ck1080 FIND v(dout1_87) AT=545.025n

.meas tran vdout1_88ck1080 FIND v(dout1_88) AT=545.025n

.meas tran vdout1_89ck1080 FIND v(dout1_89) AT=545.025n

.meas tran vdout1_90ck1080 FIND v(dout1_90) AT=545.025n

.meas tran vdout1_91ck1080 FIND v(dout1_91) AT=545.025n

.meas tran vdout1_92ck1080 FIND v(dout1_92) AT=545.025n

.meas tran vdout1_93ck1080 FIND v(dout1_93) AT=545.025n

.meas tran vdout1_94ck1080 FIND v(dout1_94) AT=545.025n

.meas tran vdout1_95ck1080 FIND v(dout1_95) AT=545.025n

.meas tran vdout1_96ck1080 FIND v(dout1_96) AT=545.025n

.meas tran vdout1_97ck1080 FIND v(dout1_97) AT=545.025n

.meas tran vdout1_98ck1080 FIND v(dout1_98) AT=545.025n

.meas tran vdout1_99ck1080 FIND v(dout1_99) AT=545.025n

.meas tran vdout1_100ck1080 FIND v(dout1_100) AT=545.025n

.meas tran vdout1_101ck1080 FIND v(dout1_101) AT=545.025n

.meas tran vdout1_102ck1080 FIND v(dout1_102) AT=545.025n

.meas tran vdout1_103ck1080 FIND v(dout1_103) AT=545.025n

.meas tran vdout1_104ck1080 FIND v(dout1_104) AT=545.025n

.meas tran vdout1_105ck1080 FIND v(dout1_105) AT=545.025n

.meas tran vdout1_106ck1080 FIND v(dout1_106) AT=545.025n

.meas tran vdout1_107ck1080 FIND v(dout1_107) AT=545.025n

.meas tran vdout1_108ck1080 FIND v(dout1_108) AT=545.025n

.meas tran vdout1_109ck1080 FIND v(dout1_109) AT=545.025n

.meas tran vdout1_110ck1080 FIND v(dout1_110) AT=545.025n

.meas tran vdout1_111ck1080 FIND v(dout1_111) AT=545.025n

.meas tran vdout1_112ck1080 FIND v(dout1_112) AT=545.025n

.meas tran vdout1_113ck1080 FIND v(dout1_113) AT=545.025n

.meas tran vdout1_114ck1080 FIND v(dout1_114) AT=545.025n

.meas tran vdout1_115ck1080 FIND v(dout1_115) AT=545.025n

.meas tran vdout1_116ck1080 FIND v(dout1_116) AT=545.025n

.meas tran vdout1_117ck1080 FIND v(dout1_117) AT=545.025n

.meas tran vdout1_118ck1080 FIND v(dout1_118) AT=545.025n

.meas tran vdout1_119ck1080 FIND v(dout1_119) AT=545.025n

.meas tran vdout1_120ck1080 FIND v(dout1_120) AT=545.025n

.meas tran vdout1_121ck1080 FIND v(dout1_121) AT=545.025n

.meas tran vdout1_122ck1080 FIND v(dout1_122) AT=545.025n

.meas tran vdout1_123ck1080 FIND v(dout1_123) AT=545.025n

.meas tran vdout1_124ck1080 FIND v(dout1_124) AT=545.025n

.meas tran vdout1_125ck1080 FIND v(dout1_125) AT=545.025n

.meas tran vdout1_126ck1080 FIND v(dout1_126) AT=545.025n

.meas tran vdout1_127ck1080 FIND v(dout1_127) AT=545.025n

.meas tran vdout1_0ck1100 FIND v(dout1_0) AT=555.025n

.meas tran vdout1_1ck1100 FIND v(dout1_1) AT=555.025n

.meas tran vdout1_2ck1100 FIND v(dout1_2) AT=555.025n

.meas tran vdout1_3ck1100 FIND v(dout1_3) AT=555.025n

.meas tran vdout1_4ck1100 FIND v(dout1_4) AT=555.025n

.meas tran vdout1_5ck1100 FIND v(dout1_5) AT=555.025n

.meas tran vdout1_6ck1100 FIND v(dout1_6) AT=555.025n

.meas tran vdout1_7ck1100 FIND v(dout1_7) AT=555.025n

.meas tran vdout1_8ck1100 FIND v(dout1_8) AT=555.025n

.meas tran vdout1_9ck1100 FIND v(dout1_9) AT=555.025n

.meas tran vdout1_10ck1100 FIND v(dout1_10) AT=555.025n

.meas tran vdout1_11ck1100 FIND v(dout1_11) AT=555.025n

.meas tran vdout1_12ck1100 FIND v(dout1_12) AT=555.025n

.meas tran vdout1_13ck1100 FIND v(dout1_13) AT=555.025n

.meas tran vdout1_14ck1100 FIND v(dout1_14) AT=555.025n

.meas tran vdout1_15ck1100 FIND v(dout1_15) AT=555.025n

.meas tran vdout1_16ck1100 FIND v(dout1_16) AT=555.025n

.meas tran vdout1_17ck1100 FIND v(dout1_17) AT=555.025n

.meas tran vdout1_18ck1100 FIND v(dout1_18) AT=555.025n

.meas tran vdout1_19ck1100 FIND v(dout1_19) AT=555.025n

.meas tran vdout1_20ck1100 FIND v(dout1_20) AT=555.025n

.meas tran vdout1_21ck1100 FIND v(dout1_21) AT=555.025n

.meas tran vdout1_22ck1100 FIND v(dout1_22) AT=555.025n

.meas tran vdout1_23ck1100 FIND v(dout1_23) AT=555.025n

.meas tran vdout1_24ck1100 FIND v(dout1_24) AT=555.025n

.meas tran vdout1_25ck1100 FIND v(dout1_25) AT=555.025n

.meas tran vdout1_26ck1100 FIND v(dout1_26) AT=555.025n

.meas tran vdout1_27ck1100 FIND v(dout1_27) AT=555.025n

.meas tran vdout1_28ck1100 FIND v(dout1_28) AT=555.025n

.meas tran vdout1_29ck1100 FIND v(dout1_29) AT=555.025n

.meas tran vdout1_30ck1100 FIND v(dout1_30) AT=555.025n

.meas tran vdout1_31ck1100 FIND v(dout1_31) AT=555.025n

.meas tran vdout1_32ck1100 FIND v(dout1_32) AT=555.025n

.meas tran vdout1_33ck1100 FIND v(dout1_33) AT=555.025n

.meas tran vdout1_34ck1100 FIND v(dout1_34) AT=555.025n

.meas tran vdout1_35ck1100 FIND v(dout1_35) AT=555.025n

.meas tran vdout1_36ck1100 FIND v(dout1_36) AT=555.025n

.meas tran vdout1_37ck1100 FIND v(dout1_37) AT=555.025n

.meas tran vdout1_38ck1100 FIND v(dout1_38) AT=555.025n

.meas tran vdout1_39ck1100 FIND v(dout1_39) AT=555.025n

.meas tran vdout1_40ck1100 FIND v(dout1_40) AT=555.025n

.meas tran vdout1_41ck1100 FIND v(dout1_41) AT=555.025n

.meas tran vdout1_42ck1100 FIND v(dout1_42) AT=555.025n

.meas tran vdout1_43ck1100 FIND v(dout1_43) AT=555.025n

.meas tran vdout1_44ck1100 FIND v(dout1_44) AT=555.025n

.meas tran vdout1_45ck1100 FIND v(dout1_45) AT=555.025n

.meas tran vdout1_46ck1100 FIND v(dout1_46) AT=555.025n

.meas tran vdout1_47ck1100 FIND v(dout1_47) AT=555.025n

.meas tran vdout1_48ck1100 FIND v(dout1_48) AT=555.025n

.meas tran vdout1_49ck1100 FIND v(dout1_49) AT=555.025n

.meas tran vdout1_50ck1100 FIND v(dout1_50) AT=555.025n

.meas tran vdout1_51ck1100 FIND v(dout1_51) AT=555.025n

.meas tran vdout1_52ck1100 FIND v(dout1_52) AT=555.025n

.meas tran vdout1_53ck1100 FIND v(dout1_53) AT=555.025n

.meas tran vdout1_54ck1100 FIND v(dout1_54) AT=555.025n

.meas tran vdout1_55ck1100 FIND v(dout1_55) AT=555.025n

.meas tran vdout1_56ck1100 FIND v(dout1_56) AT=555.025n

.meas tran vdout1_57ck1100 FIND v(dout1_57) AT=555.025n

.meas tran vdout1_58ck1100 FIND v(dout1_58) AT=555.025n

.meas tran vdout1_59ck1100 FIND v(dout1_59) AT=555.025n

.meas tran vdout1_60ck1100 FIND v(dout1_60) AT=555.025n

.meas tran vdout1_61ck1100 FIND v(dout1_61) AT=555.025n

.meas tran vdout1_62ck1100 FIND v(dout1_62) AT=555.025n

.meas tran vdout1_63ck1100 FIND v(dout1_63) AT=555.025n

.meas tran vdout1_64ck1100 FIND v(dout1_64) AT=555.025n

.meas tran vdout1_65ck1100 FIND v(dout1_65) AT=555.025n

.meas tran vdout1_66ck1100 FIND v(dout1_66) AT=555.025n

.meas tran vdout1_67ck1100 FIND v(dout1_67) AT=555.025n

.meas tran vdout1_68ck1100 FIND v(dout1_68) AT=555.025n

.meas tran vdout1_69ck1100 FIND v(dout1_69) AT=555.025n

.meas tran vdout1_70ck1100 FIND v(dout1_70) AT=555.025n

.meas tran vdout1_71ck1100 FIND v(dout1_71) AT=555.025n

.meas tran vdout1_72ck1100 FIND v(dout1_72) AT=555.025n

.meas tran vdout1_73ck1100 FIND v(dout1_73) AT=555.025n

.meas tran vdout1_74ck1100 FIND v(dout1_74) AT=555.025n

.meas tran vdout1_75ck1100 FIND v(dout1_75) AT=555.025n

.meas tran vdout1_76ck1100 FIND v(dout1_76) AT=555.025n

.meas tran vdout1_77ck1100 FIND v(dout1_77) AT=555.025n

.meas tran vdout1_78ck1100 FIND v(dout1_78) AT=555.025n

.meas tran vdout1_79ck1100 FIND v(dout1_79) AT=555.025n

.meas tran vdout1_80ck1100 FIND v(dout1_80) AT=555.025n

.meas tran vdout1_81ck1100 FIND v(dout1_81) AT=555.025n

.meas tran vdout1_82ck1100 FIND v(dout1_82) AT=555.025n

.meas tran vdout1_83ck1100 FIND v(dout1_83) AT=555.025n

.meas tran vdout1_84ck1100 FIND v(dout1_84) AT=555.025n

.meas tran vdout1_85ck1100 FIND v(dout1_85) AT=555.025n

.meas tran vdout1_86ck1100 FIND v(dout1_86) AT=555.025n

.meas tran vdout1_87ck1100 FIND v(dout1_87) AT=555.025n

.meas tran vdout1_88ck1100 FIND v(dout1_88) AT=555.025n

.meas tran vdout1_89ck1100 FIND v(dout1_89) AT=555.025n

.meas tran vdout1_90ck1100 FIND v(dout1_90) AT=555.025n

.meas tran vdout1_91ck1100 FIND v(dout1_91) AT=555.025n

.meas tran vdout1_92ck1100 FIND v(dout1_92) AT=555.025n

.meas tran vdout1_93ck1100 FIND v(dout1_93) AT=555.025n

.meas tran vdout1_94ck1100 FIND v(dout1_94) AT=555.025n

.meas tran vdout1_95ck1100 FIND v(dout1_95) AT=555.025n

.meas tran vdout1_96ck1100 FIND v(dout1_96) AT=555.025n

.meas tran vdout1_97ck1100 FIND v(dout1_97) AT=555.025n

.meas tran vdout1_98ck1100 FIND v(dout1_98) AT=555.025n

.meas tran vdout1_99ck1100 FIND v(dout1_99) AT=555.025n

.meas tran vdout1_100ck1100 FIND v(dout1_100) AT=555.025n

.meas tran vdout1_101ck1100 FIND v(dout1_101) AT=555.025n

.meas tran vdout1_102ck1100 FIND v(dout1_102) AT=555.025n

.meas tran vdout1_103ck1100 FIND v(dout1_103) AT=555.025n

.meas tran vdout1_104ck1100 FIND v(dout1_104) AT=555.025n

.meas tran vdout1_105ck1100 FIND v(dout1_105) AT=555.025n

.meas tran vdout1_106ck1100 FIND v(dout1_106) AT=555.025n

.meas tran vdout1_107ck1100 FIND v(dout1_107) AT=555.025n

.meas tran vdout1_108ck1100 FIND v(dout1_108) AT=555.025n

.meas tran vdout1_109ck1100 FIND v(dout1_109) AT=555.025n

.meas tran vdout1_110ck1100 FIND v(dout1_110) AT=555.025n

.meas tran vdout1_111ck1100 FIND v(dout1_111) AT=555.025n

.meas tran vdout1_112ck1100 FIND v(dout1_112) AT=555.025n

.meas tran vdout1_113ck1100 FIND v(dout1_113) AT=555.025n

.meas tran vdout1_114ck1100 FIND v(dout1_114) AT=555.025n

.meas tran vdout1_115ck1100 FIND v(dout1_115) AT=555.025n

.meas tran vdout1_116ck1100 FIND v(dout1_116) AT=555.025n

.meas tran vdout1_117ck1100 FIND v(dout1_117) AT=555.025n

.meas tran vdout1_118ck1100 FIND v(dout1_118) AT=555.025n

.meas tran vdout1_119ck1100 FIND v(dout1_119) AT=555.025n

.meas tran vdout1_120ck1100 FIND v(dout1_120) AT=555.025n

.meas tran vdout1_121ck1100 FIND v(dout1_121) AT=555.025n

.meas tran vdout1_122ck1100 FIND v(dout1_122) AT=555.025n

.meas tran vdout1_123ck1100 FIND v(dout1_123) AT=555.025n

.meas tran vdout1_124ck1100 FIND v(dout1_124) AT=555.025n

.meas tran vdout1_125ck1100 FIND v(dout1_125) AT=555.025n

.meas tran vdout1_126ck1100 FIND v(dout1_126) AT=555.025n

.meas tran vdout1_127ck1100 FIND v(dout1_127) AT=555.025n

.meas tran vdout1_0ck1120 FIND v(dout1_0) AT=565.025n

.meas tran vdout1_1ck1120 FIND v(dout1_1) AT=565.025n

.meas tran vdout1_2ck1120 FIND v(dout1_2) AT=565.025n

.meas tran vdout1_3ck1120 FIND v(dout1_3) AT=565.025n

.meas tran vdout1_4ck1120 FIND v(dout1_4) AT=565.025n

.meas tran vdout1_5ck1120 FIND v(dout1_5) AT=565.025n

.meas tran vdout1_6ck1120 FIND v(dout1_6) AT=565.025n

.meas tran vdout1_7ck1120 FIND v(dout1_7) AT=565.025n

.meas tran vdout1_8ck1120 FIND v(dout1_8) AT=565.025n

.meas tran vdout1_9ck1120 FIND v(dout1_9) AT=565.025n

.meas tran vdout1_10ck1120 FIND v(dout1_10) AT=565.025n

.meas tran vdout1_11ck1120 FIND v(dout1_11) AT=565.025n

.meas tran vdout1_12ck1120 FIND v(dout1_12) AT=565.025n

.meas tran vdout1_13ck1120 FIND v(dout1_13) AT=565.025n

.meas tran vdout1_14ck1120 FIND v(dout1_14) AT=565.025n

.meas tran vdout1_15ck1120 FIND v(dout1_15) AT=565.025n

.meas tran vdout1_16ck1120 FIND v(dout1_16) AT=565.025n

.meas tran vdout1_17ck1120 FIND v(dout1_17) AT=565.025n

.meas tran vdout1_18ck1120 FIND v(dout1_18) AT=565.025n

.meas tran vdout1_19ck1120 FIND v(dout1_19) AT=565.025n

.meas tran vdout1_20ck1120 FIND v(dout1_20) AT=565.025n

.meas tran vdout1_21ck1120 FIND v(dout1_21) AT=565.025n

.meas tran vdout1_22ck1120 FIND v(dout1_22) AT=565.025n

.meas tran vdout1_23ck1120 FIND v(dout1_23) AT=565.025n

.meas tran vdout1_24ck1120 FIND v(dout1_24) AT=565.025n

.meas tran vdout1_25ck1120 FIND v(dout1_25) AT=565.025n

.meas tran vdout1_26ck1120 FIND v(dout1_26) AT=565.025n

.meas tran vdout1_27ck1120 FIND v(dout1_27) AT=565.025n

.meas tran vdout1_28ck1120 FIND v(dout1_28) AT=565.025n

.meas tran vdout1_29ck1120 FIND v(dout1_29) AT=565.025n

.meas tran vdout1_30ck1120 FIND v(dout1_30) AT=565.025n

.meas tran vdout1_31ck1120 FIND v(dout1_31) AT=565.025n

.meas tran vdout1_32ck1120 FIND v(dout1_32) AT=565.025n

.meas tran vdout1_33ck1120 FIND v(dout1_33) AT=565.025n

.meas tran vdout1_34ck1120 FIND v(dout1_34) AT=565.025n

.meas tran vdout1_35ck1120 FIND v(dout1_35) AT=565.025n

.meas tran vdout1_36ck1120 FIND v(dout1_36) AT=565.025n

.meas tran vdout1_37ck1120 FIND v(dout1_37) AT=565.025n

.meas tran vdout1_38ck1120 FIND v(dout1_38) AT=565.025n

.meas tran vdout1_39ck1120 FIND v(dout1_39) AT=565.025n

.meas tran vdout1_40ck1120 FIND v(dout1_40) AT=565.025n

.meas tran vdout1_41ck1120 FIND v(dout1_41) AT=565.025n

.meas tran vdout1_42ck1120 FIND v(dout1_42) AT=565.025n

.meas tran vdout1_43ck1120 FIND v(dout1_43) AT=565.025n

.meas tran vdout1_44ck1120 FIND v(dout1_44) AT=565.025n

.meas tran vdout1_45ck1120 FIND v(dout1_45) AT=565.025n

.meas tran vdout1_46ck1120 FIND v(dout1_46) AT=565.025n

.meas tran vdout1_47ck1120 FIND v(dout1_47) AT=565.025n

.meas tran vdout1_48ck1120 FIND v(dout1_48) AT=565.025n

.meas tran vdout1_49ck1120 FIND v(dout1_49) AT=565.025n

.meas tran vdout1_50ck1120 FIND v(dout1_50) AT=565.025n

.meas tran vdout1_51ck1120 FIND v(dout1_51) AT=565.025n

.meas tran vdout1_52ck1120 FIND v(dout1_52) AT=565.025n

.meas tran vdout1_53ck1120 FIND v(dout1_53) AT=565.025n

.meas tran vdout1_54ck1120 FIND v(dout1_54) AT=565.025n

.meas tran vdout1_55ck1120 FIND v(dout1_55) AT=565.025n

.meas tran vdout1_56ck1120 FIND v(dout1_56) AT=565.025n

.meas tran vdout1_57ck1120 FIND v(dout1_57) AT=565.025n

.meas tran vdout1_58ck1120 FIND v(dout1_58) AT=565.025n

.meas tran vdout1_59ck1120 FIND v(dout1_59) AT=565.025n

.meas tran vdout1_60ck1120 FIND v(dout1_60) AT=565.025n

.meas tran vdout1_61ck1120 FIND v(dout1_61) AT=565.025n

.meas tran vdout1_62ck1120 FIND v(dout1_62) AT=565.025n

.meas tran vdout1_63ck1120 FIND v(dout1_63) AT=565.025n

.meas tran vdout1_64ck1120 FIND v(dout1_64) AT=565.025n

.meas tran vdout1_65ck1120 FIND v(dout1_65) AT=565.025n

.meas tran vdout1_66ck1120 FIND v(dout1_66) AT=565.025n

.meas tran vdout1_67ck1120 FIND v(dout1_67) AT=565.025n

.meas tran vdout1_68ck1120 FIND v(dout1_68) AT=565.025n

.meas tran vdout1_69ck1120 FIND v(dout1_69) AT=565.025n

.meas tran vdout1_70ck1120 FIND v(dout1_70) AT=565.025n

.meas tran vdout1_71ck1120 FIND v(dout1_71) AT=565.025n

.meas tran vdout1_72ck1120 FIND v(dout1_72) AT=565.025n

.meas tran vdout1_73ck1120 FIND v(dout1_73) AT=565.025n

.meas tran vdout1_74ck1120 FIND v(dout1_74) AT=565.025n

.meas tran vdout1_75ck1120 FIND v(dout1_75) AT=565.025n

.meas tran vdout1_76ck1120 FIND v(dout1_76) AT=565.025n

.meas tran vdout1_77ck1120 FIND v(dout1_77) AT=565.025n

.meas tran vdout1_78ck1120 FIND v(dout1_78) AT=565.025n

.meas tran vdout1_79ck1120 FIND v(dout1_79) AT=565.025n

.meas tran vdout1_80ck1120 FIND v(dout1_80) AT=565.025n

.meas tran vdout1_81ck1120 FIND v(dout1_81) AT=565.025n

.meas tran vdout1_82ck1120 FIND v(dout1_82) AT=565.025n

.meas tran vdout1_83ck1120 FIND v(dout1_83) AT=565.025n

.meas tran vdout1_84ck1120 FIND v(dout1_84) AT=565.025n

.meas tran vdout1_85ck1120 FIND v(dout1_85) AT=565.025n

.meas tran vdout1_86ck1120 FIND v(dout1_86) AT=565.025n

.meas tran vdout1_87ck1120 FIND v(dout1_87) AT=565.025n

.meas tran vdout1_88ck1120 FIND v(dout1_88) AT=565.025n

.meas tran vdout1_89ck1120 FIND v(dout1_89) AT=565.025n

.meas tran vdout1_90ck1120 FIND v(dout1_90) AT=565.025n

.meas tran vdout1_91ck1120 FIND v(dout1_91) AT=565.025n

.meas tran vdout1_92ck1120 FIND v(dout1_92) AT=565.025n

.meas tran vdout1_93ck1120 FIND v(dout1_93) AT=565.025n

.meas tran vdout1_94ck1120 FIND v(dout1_94) AT=565.025n

.meas tran vdout1_95ck1120 FIND v(dout1_95) AT=565.025n

.meas tran vdout1_96ck1120 FIND v(dout1_96) AT=565.025n

.meas tran vdout1_97ck1120 FIND v(dout1_97) AT=565.025n

.meas tran vdout1_98ck1120 FIND v(dout1_98) AT=565.025n

.meas tran vdout1_99ck1120 FIND v(dout1_99) AT=565.025n

.meas tran vdout1_100ck1120 FIND v(dout1_100) AT=565.025n

.meas tran vdout1_101ck1120 FIND v(dout1_101) AT=565.025n

.meas tran vdout1_102ck1120 FIND v(dout1_102) AT=565.025n

.meas tran vdout1_103ck1120 FIND v(dout1_103) AT=565.025n

.meas tran vdout1_104ck1120 FIND v(dout1_104) AT=565.025n

.meas tran vdout1_105ck1120 FIND v(dout1_105) AT=565.025n

.meas tran vdout1_106ck1120 FIND v(dout1_106) AT=565.025n

.meas tran vdout1_107ck1120 FIND v(dout1_107) AT=565.025n

.meas tran vdout1_108ck1120 FIND v(dout1_108) AT=565.025n

.meas tran vdout1_109ck1120 FIND v(dout1_109) AT=565.025n

.meas tran vdout1_110ck1120 FIND v(dout1_110) AT=565.025n

.meas tran vdout1_111ck1120 FIND v(dout1_111) AT=565.025n

.meas tran vdout1_112ck1120 FIND v(dout1_112) AT=565.025n

.meas tran vdout1_113ck1120 FIND v(dout1_113) AT=565.025n

.meas tran vdout1_114ck1120 FIND v(dout1_114) AT=565.025n

.meas tran vdout1_115ck1120 FIND v(dout1_115) AT=565.025n

.meas tran vdout1_116ck1120 FIND v(dout1_116) AT=565.025n

.meas tran vdout1_117ck1120 FIND v(dout1_117) AT=565.025n

.meas tran vdout1_118ck1120 FIND v(dout1_118) AT=565.025n

.meas tran vdout1_119ck1120 FIND v(dout1_119) AT=565.025n

.meas tran vdout1_120ck1120 FIND v(dout1_120) AT=565.025n

.meas tran vdout1_121ck1120 FIND v(dout1_121) AT=565.025n

.meas tran vdout1_122ck1120 FIND v(dout1_122) AT=565.025n

.meas tran vdout1_123ck1120 FIND v(dout1_123) AT=565.025n

.meas tran vdout1_124ck1120 FIND v(dout1_124) AT=565.025n

.meas tran vdout1_125ck1120 FIND v(dout1_125) AT=565.025n

.meas tran vdout1_126ck1120 FIND v(dout1_126) AT=565.025n

.meas tran vdout1_127ck1120 FIND v(dout1_127) AT=565.025n

.meas tran vdout1_0ck1170 FIND v(dout1_0) AT=590.025n

.meas tran vdout1_1ck1170 FIND v(dout1_1) AT=590.025n

.meas tran vdout1_2ck1170 FIND v(dout1_2) AT=590.025n

.meas tran vdout1_3ck1170 FIND v(dout1_3) AT=590.025n

.meas tran vdout1_4ck1170 FIND v(dout1_4) AT=590.025n

.meas tran vdout1_5ck1170 FIND v(dout1_5) AT=590.025n

.meas tran vdout1_6ck1170 FIND v(dout1_6) AT=590.025n

.meas tran vdout1_7ck1170 FIND v(dout1_7) AT=590.025n

.meas tran vdout1_8ck1170 FIND v(dout1_8) AT=590.025n

.meas tran vdout1_9ck1170 FIND v(dout1_9) AT=590.025n

.meas tran vdout1_10ck1170 FIND v(dout1_10) AT=590.025n

.meas tran vdout1_11ck1170 FIND v(dout1_11) AT=590.025n

.meas tran vdout1_12ck1170 FIND v(dout1_12) AT=590.025n

.meas tran vdout1_13ck1170 FIND v(dout1_13) AT=590.025n

.meas tran vdout1_14ck1170 FIND v(dout1_14) AT=590.025n

.meas tran vdout1_15ck1170 FIND v(dout1_15) AT=590.025n

.meas tran vdout1_16ck1170 FIND v(dout1_16) AT=590.025n

.meas tran vdout1_17ck1170 FIND v(dout1_17) AT=590.025n

.meas tran vdout1_18ck1170 FIND v(dout1_18) AT=590.025n

.meas tran vdout1_19ck1170 FIND v(dout1_19) AT=590.025n

.meas tran vdout1_20ck1170 FIND v(dout1_20) AT=590.025n

.meas tran vdout1_21ck1170 FIND v(dout1_21) AT=590.025n

.meas tran vdout1_22ck1170 FIND v(dout1_22) AT=590.025n

.meas tran vdout1_23ck1170 FIND v(dout1_23) AT=590.025n

.meas tran vdout1_24ck1170 FIND v(dout1_24) AT=590.025n

.meas tran vdout1_25ck1170 FIND v(dout1_25) AT=590.025n

.meas tran vdout1_26ck1170 FIND v(dout1_26) AT=590.025n

.meas tran vdout1_27ck1170 FIND v(dout1_27) AT=590.025n

.meas tran vdout1_28ck1170 FIND v(dout1_28) AT=590.025n

.meas tran vdout1_29ck1170 FIND v(dout1_29) AT=590.025n

.meas tran vdout1_30ck1170 FIND v(dout1_30) AT=590.025n

.meas tran vdout1_31ck1170 FIND v(dout1_31) AT=590.025n

.meas tran vdout1_32ck1170 FIND v(dout1_32) AT=590.025n

.meas tran vdout1_33ck1170 FIND v(dout1_33) AT=590.025n

.meas tran vdout1_34ck1170 FIND v(dout1_34) AT=590.025n

.meas tran vdout1_35ck1170 FIND v(dout1_35) AT=590.025n

.meas tran vdout1_36ck1170 FIND v(dout1_36) AT=590.025n

.meas tran vdout1_37ck1170 FIND v(dout1_37) AT=590.025n

.meas tran vdout1_38ck1170 FIND v(dout1_38) AT=590.025n

.meas tran vdout1_39ck1170 FIND v(dout1_39) AT=590.025n

.meas tran vdout1_40ck1170 FIND v(dout1_40) AT=590.025n

.meas tran vdout1_41ck1170 FIND v(dout1_41) AT=590.025n

.meas tran vdout1_42ck1170 FIND v(dout1_42) AT=590.025n

.meas tran vdout1_43ck1170 FIND v(dout1_43) AT=590.025n

.meas tran vdout1_44ck1170 FIND v(dout1_44) AT=590.025n

.meas tran vdout1_45ck1170 FIND v(dout1_45) AT=590.025n

.meas tran vdout1_46ck1170 FIND v(dout1_46) AT=590.025n

.meas tran vdout1_47ck1170 FIND v(dout1_47) AT=590.025n

.meas tran vdout1_48ck1170 FIND v(dout1_48) AT=590.025n

.meas tran vdout1_49ck1170 FIND v(dout1_49) AT=590.025n

.meas tran vdout1_50ck1170 FIND v(dout1_50) AT=590.025n

.meas tran vdout1_51ck1170 FIND v(dout1_51) AT=590.025n

.meas tran vdout1_52ck1170 FIND v(dout1_52) AT=590.025n

.meas tran vdout1_53ck1170 FIND v(dout1_53) AT=590.025n

.meas tran vdout1_54ck1170 FIND v(dout1_54) AT=590.025n

.meas tran vdout1_55ck1170 FIND v(dout1_55) AT=590.025n

.meas tran vdout1_56ck1170 FIND v(dout1_56) AT=590.025n

.meas tran vdout1_57ck1170 FIND v(dout1_57) AT=590.025n

.meas tran vdout1_58ck1170 FIND v(dout1_58) AT=590.025n

.meas tran vdout1_59ck1170 FIND v(dout1_59) AT=590.025n

.meas tran vdout1_60ck1170 FIND v(dout1_60) AT=590.025n

.meas tran vdout1_61ck1170 FIND v(dout1_61) AT=590.025n

.meas tran vdout1_62ck1170 FIND v(dout1_62) AT=590.025n

.meas tran vdout1_63ck1170 FIND v(dout1_63) AT=590.025n

.meas tran vdout1_64ck1170 FIND v(dout1_64) AT=590.025n

.meas tran vdout1_65ck1170 FIND v(dout1_65) AT=590.025n

.meas tran vdout1_66ck1170 FIND v(dout1_66) AT=590.025n

.meas tran vdout1_67ck1170 FIND v(dout1_67) AT=590.025n

.meas tran vdout1_68ck1170 FIND v(dout1_68) AT=590.025n

.meas tran vdout1_69ck1170 FIND v(dout1_69) AT=590.025n

.meas tran vdout1_70ck1170 FIND v(dout1_70) AT=590.025n

.meas tran vdout1_71ck1170 FIND v(dout1_71) AT=590.025n

.meas tran vdout1_72ck1170 FIND v(dout1_72) AT=590.025n

.meas tran vdout1_73ck1170 FIND v(dout1_73) AT=590.025n

.meas tran vdout1_74ck1170 FIND v(dout1_74) AT=590.025n

.meas tran vdout1_75ck1170 FIND v(dout1_75) AT=590.025n

.meas tran vdout1_76ck1170 FIND v(dout1_76) AT=590.025n

.meas tran vdout1_77ck1170 FIND v(dout1_77) AT=590.025n

.meas tran vdout1_78ck1170 FIND v(dout1_78) AT=590.025n

.meas tran vdout1_79ck1170 FIND v(dout1_79) AT=590.025n

.meas tran vdout1_80ck1170 FIND v(dout1_80) AT=590.025n

.meas tran vdout1_81ck1170 FIND v(dout1_81) AT=590.025n

.meas tran vdout1_82ck1170 FIND v(dout1_82) AT=590.025n

.meas tran vdout1_83ck1170 FIND v(dout1_83) AT=590.025n

.meas tran vdout1_84ck1170 FIND v(dout1_84) AT=590.025n

.meas tran vdout1_85ck1170 FIND v(dout1_85) AT=590.025n

.meas tran vdout1_86ck1170 FIND v(dout1_86) AT=590.025n

.meas tran vdout1_87ck1170 FIND v(dout1_87) AT=590.025n

.meas tran vdout1_88ck1170 FIND v(dout1_88) AT=590.025n

.meas tran vdout1_89ck1170 FIND v(dout1_89) AT=590.025n

.meas tran vdout1_90ck1170 FIND v(dout1_90) AT=590.025n

.meas tran vdout1_91ck1170 FIND v(dout1_91) AT=590.025n

.meas tran vdout1_92ck1170 FIND v(dout1_92) AT=590.025n

.meas tran vdout1_93ck1170 FIND v(dout1_93) AT=590.025n

.meas tran vdout1_94ck1170 FIND v(dout1_94) AT=590.025n

.meas tran vdout1_95ck1170 FIND v(dout1_95) AT=590.025n

.meas tran vdout1_96ck1170 FIND v(dout1_96) AT=590.025n

.meas tran vdout1_97ck1170 FIND v(dout1_97) AT=590.025n

.meas tran vdout1_98ck1170 FIND v(dout1_98) AT=590.025n

.meas tran vdout1_99ck1170 FIND v(dout1_99) AT=590.025n

.meas tran vdout1_100ck1170 FIND v(dout1_100) AT=590.025n

.meas tran vdout1_101ck1170 FIND v(dout1_101) AT=590.025n

.meas tran vdout1_102ck1170 FIND v(dout1_102) AT=590.025n

.meas tran vdout1_103ck1170 FIND v(dout1_103) AT=590.025n

.meas tran vdout1_104ck1170 FIND v(dout1_104) AT=590.025n

.meas tran vdout1_105ck1170 FIND v(dout1_105) AT=590.025n

.meas tran vdout1_106ck1170 FIND v(dout1_106) AT=590.025n

.meas tran vdout1_107ck1170 FIND v(dout1_107) AT=590.025n

.meas tran vdout1_108ck1170 FIND v(dout1_108) AT=590.025n

.meas tran vdout1_109ck1170 FIND v(dout1_109) AT=590.025n

.meas tran vdout1_110ck1170 FIND v(dout1_110) AT=590.025n

.meas tran vdout1_111ck1170 FIND v(dout1_111) AT=590.025n

.meas tran vdout1_112ck1170 FIND v(dout1_112) AT=590.025n

.meas tran vdout1_113ck1170 FIND v(dout1_113) AT=590.025n

.meas tran vdout1_114ck1170 FIND v(dout1_114) AT=590.025n

.meas tran vdout1_115ck1170 FIND v(dout1_115) AT=590.025n

.meas tran vdout1_116ck1170 FIND v(dout1_116) AT=590.025n

.meas tran vdout1_117ck1170 FIND v(dout1_117) AT=590.025n

.meas tran vdout1_118ck1170 FIND v(dout1_118) AT=590.025n

.meas tran vdout1_119ck1170 FIND v(dout1_119) AT=590.025n

.meas tran vdout1_120ck1170 FIND v(dout1_120) AT=590.025n

.meas tran vdout1_121ck1170 FIND v(dout1_121) AT=590.025n

.meas tran vdout1_122ck1170 FIND v(dout1_122) AT=590.025n

.meas tran vdout1_123ck1170 FIND v(dout1_123) AT=590.025n

.meas tran vdout1_124ck1170 FIND v(dout1_124) AT=590.025n

.meas tran vdout1_125ck1170 FIND v(dout1_125) AT=590.025n

.meas tran vdout1_126ck1170 FIND v(dout1_126) AT=590.025n

.meas tran vdout1_127ck1170 FIND v(dout1_127) AT=590.025n

.meas tran vdout1_0ck1190 FIND v(dout1_0) AT=600.025n

.meas tran vdout1_1ck1190 FIND v(dout1_1) AT=600.025n

.meas tran vdout1_2ck1190 FIND v(dout1_2) AT=600.025n

.meas tran vdout1_3ck1190 FIND v(dout1_3) AT=600.025n

.meas tran vdout1_4ck1190 FIND v(dout1_4) AT=600.025n

.meas tran vdout1_5ck1190 FIND v(dout1_5) AT=600.025n

.meas tran vdout1_6ck1190 FIND v(dout1_6) AT=600.025n

.meas tran vdout1_7ck1190 FIND v(dout1_7) AT=600.025n

.meas tran vdout1_8ck1190 FIND v(dout1_8) AT=600.025n

.meas tran vdout1_9ck1190 FIND v(dout1_9) AT=600.025n

.meas tran vdout1_10ck1190 FIND v(dout1_10) AT=600.025n

.meas tran vdout1_11ck1190 FIND v(dout1_11) AT=600.025n

.meas tran vdout1_12ck1190 FIND v(dout1_12) AT=600.025n

.meas tran vdout1_13ck1190 FIND v(dout1_13) AT=600.025n

.meas tran vdout1_14ck1190 FIND v(dout1_14) AT=600.025n

.meas tran vdout1_15ck1190 FIND v(dout1_15) AT=600.025n

.meas tran vdout1_16ck1190 FIND v(dout1_16) AT=600.025n

.meas tran vdout1_17ck1190 FIND v(dout1_17) AT=600.025n

.meas tran vdout1_18ck1190 FIND v(dout1_18) AT=600.025n

.meas tran vdout1_19ck1190 FIND v(dout1_19) AT=600.025n

.meas tran vdout1_20ck1190 FIND v(dout1_20) AT=600.025n

.meas tran vdout1_21ck1190 FIND v(dout1_21) AT=600.025n

.meas tran vdout1_22ck1190 FIND v(dout1_22) AT=600.025n

.meas tran vdout1_23ck1190 FIND v(dout1_23) AT=600.025n

.meas tran vdout1_24ck1190 FIND v(dout1_24) AT=600.025n

.meas tran vdout1_25ck1190 FIND v(dout1_25) AT=600.025n

.meas tran vdout1_26ck1190 FIND v(dout1_26) AT=600.025n

.meas tran vdout1_27ck1190 FIND v(dout1_27) AT=600.025n

.meas tran vdout1_28ck1190 FIND v(dout1_28) AT=600.025n

.meas tran vdout1_29ck1190 FIND v(dout1_29) AT=600.025n

.meas tran vdout1_30ck1190 FIND v(dout1_30) AT=600.025n

.meas tran vdout1_31ck1190 FIND v(dout1_31) AT=600.025n

.meas tran vdout1_32ck1190 FIND v(dout1_32) AT=600.025n

.meas tran vdout1_33ck1190 FIND v(dout1_33) AT=600.025n

.meas tran vdout1_34ck1190 FIND v(dout1_34) AT=600.025n

.meas tran vdout1_35ck1190 FIND v(dout1_35) AT=600.025n

.meas tran vdout1_36ck1190 FIND v(dout1_36) AT=600.025n

.meas tran vdout1_37ck1190 FIND v(dout1_37) AT=600.025n

.meas tran vdout1_38ck1190 FIND v(dout1_38) AT=600.025n

.meas tran vdout1_39ck1190 FIND v(dout1_39) AT=600.025n

.meas tran vdout1_40ck1190 FIND v(dout1_40) AT=600.025n

.meas tran vdout1_41ck1190 FIND v(dout1_41) AT=600.025n

.meas tran vdout1_42ck1190 FIND v(dout1_42) AT=600.025n

.meas tran vdout1_43ck1190 FIND v(dout1_43) AT=600.025n

.meas tran vdout1_44ck1190 FIND v(dout1_44) AT=600.025n

.meas tran vdout1_45ck1190 FIND v(dout1_45) AT=600.025n

.meas tran vdout1_46ck1190 FIND v(dout1_46) AT=600.025n

.meas tran vdout1_47ck1190 FIND v(dout1_47) AT=600.025n

.meas tran vdout1_48ck1190 FIND v(dout1_48) AT=600.025n

.meas tran vdout1_49ck1190 FIND v(dout1_49) AT=600.025n

.meas tran vdout1_50ck1190 FIND v(dout1_50) AT=600.025n

.meas tran vdout1_51ck1190 FIND v(dout1_51) AT=600.025n

.meas tran vdout1_52ck1190 FIND v(dout1_52) AT=600.025n

.meas tran vdout1_53ck1190 FIND v(dout1_53) AT=600.025n

.meas tran vdout1_54ck1190 FIND v(dout1_54) AT=600.025n

.meas tran vdout1_55ck1190 FIND v(dout1_55) AT=600.025n

.meas tran vdout1_56ck1190 FIND v(dout1_56) AT=600.025n

.meas tran vdout1_57ck1190 FIND v(dout1_57) AT=600.025n

.meas tran vdout1_58ck1190 FIND v(dout1_58) AT=600.025n

.meas tran vdout1_59ck1190 FIND v(dout1_59) AT=600.025n

.meas tran vdout1_60ck1190 FIND v(dout1_60) AT=600.025n

.meas tran vdout1_61ck1190 FIND v(dout1_61) AT=600.025n

.meas tran vdout1_62ck1190 FIND v(dout1_62) AT=600.025n

.meas tran vdout1_63ck1190 FIND v(dout1_63) AT=600.025n

.meas tran vdout1_64ck1190 FIND v(dout1_64) AT=600.025n

.meas tran vdout1_65ck1190 FIND v(dout1_65) AT=600.025n

.meas tran vdout1_66ck1190 FIND v(dout1_66) AT=600.025n

.meas tran vdout1_67ck1190 FIND v(dout1_67) AT=600.025n

.meas tran vdout1_68ck1190 FIND v(dout1_68) AT=600.025n

.meas tran vdout1_69ck1190 FIND v(dout1_69) AT=600.025n

.meas tran vdout1_70ck1190 FIND v(dout1_70) AT=600.025n

.meas tran vdout1_71ck1190 FIND v(dout1_71) AT=600.025n

.meas tran vdout1_72ck1190 FIND v(dout1_72) AT=600.025n

.meas tran vdout1_73ck1190 FIND v(dout1_73) AT=600.025n

.meas tran vdout1_74ck1190 FIND v(dout1_74) AT=600.025n

.meas tran vdout1_75ck1190 FIND v(dout1_75) AT=600.025n

.meas tran vdout1_76ck1190 FIND v(dout1_76) AT=600.025n

.meas tran vdout1_77ck1190 FIND v(dout1_77) AT=600.025n

.meas tran vdout1_78ck1190 FIND v(dout1_78) AT=600.025n

.meas tran vdout1_79ck1190 FIND v(dout1_79) AT=600.025n

.meas tran vdout1_80ck1190 FIND v(dout1_80) AT=600.025n

.meas tran vdout1_81ck1190 FIND v(dout1_81) AT=600.025n

.meas tran vdout1_82ck1190 FIND v(dout1_82) AT=600.025n

.meas tran vdout1_83ck1190 FIND v(dout1_83) AT=600.025n

.meas tran vdout1_84ck1190 FIND v(dout1_84) AT=600.025n

.meas tran vdout1_85ck1190 FIND v(dout1_85) AT=600.025n

.meas tran vdout1_86ck1190 FIND v(dout1_86) AT=600.025n

.meas tran vdout1_87ck1190 FIND v(dout1_87) AT=600.025n

.meas tran vdout1_88ck1190 FIND v(dout1_88) AT=600.025n

.meas tran vdout1_89ck1190 FIND v(dout1_89) AT=600.025n

.meas tran vdout1_90ck1190 FIND v(dout1_90) AT=600.025n

.meas tran vdout1_91ck1190 FIND v(dout1_91) AT=600.025n

.meas tran vdout1_92ck1190 FIND v(dout1_92) AT=600.025n

.meas tran vdout1_93ck1190 FIND v(dout1_93) AT=600.025n

.meas tran vdout1_94ck1190 FIND v(dout1_94) AT=600.025n

.meas tran vdout1_95ck1190 FIND v(dout1_95) AT=600.025n

.meas tran vdout1_96ck1190 FIND v(dout1_96) AT=600.025n

.meas tran vdout1_97ck1190 FIND v(dout1_97) AT=600.025n

.meas tran vdout1_98ck1190 FIND v(dout1_98) AT=600.025n

.meas tran vdout1_99ck1190 FIND v(dout1_99) AT=600.025n

.meas tran vdout1_100ck1190 FIND v(dout1_100) AT=600.025n

.meas tran vdout1_101ck1190 FIND v(dout1_101) AT=600.025n

.meas tran vdout1_102ck1190 FIND v(dout1_102) AT=600.025n

.meas tran vdout1_103ck1190 FIND v(dout1_103) AT=600.025n

.meas tran vdout1_104ck1190 FIND v(dout1_104) AT=600.025n

.meas tran vdout1_105ck1190 FIND v(dout1_105) AT=600.025n

.meas tran vdout1_106ck1190 FIND v(dout1_106) AT=600.025n

.meas tran vdout1_107ck1190 FIND v(dout1_107) AT=600.025n

.meas tran vdout1_108ck1190 FIND v(dout1_108) AT=600.025n

.meas tran vdout1_109ck1190 FIND v(dout1_109) AT=600.025n

.meas tran vdout1_110ck1190 FIND v(dout1_110) AT=600.025n

.meas tran vdout1_111ck1190 FIND v(dout1_111) AT=600.025n

.meas tran vdout1_112ck1190 FIND v(dout1_112) AT=600.025n

.meas tran vdout1_113ck1190 FIND v(dout1_113) AT=600.025n

.meas tran vdout1_114ck1190 FIND v(dout1_114) AT=600.025n

.meas tran vdout1_115ck1190 FIND v(dout1_115) AT=600.025n

.meas tran vdout1_116ck1190 FIND v(dout1_116) AT=600.025n

.meas tran vdout1_117ck1190 FIND v(dout1_117) AT=600.025n

.meas tran vdout1_118ck1190 FIND v(dout1_118) AT=600.025n

.meas tran vdout1_119ck1190 FIND v(dout1_119) AT=600.025n

.meas tran vdout1_120ck1190 FIND v(dout1_120) AT=600.025n

.meas tran vdout1_121ck1190 FIND v(dout1_121) AT=600.025n

.meas tran vdout1_122ck1190 FIND v(dout1_122) AT=600.025n

.meas tran vdout1_123ck1190 FIND v(dout1_123) AT=600.025n

.meas tran vdout1_124ck1190 FIND v(dout1_124) AT=600.025n

.meas tran vdout1_125ck1190 FIND v(dout1_125) AT=600.025n

.meas tran vdout1_126ck1190 FIND v(dout1_126) AT=600.025n

.meas tran vdout1_127ck1190 FIND v(dout1_127) AT=600.025n

.meas tran vdout1_0ck1220 FIND v(dout1_0) AT=615.025n

.meas tran vdout1_1ck1220 FIND v(dout1_1) AT=615.025n

.meas tran vdout1_2ck1220 FIND v(dout1_2) AT=615.025n

.meas tran vdout1_3ck1220 FIND v(dout1_3) AT=615.025n

.meas tran vdout1_4ck1220 FIND v(dout1_4) AT=615.025n

.meas tran vdout1_5ck1220 FIND v(dout1_5) AT=615.025n

.meas tran vdout1_6ck1220 FIND v(dout1_6) AT=615.025n

.meas tran vdout1_7ck1220 FIND v(dout1_7) AT=615.025n

.meas tran vdout1_8ck1220 FIND v(dout1_8) AT=615.025n

.meas tran vdout1_9ck1220 FIND v(dout1_9) AT=615.025n

.meas tran vdout1_10ck1220 FIND v(dout1_10) AT=615.025n

.meas tran vdout1_11ck1220 FIND v(dout1_11) AT=615.025n

.meas tran vdout1_12ck1220 FIND v(dout1_12) AT=615.025n

.meas tran vdout1_13ck1220 FIND v(dout1_13) AT=615.025n

.meas tran vdout1_14ck1220 FIND v(dout1_14) AT=615.025n

.meas tran vdout1_15ck1220 FIND v(dout1_15) AT=615.025n

.meas tran vdout1_16ck1220 FIND v(dout1_16) AT=615.025n

.meas tran vdout1_17ck1220 FIND v(dout1_17) AT=615.025n

.meas tran vdout1_18ck1220 FIND v(dout1_18) AT=615.025n

.meas tran vdout1_19ck1220 FIND v(dout1_19) AT=615.025n

.meas tran vdout1_20ck1220 FIND v(dout1_20) AT=615.025n

.meas tran vdout1_21ck1220 FIND v(dout1_21) AT=615.025n

.meas tran vdout1_22ck1220 FIND v(dout1_22) AT=615.025n

.meas tran vdout1_23ck1220 FIND v(dout1_23) AT=615.025n

.meas tran vdout1_24ck1220 FIND v(dout1_24) AT=615.025n

.meas tran vdout1_25ck1220 FIND v(dout1_25) AT=615.025n

.meas tran vdout1_26ck1220 FIND v(dout1_26) AT=615.025n

.meas tran vdout1_27ck1220 FIND v(dout1_27) AT=615.025n

.meas tran vdout1_28ck1220 FIND v(dout1_28) AT=615.025n

.meas tran vdout1_29ck1220 FIND v(dout1_29) AT=615.025n

.meas tran vdout1_30ck1220 FIND v(dout1_30) AT=615.025n

.meas tran vdout1_31ck1220 FIND v(dout1_31) AT=615.025n

.meas tran vdout1_32ck1220 FIND v(dout1_32) AT=615.025n

.meas tran vdout1_33ck1220 FIND v(dout1_33) AT=615.025n

.meas tran vdout1_34ck1220 FIND v(dout1_34) AT=615.025n

.meas tran vdout1_35ck1220 FIND v(dout1_35) AT=615.025n

.meas tran vdout1_36ck1220 FIND v(dout1_36) AT=615.025n

.meas tran vdout1_37ck1220 FIND v(dout1_37) AT=615.025n

.meas tran vdout1_38ck1220 FIND v(dout1_38) AT=615.025n

.meas tran vdout1_39ck1220 FIND v(dout1_39) AT=615.025n

.meas tran vdout1_40ck1220 FIND v(dout1_40) AT=615.025n

.meas tran vdout1_41ck1220 FIND v(dout1_41) AT=615.025n

.meas tran vdout1_42ck1220 FIND v(dout1_42) AT=615.025n

.meas tran vdout1_43ck1220 FIND v(dout1_43) AT=615.025n

.meas tran vdout1_44ck1220 FIND v(dout1_44) AT=615.025n

.meas tran vdout1_45ck1220 FIND v(dout1_45) AT=615.025n

.meas tran vdout1_46ck1220 FIND v(dout1_46) AT=615.025n

.meas tran vdout1_47ck1220 FIND v(dout1_47) AT=615.025n

.meas tran vdout1_48ck1220 FIND v(dout1_48) AT=615.025n

.meas tran vdout1_49ck1220 FIND v(dout1_49) AT=615.025n

.meas tran vdout1_50ck1220 FIND v(dout1_50) AT=615.025n

.meas tran vdout1_51ck1220 FIND v(dout1_51) AT=615.025n

.meas tran vdout1_52ck1220 FIND v(dout1_52) AT=615.025n

.meas tran vdout1_53ck1220 FIND v(dout1_53) AT=615.025n

.meas tran vdout1_54ck1220 FIND v(dout1_54) AT=615.025n

.meas tran vdout1_55ck1220 FIND v(dout1_55) AT=615.025n

.meas tran vdout1_56ck1220 FIND v(dout1_56) AT=615.025n

.meas tran vdout1_57ck1220 FIND v(dout1_57) AT=615.025n

.meas tran vdout1_58ck1220 FIND v(dout1_58) AT=615.025n

.meas tran vdout1_59ck1220 FIND v(dout1_59) AT=615.025n

.meas tran vdout1_60ck1220 FIND v(dout1_60) AT=615.025n

.meas tran vdout1_61ck1220 FIND v(dout1_61) AT=615.025n

.meas tran vdout1_62ck1220 FIND v(dout1_62) AT=615.025n

.meas tran vdout1_63ck1220 FIND v(dout1_63) AT=615.025n

.meas tran vdout1_64ck1220 FIND v(dout1_64) AT=615.025n

.meas tran vdout1_65ck1220 FIND v(dout1_65) AT=615.025n

.meas tran vdout1_66ck1220 FIND v(dout1_66) AT=615.025n

.meas tran vdout1_67ck1220 FIND v(dout1_67) AT=615.025n

.meas tran vdout1_68ck1220 FIND v(dout1_68) AT=615.025n

.meas tran vdout1_69ck1220 FIND v(dout1_69) AT=615.025n

.meas tran vdout1_70ck1220 FIND v(dout1_70) AT=615.025n

.meas tran vdout1_71ck1220 FIND v(dout1_71) AT=615.025n

.meas tran vdout1_72ck1220 FIND v(dout1_72) AT=615.025n

.meas tran vdout1_73ck1220 FIND v(dout1_73) AT=615.025n

.meas tran vdout1_74ck1220 FIND v(dout1_74) AT=615.025n

.meas tran vdout1_75ck1220 FIND v(dout1_75) AT=615.025n

.meas tran vdout1_76ck1220 FIND v(dout1_76) AT=615.025n

.meas tran vdout1_77ck1220 FIND v(dout1_77) AT=615.025n

.meas tran vdout1_78ck1220 FIND v(dout1_78) AT=615.025n

.meas tran vdout1_79ck1220 FIND v(dout1_79) AT=615.025n

.meas tran vdout1_80ck1220 FIND v(dout1_80) AT=615.025n

.meas tran vdout1_81ck1220 FIND v(dout1_81) AT=615.025n

.meas tran vdout1_82ck1220 FIND v(dout1_82) AT=615.025n

.meas tran vdout1_83ck1220 FIND v(dout1_83) AT=615.025n

.meas tran vdout1_84ck1220 FIND v(dout1_84) AT=615.025n

.meas tran vdout1_85ck1220 FIND v(dout1_85) AT=615.025n

.meas tran vdout1_86ck1220 FIND v(dout1_86) AT=615.025n

.meas tran vdout1_87ck1220 FIND v(dout1_87) AT=615.025n

.meas tran vdout1_88ck1220 FIND v(dout1_88) AT=615.025n

.meas tran vdout1_89ck1220 FIND v(dout1_89) AT=615.025n

.meas tran vdout1_90ck1220 FIND v(dout1_90) AT=615.025n

.meas tran vdout1_91ck1220 FIND v(dout1_91) AT=615.025n

.meas tran vdout1_92ck1220 FIND v(dout1_92) AT=615.025n

.meas tran vdout1_93ck1220 FIND v(dout1_93) AT=615.025n

.meas tran vdout1_94ck1220 FIND v(dout1_94) AT=615.025n

.meas tran vdout1_95ck1220 FIND v(dout1_95) AT=615.025n

.meas tran vdout1_96ck1220 FIND v(dout1_96) AT=615.025n

.meas tran vdout1_97ck1220 FIND v(dout1_97) AT=615.025n

.meas tran vdout1_98ck1220 FIND v(dout1_98) AT=615.025n

.meas tran vdout1_99ck1220 FIND v(dout1_99) AT=615.025n

.meas tran vdout1_100ck1220 FIND v(dout1_100) AT=615.025n

.meas tran vdout1_101ck1220 FIND v(dout1_101) AT=615.025n

.meas tran vdout1_102ck1220 FIND v(dout1_102) AT=615.025n

.meas tran vdout1_103ck1220 FIND v(dout1_103) AT=615.025n

.meas tran vdout1_104ck1220 FIND v(dout1_104) AT=615.025n

.meas tran vdout1_105ck1220 FIND v(dout1_105) AT=615.025n

.meas tran vdout1_106ck1220 FIND v(dout1_106) AT=615.025n

.meas tran vdout1_107ck1220 FIND v(dout1_107) AT=615.025n

.meas tran vdout1_108ck1220 FIND v(dout1_108) AT=615.025n

.meas tran vdout1_109ck1220 FIND v(dout1_109) AT=615.025n

.meas tran vdout1_110ck1220 FIND v(dout1_110) AT=615.025n

.meas tran vdout1_111ck1220 FIND v(dout1_111) AT=615.025n

.meas tran vdout1_112ck1220 FIND v(dout1_112) AT=615.025n

.meas tran vdout1_113ck1220 FIND v(dout1_113) AT=615.025n

.meas tran vdout1_114ck1220 FIND v(dout1_114) AT=615.025n

.meas tran vdout1_115ck1220 FIND v(dout1_115) AT=615.025n

.meas tran vdout1_116ck1220 FIND v(dout1_116) AT=615.025n

.meas tran vdout1_117ck1220 FIND v(dout1_117) AT=615.025n

.meas tran vdout1_118ck1220 FIND v(dout1_118) AT=615.025n

.meas tran vdout1_119ck1220 FIND v(dout1_119) AT=615.025n

.meas tran vdout1_120ck1220 FIND v(dout1_120) AT=615.025n

.meas tran vdout1_121ck1220 FIND v(dout1_121) AT=615.025n

.meas tran vdout1_122ck1220 FIND v(dout1_122) AT=615.025n

.meas tran vdout1_123ck1220 FIND v(dout1_123) AT=615.025n

.meas tran vdout1_124ck1220 FIND v(dout1_124) AT=615.025n

.meas tran vdout1_125ck1220 FIND v(dout1_125) AT=615.025n

.meas tran vdout1_126ck1220 FIND v(dout1_126) AT=615.025n

.meas tran vdout1_127ck1220 FIND v(dout1_127) AT=615.025n

.meas tran vdout1_0ck1240 FIND v(dout1_0) AT=625.025n

.meas tran vdout1_1ck1240 FIND v(dout1_1) AT=625.025n

.meas tran vdout1_2ck1240 FIND v(dout1_2) AT=625.025n

.meas tran vdout1_3ck1240 FIND v(dout1_3) AT=625.025n

.meas tran vdout1_4ck1240 FIND v(dout1_4) AT=625.025n

.meas tran vdout1_5ck1240 FIND v(dout1_5) AT=625.025n

.meas tran vdout1_6ck1240 FIND v(dout1_6) AT=625.025n

.meas tran vdout1_7ck1240 FIND v(dout1_7) AT=625.025n

.meas tran vdout1_8ck1240 FIND v(dout1_8) AT=625.025n

.meas tran vdout1_9ck1240 FIND v(dout1_9) AT=625.025n

.meas tran vdout1_10ck1240 FIND v(dout1_10) AT=625.025n

.meas tran vdout1_11ck1240 FIND v(dout1_11) AT=625.025n

.meas tran vdout1_12ck1240 FIND v(dout1_12) AT=625.025n

.meas tran vdout1_13ck1240 FIND v(dout1_13) AT=625.025n

.meas tran vdout1_14ck1240 FIND v(dout1_14) AT=625.025n

.meas tran vdout1_15ck1240 FIND v(dout1_15) AT=625.025n

.meas tran vdout1_16ck1240 FIND v(dout1_16) AT=625.025n

.meas tran vdout1_17ck1240 FIND v(dout1_17) AT=625.025n

.meas tran vdout1_18ck1240 FIND v(dout1_18) AT=625.025n

.meas tran vdout1_19ck1240 FIND v(dout1_19) AT=625.025n

.meas tran vdout1_20ck1240 FIND v(dout1_20) AT=625.025n

.meas tran vdout1_21ck1240 FIND v(dout1_21) AT=625.025n

.meas tran vdout1_22ck1240 FIND v(dout1_22) AT=625.025n

.meas tran vdout1_23ck1240 FIND v(dout1_23) AT=625.025n

.meas tran vdout1_24ck1240 FIND v(dout1_24) AT=625.025n

.meas tran vdout1_25ck1240 FIND v(dout1_25) AT=625.025n

.meas tran vdout1_26ck1240 FIND v(dout1_26) AT=625.025n

.meas tran vdout1_27ck1240 FIND v(dout1_27) AT=625.025n

.meas tran vdout1_28ck1240 FIND v(dout1_28) AT=625.025n

.meas tran vdout1_29ck1240 FIND v(dout1_29) AT=625.025n

.meas tran vdout1_30ck1240 FIND v(dout1_30) AT=625.025n

.meas tran vdout1_31ck1240 FIND v(dout1_31) AT=625.025n

.meas tran vdout1_32ck1240 FIND v(dout1_32) AT=625.025n

.meas tran vdout1_33ck1240 FIND v(dout1_33) AT=625.025n

.meas tran vdout1_34ck1240 FIND v(dout1_34) AT=625.025n

.meas tran vdout1_35ck1240 FIND v(dout1_35) AT=625.025n

.meas tran vdout1_36ck1240 FIND v(dout1_36) AT=625.025n

.meas tran vdout1_37ck1240 FIND v(dout1_37) AT=625.025n

.meas tran vdout1_38ck1240 FIND v(dout1_38) AT=625.025n

.meas tran vdout1_39ck1240 FIND v(dout1_39) AT=625.025n

.meas tran vdout1_40ck1240 FIND v(dout1_40) AT=625.025n

.meas tran vdout1_41ck1240 FIND v(dout1_41) AT=625.025n

.meas tran vdout1_42ck1240 FIND v(dout1_42) AT=625.025n

.meas tran vdout1_43ck1240 FIND v(dout1_43) AT=625.025n

.meas tran vdout1_44ck1240 FIND v(dout1_44) AT=625.025n

.meas tran vdout1_45ck1240 FIND v(dout1_45) AT=625.025n

.meas tran vdout1_46ck1240 FIND v(dout1_46) AT=625.025n

.meas tran vdout1_47ck1240 FIND v(dout1_47) AT=625.025n

.meas tran vdout1_48ck1240 FIND v(dout1_48) AT=625.025n

.meas tran vdout1_49ck1240 FIND v(dout1_49) AT=625.025n

.meas tran vdout1_50ck1240 FIND v(dout1_50) AT=625.025n

.meas tran vdout1_51ck1240 FIND v(dout1_51) AT=625.025n

.meas tran vdout1_52ck1240 FIND v(dout1_52) AT=625.025n

.meas tran vdout1_53ck1240 FIND v(dout1_53) AT=625.025n

.meas tran vdout1_54ck1240 FIND v(dout1_54) AT=625.025n

.meas tran vdout1_55ck1240 FIND v(dout1_55) AT=625.025n

.meas tran vdout1_56ck1240 FIND v(dout1_56) AT=625.025n

.meas tran vdout1_57ck1240 FIND v(dout1_57) AT=625.025n

.meas tran vdout1_58ck1240 FIND v(dout1_58) AT=625.025n

.meas tran vdout1_59ck1240 FIND v(dout1_59) AT=625.025n

.meas tran vdout1_60ck1240 FIND v(dout1_60) AT=625.025n

.meas tran vdout1_61ck1240 FIND v(dout1_61) AT=625.025n

.meas tran vdout1_62ck1240 FIND v(dout1_62) AT=625.025n

.meas tran vdout1_63ck1240 FIND v(dout1_63) AT=625.025n

.meas tran vdout1_64ck1240 FIND v(dout1_64) AT=625.025n

.meas tran vdout1_65ck1240 FIND v(dout1_65) AT=625.025n

.meas tran vdout1_66ck1240 FIND v(dout1_66) AT=625.025n

.meas tran vdout1_67ck1240 FIND v(dout1_67) AT=625.025n

.meas tran vdout1_68ck1240 FIND v(dout1_68) AT=625.025n

.meas tran vdout1_69ck1240 FIND v(dout1_69) AT=625.025n

.meas tran vdout1_70ck1240 FIND v(dout1_70) AT=625.025n

.meas tran vdout1_71ck1240 FIND v(dout1_71) AT=625.025n

.meas tran vdout1_72ck1240 FIND v(dout1_72) AT=625.025n

.meas tran vdout1_73ck1240 FIND v(dout1_73) AT=625.025n

.meas tran vdout1_74ck1240 FIND v(dout1_74) AT=625.025n

.meas tran vdout1_75ck1240 FIND v(dout1_75) AT=625.025n

.meas tran vdout1_76ck1240 FIND v(dout1_76) AT=625.025n

.meas tran vdout1_77ck1240 FIND v(dout1_77) AT=625.025n

.meas tran vdout1_78ck1240 FIND v(dout1_78) AT=625.025n

.meas tran vdout1_79ck1240 FIND v(dout1_79) AT=625.025n

.meas tran vdout1_80ck1240 FIND v(dout1_80) AT=625.025n

.meas tran vdout1_81ck1240 FIND v(dout1_81) AT=625.025n

.meas tran vdout1_82ck1240 FIND v(dout1_82) AT=625.025n

.meas tran vdout1_83ck1240 FIND v(dout1_83) AT=625.025n

.meas tran vdout1_84ck1240 FIND v(dout1_84) AT=625.025n

.meas tran vdout1_85ck1240 FIND v(dout1_85) AT=625.025n

.meas tran vdout1_86ck1240 FIND v(dout1_86) AT=625.025n

.meas tran vdout1_87ck1240 FIND v(dout1_87) AT=625.025n

.meas tran vdout1_88ck1240 FIND v(dout1_88) AT=625.025n

.meas tran vdout1_89ck1240 FIND v(dout1_89) AT=625.025n

.meas tran vdout1_90ck1240 FIND v(dout1_90) AT=625.025n

.meas tran vdout1_91ck1240 FIND v(dout1_91) AT=625.025n

.meas tran vdout1_92ck1240 FIND v(dout1_92) AT=625.025n

.meas tran vdout1_93ck1240 FIND v(dout1_93) AT=625.025n

.meas tran vdout1_94ck1240 FIND v(dout1_94) AT=625.025n

.meas tran vdout1_95ck1240 FIND v(dout1_95) AT=625.025n

.meas tran vdout1_96ck1240 FIND v(dout1_96) AT=625.025n

.meas tran vdout1_97ck1240 FIND v(dout1_97) AT=625.025n

.meas tran vdout1_98ck1240 FIND v(dout1_98) AT=625.025n

.meas tran vdout1_99ck1240 FIND v(dout1_99) AT=625.025n

.meas tran vdout1_100ck1240 FIND v(dout1_100) AT=625.025n

.meas tran vdout1_101ck1240 FIND v(dout1_101) AT=625.025n

.meas tran vdout1_102ck1240 FIND v(dout1_102) AT=625.025n

.meas tran vdout1_103ck1240 FIND v(dout1_103) AT=625.025n

.meas tran vdout1_104ck1240 FIND v(dout1_104) AT=625.025n

.meas tran vdout1_105ck1240 FIND v(dout1_105) AT=625.025n

.meas tran vdout1_106ck1240 FIND v(dout1_106) AT=625.025n

.meas tran vdout1_107ck1240 FIND v(dout1_107) AT=625.025n

.meas tran vdout1_108ck1240 FIND v(dout1_108) AT=625.025n

.meas tran vdout1_109ck1240 FIND v(dout1_109) AT=625.025n

.meas tran vdout1_110ck1240 FIND v(dout1_110) AT=625.025n

.meas tran vdout1_111ck1240 FIND v(dout1_111) AT=625.025n

.meas tran vdout1_112ck1240 FIND v(dout1_112) AT=625.025n

.meas tran vdout1_113ck1240 FIND v(dout1_113) AT=625.025n

.meas tran vdout1_114ck1240 FIND v(dout1_114) AT=625.025n

.meas tran vdout1_115ck1240 FIND v(dout1_115) AT=625.025n

.meas tran vdout1_116ck1240 FIND v(dout1_116) AT=625.025n

.meas tran vdout1_117ck1240 FIND v(dout1_117) AT=625.025n

.meas tran vdout1_118ck1240 FIND v(dout1_118) AT=625.025n

.meas tran vdout1_119ck1240 FIND v(dout1_119) AT=625.025n

.meas tran vdout1_120ck1240 FIND v(dout1_120) AT=625.025n

.meas tran vdout1_121ck1240 FIND v(dout1_121) AT=625.025n

.meas tran vdout1_122ck1240 FIND v(dout1_122) AT=625.025n

.meas tran vdout1_123ck1240 FIND v(dout1_123) AT=625.025n

.meas tran vdout1_124ck1240 FIND v(dout1_124) AT=625.025n

.meas tran vdout1_125ck1240 FIND v(dout1_125) AT=625.025n

.meas tran vdout1_126ck1240 FIND v(dout1_126) AT=625.025n

.meas tran vdout1_127ck1240 FIND v(dout1_127) AT=625.025n

.meas tran vdout1_0ck1260 FIND v(dout1_0) AT=635.025n

.meas tran vdout1_1ck1260 FIND v(dout1_1) AT=635.025n

.meas tran vdout1_2ck1260 FIND v(dout1_2) AT=635.025n

.meas tran vdout1_3ck1260 FIND v(dout1_3) AT=635.025n

.meas tran vdout1_4ck1260 FIND v(dout1_4) AT=635.025n

.meas tran vdout1_5ck1260 FIND v(dout1_5) AT=635.025n

.meas tran vdout1_6ck1260 FIND v(dout1_6) AT=635.025n

.meas tran vdout1_7ck1260 FIND v(dout1_7) AT=635.025n

.meas tran vdout1_8ck1260 FIND v(dout1_8) AT=635.025n

.meas tran vdout1_9ck1260 FIND v(dout1_9) AT=635.025n

.meas tran vdout1_10ck1260 FIND v(dout1_10) AT=635.025n

.meas tran vdout1_11ck1260 FIND v(dout1_11) AT=635.025n

.meas tran vdout1_12ck1260 FIND v(dout1_12) AT=635.025n

.meas tran vdout1_13ck1260 FIND v(dout1_13) AT=635.025n

.meas tran vdout1_14ck1260 FIND v(dout1_14) AT=635.025n

.meas tran vdout1_15ck1260 FIND v(dout1_15) AT=635.025n

.meas tran vdout1_16ck1260 FIND v(dout1_16) AT=635.025n

.meas tran vdout1_17ck1260 FIND v(dout1_17) AT=635.025n

.meas tran vdout1_18ck1260 FIND v(dout1_18) AT=635.025n

.meas tran vdout1_19ck1260 FIND v(dout1_19) AT=635.025n

.meas tran vdout1_20ck1260 FIND v(dout1_20) AT=635.025n

.meas tran vdout1_21ck1260 FIND v(dout1_21) AT=635.025n

.meas tran vdout1_22ck1260 FIND v(dout1_22) AT=635.025n

.meas tran vdout1_23ck1260 FIND v(dout1_23) AT=635.025n

.meas tran vdout1_24ck1260 FIND v(dout1_24) AT=635.025n

.meas tran vdout1_25ck1260 FIND v(dout1_25) AT=635.025n

.meas tran vdout1_26ck1260 FIND v(dout1_26) AT=635.025n

.meas tran vdout1_27ck1260 FIND v(dout1_27) AT=635.025n

.meas tran vdout1_28ck1260 FIND v(dout1_28) AT=635.025n

.meas tran vdout1_29ck1260 FIND v(dout1_29) AT=635.025n

.meas tran vdout1_30ck1260 FIND v(dout1_30) AT=635.025n

.meas tran vdout1_31ck1260 FIND v(dout1_31) AT=635.025n

.meas tran vdout1_32ck1260 FIND v(dout1_32) AT=635.025n

.meas tran vdout1_33ck1260 FIND v(dout1_33) AT=635.025n

.meas tran vdout1_34ck1260 FIND v(dout1_34) AT=635.025n

.meas tran vdout1_35ck1260 FIND v(dout1_35) AT=635.025n

.meas tran vdout1_36ck1260 FIND v(dout1_36) AT=635.025n

.meas tran vdout1_37ck1260 FIND v(dout1_37) AT=635.025n

.meas tran vdout1_38ck1260 FIND v(dout1_38) AT=635.025n

.meas tran vdout1_39ck1260 FIND v(dout1_39) AT=635.025n

.meas tran vdout1_40ck1260 FIND v(dout1_40) AT=635.025n

.meas tran vdout1_41ck1260 FIND v(dout1_41) AT=635.025n

.meas tran vdout1_42ck1260 FIND v(dout1_42) AT=635.025n

.meas tran vdout1_43ck1260 FIND v(dout1_43) AT=635.025n

.meas tran vdout1_44ck1260 FIND v(dout1_44) AT=635.025n

.meas tran vdout1_45ck1260 FIND v(dout1_45) AT=635.025n

.meas tran vdout1_46ck1260 FIND v(dout1_46) AT=635.025n

.meas tran vdout1_47ck1260 FIND v(dout1_47) AT=635.025n

.meas tran vdout1_48ck1260 FIND v(dout1_48) AT=635.025n

.meas tran vdout1_49ck1260 FIND v(dout1_49) AT=635.025n

.meas tran vdout1_50ck1260 FIND v(dout1_50) AT=635.025n

.meas tran vdout1_51ck1260 FIND v(dout1_51) AT=635.025n

.meas tran vdout1_52ck1260 FIND v(dout1_52) AT=635.025n

.meas tran vdout1_53ck1260 FIND v(dout1_53) AT=635.025n

.meas tran vdout1_54ck1260 FIND v(dout1_54) AT=635.025n

.meas tran vdout1_55ck1260 FIND v(dout1_55) AT=635.025n

.meas tran vdout1_56ck1260 FIND v(dout1_56) AT=635.025n

.meas tran vdout1_57ck1260 FIND v(dout1_57) AT=635.025n

.meas tran vdout1_58ck1260 FIND v(dout1_58) AT=635.025n

.meas tran vdout1_59ck1260 FIND v(dout1_59) AT=635.025n

.meas tran vdout1_60ck1260 FIND v(dout1_60) AT=635.025n

.meas tran vdout1_61ck1260 FIND v(dout1_61) AT=635.025n

.meas tran vdout1_62ck1260 FIND v(dout1_62) AT=635.025n

.meas tran vdout1_63ck1260 FIND v(dout1_63) AT=635.025n

.meas tran vdout1_64ck1260 FIND v(dout1_64) AT=635.025n

.meas tran vdout1_65ck1260 FIND v(dout1_65) AT=635.025n

.meas tran vdout1_66ck1260 FIND v(dout1_66) AT=635.025n

.meas tran vdout1_67ck1260 FIND v(dout1_67) AT=635.025n

.meas tran vdout1_68ck1260 FIND v(dout1_68) AT=635.025n

.meas tran vdout1_69ck1260 FIND v(dout1_69) AT=635.025n

.meas tran vdout1_70ck1260 FIND v(dout1_70) AT=635.025n

.meas tran vdout1_71ck1260 FIND v(dout1_71) AT=635.025n

.meas tran vdout1_72ck1260 FIND v(dout1_72) AT=635.025n

.meas tran vdout1_73ck1260 FIND v(dout1_73) AT=635.025n

.meas tran vdout1_74ck1260 FIND v(dout1_74) AT=635.025n

.meas tran vdout1_75ck1260 FIND v(dout1_75) AT=635.025n

.meas tran vdout1_76ck1260 FIND v(dout1_76) AT=635.025n

.meas tran vdout1_77ck1260 FIND v(dout1_77) AT=635.025n

.meas tran vdout1_78ck1260 FIND v(dout1_78) AT=635.025n

.meas tran vdout1_79ck1260 FIND v(dout1_79) AT=635.025n

.meas tran vdout1_80ck1260 FIND v(dout1_80) AT=635.025n

.meas tran vdout1_81ck1260 FIND v(dout1_81) AT=635.025n

.meas tran vdout1_82ck1260 FIND v(dout1_82) AT=635.025n

.meas tran vdout1_83ck1260 FIND v(dout1_83) AT=635.025n

.meas tran vdout1_84ck1260 FIND v(dout1_84) AT=635.025n

.meas tran vdout1_85ck1260 FIND v(dout1_85) AT=635.025n

.meas tran vdout1_86ck1260 FIND v(dout1_86) AT=635.025n

.meas tran vdout1_87ck1260 FIND v(dout1_87) AT=635.025n

.meas tran vdout1_88ck1260 FIND v(dout1_88) AT=635.025n

.meas tran vdout1_89ck1260 FIND v(dout1_89) AT=635.025n

.meas tran vdout1_90ck1260 FIND v(dout1_90) AT=635.025n

.meas tran vdout1_91ck1260 FIND v(dout1_91) AT=635.025n

.meas tran vdout1_92ck1260 FIND v(dout1_92) AT=635.025n

.meas tran vdout1_93ck1260 FIND v(dout1_93) AT=635.025n

.meas tran vdout1_94ck1260 FIND v(dout1_94) AT=635.025n

.meas tran vdout1_95ck1260 FIND v(dout1_95) AT=635.025n

.meas tran vdout1_96ck1260 FIND v(dout1_96) AT=635.025n

.meas tran vdout1_97ck1260 FIND v(dout1_97) AT=635.025n

.meas tran vdout1_98ck1260 FIND v(dout1_98) AT=635.025n

.meas tran vdout1_99ck1260 FIND v(dout1_99) AT=635.025n

.meas tran vdout1_100ck1260 FIND v(dout1_100) AT=635.025n

.meas tran vdout1_101ck1260 FIND v(dout1_101) AT=635.025n

.meas tran vdout1_102ck1260 FIND v(dout1_102) AT=635.025n

.meas tran vdout1_103ck1260 FIND v(dout1_103) AT=635.025n

.meas tran vdout1_104ck1260 FIND v(dout1_104) AT=635.025n

.meas tran vdout1_105ck1260 FIND v(dout1_105) AT=635.025n

.meas tran vdout1_106ck1260 FIND v(dout1_106) AT=635.025n

.meas tran vdout1_107ck1260 FIND v(dout1_107) AT=635.025n

.meas tran vdout1_108ck1260 FIND v(dout1_108) AT=635.025n

.meas tran vdout1_109ck1260 FIND v(dout1_109) AT=635.025n

.meas tran vdout1_110ck1260 FIND v(dout1_110) AT=635.025n

.meas tran vdout1_111ck1260 FIND v(dout1_111) AT=635.025n

.meas tran vdout1_112ck1260 FIND v(dout1_112) AT=635.025n

.meas tran vdout1_113ck1260 FIND v(dout1_113) AT=635.025n

.meas tran vdout1_114ck1260 FIND v(dout1_114) AT=635.025n

.meas tran vdout1_115ck1260 FIND v(dout1_115) AT=635.025n

.meas tran vdout1_116ck1260 FIND v(dout1_116) AT=635.025n

.meas tran vdout1_117ck1260 FIND v(dout1_117) AT=635.025n

.meas tran vdout1_118ck1260 FIND v(dout1_118) AT=635.025n

.meas tran vdout1_119ck1260 FIND v(dout1_119) AT=635.025n

.meas tran vdout1_120ck1260 FIND v(dout1_120) AT=635.025n

.meas tran vdout1_121ck1260 FIND v(dout1_121) AT=635.025n

.meas tran vdout1_122ck1260 FIND v(dout1_122) AT=635.025n

.meas tran vdout1_123ck1260 FIND v(dout1_123) AT=635.025n

.meas tran vdout1_124ck1260 FIND v(dout1_124) AT=635.025n

.meas tran vdout1_125ck1260 FIND v(dout1_125) AT=635.025n

.meas tran vdout1_126ck1260 FIND v(dout1_126) AT=635.025n

.meas tran vdout1_127ck1260 FIND v(dout1_127) AT=635.025n

.meas tran vdout1_0ck1270 FIND v(dout1_0) AT=640.025n

.meas tran vdout1_1ck1270 FIND v(dout1_1) AT=640.025n

.meas tran vdout1_2ck1270 FIND v(dout1_2) AT=640.025n

.meas tran vdout1_3ck1270 FIND v(dout1_3) AT=640.025n

.meas tran vdout1_4ck1270 FIND v(dout1_4) AT=640.025n

.meas tran vdout1_5ck1270 FIND v(dout1_5) AT=640.025n

.meas tran vdout1_6ck1270 FIND v(dout1_6) AT=640.025n

.meas tran vdout1_7ck1270 FIND v(dout1_7) AT=640.025n

.meas tran vdout1_8ck1270 FIND v(dout1_8) AT=640.025n

.meas tran vdout1_9ck1270 FIND v(dout1_9) AT=640.025n

.meas tran vdout1_10ck1270 FIND v(dout1_10) AT=640.025n

.meas tran vdout1_11ck1270 FIND v(dout1_11) AT=640.025n

.meas tran vdout1_12ck1270 FIND v(dout1_12) AT=640.025n

.meas tran vdout1_13ck1270 FIND v(dout1_13) AT=640.025n

.meas tran vdout1_14ck1270 FIND v(dout1_14) AT=640.025n

.meas tran vdout1_15ck1270 FIND v(dout1_15) AT=640.025n

.meas tran vdout1_16ck1270 FIND v(dout1_16) AT=640.025n

.meas tran vdout1_17ck1270 FIND v(dout1_17) AT=640.025n

.meas tran vdout1_18ck1270 FIND v(dout1_18) AT=640.025n

.meas tran vdout1_19ck1270 FIND v(dout1_19) AT=640.025n

.meas tran vdout1_20ck1270 FIND v(dout1_20) AT=640.025n

.meas tran vdout1_21ck1270 FIND v(dout1_21) AT=640.025n

.meas tran vdout1_22ck1270 FIND v(dout1_22) AT=640.025n

.meas tran vdout1_23ck1270 FIND v(dout1_23) AT=640.025n

.meas tran vdout1_24ck1270 FIND v(dout1_24) AT=640.025n

.meas tran vdout1_25ck1270 FIND v(dout1_25) AT=640.025n

.meas tran vdout1_26ck1270 FIND v(dout1_26) AT=640.025n

.meas tran vdout1_27ck1270 FIND v(dout1_27) AT=640.025n

.meas tran vdout1_28ck1270 FIND v(dout1_28) AT=640.025n

.meas tran vdout1_29ck1270 FIND v(dout1_29) AT=640.025n

.meas tran vdout1_30ck1270 FIND v(dout1_30) AT=640.025n

.meas tran vdout1_31ck1270 FIND v(dout1_31) AT=640.025n

.meas tran vdout1_32ck1270 FIND v(dout1_32) AT=640.025n

.meas tran vdout1_33ck1270 FIND v(dout1_33) AT=640.025n

.meas tran vdout1_34ck1270 FIND v(dout1_34) AT=640.025n

.meas tran vdout1_35ck1270 FIND v(dout1_35) AT=640.025n

.meas tran vdout1_36ck1270 FIND v(dout1_36) AT=640.025n

.meas tran vdout1_37ck1270 FIND v(dout1_37) AT=640.025n

.meas tran vdout1_38ck1270 FIND v(dout1_38) AT=640.025n

.meas tran vdout1_39ck1270 FIND v(dout1_39) AT=640.025n

.meas tran vdout1_40ck1270 FIND v(dout1_40) AT=640.025n

.meas tran vdout1_41ck1270 FIND v(dout1_41) AT=640.025n

.meas tran vdout1_42ck1270 FIND v(dout1_42) AT=640.025n

.meas tran vdout1_43ck1270 FIND v(dout1_43) AT=640.025n

.meas tran vdout1_44ck1270 FIND v(dout1_44) AT=640.025n

.meas tran vdout1_45ck1270 FIND v(dout1_45) AT=640.025n

.meas tran vdout1_46ck1270 FIND v(dout1_46) AT=640.025n

.meas tran vdout1_47ck1270 FIND v(dout1_47) AT=640.025n

.meas tran vdout1_48ck1270 FIND v(dout1_48) AT=640.025n

.meas tran vdout1_49ck1270 FIND v(dout1_49) AT=640.025n

.meas tran vdout1_50ck1270 FIND v(dout1_50) AT=640.025n

.meas tran vdout1_51ck1270 FIND v(dout1_51) AT=640.025n

.meas tran vdout1_52ck1270 FIND v(dout1_52) AT=640.025n

.meas tran vdout1_53ck1270 FIND v(dout1_53) AT=640.025n

.meas tran vdout1_54ck1270 FIND v(dout1_54) AT=640.025n

.meas tran vdout1_55ck1270 FIND v(dout1_55) AT=640.025n

.meas tran vdout1_56ck1270 FIND v(dout1_56) AT=640.025n

.meas tran vdout1_57ck1270 FIND v(dout1_57) AT=640.025n

.meas tran vdout1_58ck1270 FIND v(dout1_58) AT=640.025n

.meas tran vdout1_59ck1270 FIND v(dout1_59) AT=640.025n

.meas tran vdout1_60ck1270 FIND v(dout1_60) AT=640.025n

.meas tran vdout1_61ck1270 FIND v(dout1_61) AT=640.025n

.meas tran vdout1_62ck1270 FIND v(dout1_62) AT=640.025n

.meas tran vdout1_63ck1270 FIND v(dout1_63) AT=640.025n

.meas tran vdout1_64ck1270 FIND v(dout1_64) AT=640.025n

.meas tran vdout1_65ck1270 FIND v(dout1_65) AT=640.025n

.meas tran vdout1_66ck1270 FIND v(dout1_66) AT=640.025n

.meas tran vdout1_67ck1270 FIND v(dout1_67) AT=640.025n

.meas tran vdout1_68ck1270 FIND v(dout1_68) AT=640.025n

.meas tran vdout1_69ck1270 FIND v(dout1_69) AT=640.025n

.meas tran vdout1_70ck1270 FIND v(dout1_70) AT=640.025n

.meas tran vdout1_71ck1270 FIND v(dout1_71) AT=640.025n

.meas tran vdout1_72ck1270 FIND v(dout1_72) AT=640.025n

.meas tran vdout1_73ck1270 FIND v(dout1_73) AT=640.025n

.meas tran vdout1_74ck1270 FIND v(dout1_74) AT=640.025n

.meas tran vdout1_75ck1270 FIND v(dout1_75) AT=640.025n

.meas tran vdout1_76ck1270 FIND v(dout1_76) AT=640.025n

.meas tran vdout1_77ck1270 FIND v(dout1_77) AT=640.025n

.meas tran vdout1_78ck1270 FIND v(dout1_78) AT=640.025n

.meas tran vdout1_79ck1270 FIND v(dout1_79) AT=640.025n

.meas tran vdout1_80ck1270 FIND v(dout1_80) AT=640.025n

.meas tran vdout1_81ck1270 FIND v(dout1_81) AT=640.025n

.meas tran vdout1_82ck1270 FIND v(dout1_82) AT=640.025n

.meas tran vdout1_83ck1270 FIND v(dout1_83) AT=640.025n

.meas tran vdout1_84ck1270 FIND v(dout1_84) AT=640.025n

.meas tran vdout1_85ck1270 FIND v(dout1_85) AT=640.025n

.meas tran vdout1_86ck1270 FIND v(dout1_86) AT=640.025n

.meas tran vdout1_87ck1270 FIND v(dout1_87) AT=640.025n

.meas tran vdout1_88ck1270 FIND v(dout1_88) AT=640.025n

.meas tran vdout1_89ck1270 FIND v(dout1_89) AT=640.025n

.meas tran vdout1_90ck1270 FIND v(dout1_90) AT=640.025n

.meas tran vdout1_91ck1270 FIND v(dout1_91) AT=640.025n

.meas tran vdout1_92ck1270 FIND v(dout1_92) AT=640.025n

.meas tran vdout1_93ck1270 FIND v(dout1_93) AT=640.025n

.meas tran vdout1_94ck1270 FIND v(dout1_94) AT=640.025n

.meas tran vdout1_95ck1270 FIND v(dout1_95) AT=640.025n

.meas tran vdout1_96ck1270 FIND v(dout1_96) AT=640.025n

.meas tran vdout1_97ck1270 FIND v(dout1_97) AT=640.025n

.meas tran vdout1_98ck1270 FIND v(dout1_98) AT=640.025n

.meas tran vdout1_99ck1270 FIND v(dout1_99) AT=640.025n

.meas tran vdout1_100ck1270 FIND v(dout1_100) AT=640.025n

.meas tran vdout1_101ck1270 FIND v(dout1_101) AT=640.025n

.meas tran vdout1_102ck1270 FIND v(dout1_102) AT=640.025n

.meas tran vdout1_103ck1270 FIND v(dout1_103) AT=640.025n

.meas tran vdout1_104ck1270 FIND v(dout1_104) AT=640.025n

.meas tran vdout1_105ck1270 FIND v(dout1_105) AT=640.025n

.meas tran vdout1_106ck1270 FIND v(dout1_106) AT=640.025n

.meas tran vdout1_107ck1270 FIND v(dout1_107) AT=640.025n

.meas tran vdout1_108ck1270 FIND v(dout1_108) AT=640.025n

.meas tran vdout1_109ck1270 FIND v(dout1_109) AT=640.025n

.meas tran vdout1_110ck1270 FIND v(dout1_110) AT=640.025n

.meas tran vdout1_111ck1270 FIND v(dout1_111) AT=640.025n

.meas tran vdout1_112ck1270 FIND v(dout1_112) AT=640.025n

.meas tran vdout1_113ck1270 FIND v(dout1_113) AT=640.025n

.meas tran vdout1_114ck1270 FIND v(dout1_114) AT=640.025n

.meas tran vdout1_115ck1270 FIND v(dout1_115) AT=640.025n

.meas tran vdout1_116ck1270 FIND v(dout1_116) AT=640.025n

.meas tran vdout1_117ck1270 FIND v(dout1_117) AT=640.025n

.meas tran vdout1_118ck1270 FIND v(dout1_118) AT=640.025n

.meas tran vdout1_119ck1270 FIND v(dout1_119) AT=640.025n

.meas tran vdout1_120ck1270 FIND v(dout1_120) AT=640.025n

.meas tran vdout1_121ck1270 FIND v(dout1_121) AT=640.025n

.meas tran vdout1_122ck1270 FIND v(dout1_122) AT=640.025n

.meas tran vdout1_123ck1270 FIND v(dout1_123) AT=640.025n

.meas tran vdout1_124ck1270 FIND v(dout1_124) AT=640.025n

.meas tran vdout1_125ck1270 FIND v(dout1_125) AT=640.025n

.meas tran vdout1_126ck1270 FIND v(dout1_126) AT=640.025n

.meas tran vdout1_127ck1270 FIND v(dout1_127) AT=640.025n

.meas tran vdout1_0ck1290 FIND v(dout1_0) AT=650.025n

.meas tran vdout1_1ck1290 FIND v(dout1_1) AT=650.025n

.meas tran vdout1_2ck1290 FIND v(dout1_2) AT=650.025n

.meas tran vdout1_3ck1290 FIND v(dout1_3) AT=650.025n

.meas tran vdout1_4ck1290 FIND v(dout1_4) AT=650.025n

.meas tran vdout1_5ck1290 FIND v(dout1_5) AT=650.025n

.meas tran vdout1_6ck1290 FIND v(dout1_6) AT=650.025n

.meas tran vdout1_7ck1290 FIND v(dout1_7) AT=650.025n

.meas tran vdout1_8ck1290 FIND v(dout1_8) AT=650.025n

.meas tran vdout1_9ck1290 FIND v(dout1_9) AT=650.025n

.meas tran vdout1_10ck1290 FIND v(dout1_10) AT=650.025n

.meas tran vdout1_11ck1290 FIND v(dout1_11) AT=650.025n

.meas tran vdout1_12ck1290 FIND v(dout1_12) AT=650.025n

.meas tran vdout1_13ck1290 FIND v(dout1_13) AT=650.025n

.meas tran vdout1_14ck1290 FIND v(dout1_14) AT=650.025n

.meas tran vdout1_15ck1290 FIND v(dout1_15) AT=650.025n

.meas tran vdout1_16ck1290 FIND v(dout1_16) AT=650.025n

.meas tran vdout1_17ck1290 FIND v(dout1_17) AT=650.025n

.meas tran vdout1_18ck1290 FIND v(dout1_18) AT=650.025n

.meas tran vdout1_19ck1290 FIND v(dout1_19) AT=650.025n

.meas tran vdout1_20ck1290 FIND v(dout1_20) AT=650.025n

.meas tran vdout1_21ck1290 FIND v(dout1_21) AT=650.025n

.meas tran vdout1_22ck1290 FIND v(dout1_22) AT=650.025n

.meas tran vdout1_23ck1290 FIND v(dout1_23) AT=650.025n

.meas tran vdout1_24ck1290 FIND v(dout1_24) AT=650.025n

.meas tran vdout1_25ck1290 FIND v(dout1_25) AT=650.025n

.meas tran vdout1_26ck1290 FIND v(dout1_26) AT=650.025n

.meas tran vdout1_27ck1290 FIND v(dout1_27) AT=650.025n

.meas tran vdout1_28ck1290 FIND v(dout1_28) AT=650.025n

.meas tran vdout1_29ck1290 FIND v(dout1_29) AT=650.025n

.meas tran vdout1_30ck1290 FIND v(dout1_30) AT=650.025n

.meas tran vdout1_31ck1290 FIND v(dout1_31) AT=650.025n

.meas tran vdout1_32ck1290 FIND v(dout1_32) AT=650.025n

.meas tran vdout1_33ck1290 FIND v(dout1_33) AT=650.025n

.meas tran vdout1_34ck1290 FIND v(dout1_34) AT=650.025n

.meas tran vdout1_35ck1290 FIND v(dout1_35) AT=650.025n

.meas tran vdout1_36ck1290 FIND v(dout1_36) AT=650.025n

.meas tran vdout1_37ck1290 FIND v(dout1_37) AT=650.025n

.meas tran vdout1_38ck1290 FIND v(dout1_38) AT=650.025n

.meas tran vdout1_39ck1290 FIND v(dout1_39) AT=650.025n

.meas tran vdout1_40ck1290 FIND v(dout1_40) AT=650.025n

.meas tran vdout1_41ck1290 FIND v(dout1_41) AT=650.025n

.meas tran vdout1_42ck1290 FIND v(dout1_42) AT=650.025n

.meas tran vdout1_43ck1290 FIND v(dout1_43) AT=650.025n

.meas tran vdout1_44ck1290 FIND v(dout1_44) AT=650.025n

.meas tran vdout1_45ck1290 FIND v(dout1_45) AT=650.025n

.meas tran vdout1_46ck1290 FIND v(dout1_46) AT=650.025n

.meas tran vdout1_47ck1290 FIND v(dout1_47) AT=650.025n

.meas tran vdout1_48ck1290 FIND v(dout1_48) AT=650.025n

.meas tran vdout1_49ck1290 FIND v(dout1_49) AT=650.025n

.meas tran vdout1_50ck1290 FIND v(dout1_50) AT=650.025n

.meas tran vdout1_51ck1290 FIND v(dout1_51) AT=650.025n

.meas tran vdout1_52ck1290 FIND v(dout1_52) AT=650.025n

.meas tran vdout1_53ck1290 FIND v(dout1_53) AT=650.025n

.meas tran vdout1_54ck1290 FIND v(dout1_54) AT=650.025n

.meas tran vdout1_55ck1290 FIND v(dout1_55) AT=650.025n

.meas tran vdout1_56ck1290 FIND v(dout1_56) AT=650.025n

.meas tran vdout1_57ck1290 FIND v(dout1_57) AT=650.025n

.meas tran vdout1_58ck1290 FIND v(dout1_58) AT=650.025n

.meas tran vdout1_59ck1290 FIND v(dout1_59) AT=650.025n

.meas tran vdout1_60ck1290 FIND v(dout1_60) AT=650.025n

.meas tran vdout1_61ck1290 FIND v(dout1_61) AT=650.025n

.meas tran vdout1_62ck1290 FIND v(dout1_62) AT=650.025n

.meas tran vdout1_63ck1290 FIND v(dout1_63) AT=650.025n

.meas tran vdout1_64ck1290 FIND v(dout1_64) AT=650.025n

.meas tran vdout1_65ck1290 FIND v(dout1_65) AT=650.025n

.meas tran vdout1_66ck1290 FIND v(dout1_66) AT=650.025n

.meas tran vdout1_67ck1290 FIND v(dout1_67) AT=650.025n

.meas tran vdout1_68ck1290 FIND v(dout1_68) AT=650.025n

.meas tran vdout1_69ck1290 FIND v(dout1_69) AT=650.025n

.meas tran vdout1_70ck1290 FIND v(dout1_70) AT=650.025n

.meas tran vdout1_71ck1290 FIND v(dout1_71) AT=650.025n

.meas tran vdout1_72ck1290 FIND v(dout1_72) AT=650.025n

.meas tran vdout1_73ck1290 FIND v(dout1_73) AT=650.025n

.meas tran vdout1_74ck1290 FIND v(dout1_74) AT=650.025n

.meas tran vdout1_75ck1290 FIND v(dout1_75) AT=650.025n

.meas tran vdout1_76ck1290 FIND v(dout1_76) AT=650.025n

.meas tran vdout1_77ck1290 FIND v(dout1_77) AT=650.025n

.meas tran vdout1_78ck1290 FIND v(dout1_78) AT=650.025n

.meas tran vdout1_79ck1290 FIND v(dout1_79) AT=650.025n

.meas tran vdout1_80ck1290 FIND v(dout1_80) AT=650.025n

.meas tran vdout1_81ck1290 FIND v(dout1_81) AT=650.025n

.meas tran vdout1_82ck1290 FIND v(dout1_82) AT=650.025n

.meas tran vdout1_83ck1290 FIND v(dout1_83) AT=650.025n

.meas tran vdout1_84ck1290 FIND v(dout1_84) AT=650.025n

.meas tran vdout1_85ck1290 FIND v(dout1_85) AT=650.025n

.meas tran vdout1_86ck1290 FIND v(dout1_86) AT=650.025n

.meas tran vdout1_87ck1290 FIND v(dout1_87) AT=650.025n

.meas tran vdout1_88ck1290 FIND v(dout1_88) AT=650.025n

.meas tran vdout1_89ck1290 FIND v(dout1_89) AT=650.025n

.meas tran vdout1_90ck1290 FIND v(dout1_90) AT=650.025n

.meas tran vdout1_91ck1290 FIND v(dout1_91) AT=650.025n

.meas tran vdout1_92ck1290 FIND v(dout1_92) AT=650.025n

.meas tran vdout1_93ck1290 FIND v(dout1_93) AT=650.025n

.meas tran vdout1_94ck1290 FIND v(dout1_94) AT=650.025n

.meas tran vdout1_95ck1290 FIND v(dout1_95) AT=650.025n

.meas tran vdout1_96ck1290 FIND v(dout1_96) AT=650.025n

.meas tran vdout1_97ck1290 FIND v(dout1_97) AT=650.025n

.meas tran vdout1_98ck1290 FIND v(dout1_98) AT=650.025n

.meas tran vdout1_99ck1290 FIND v(dout1_99) AT=650.025n

.meas tran vdout1_100ck1290 FIND v(dout1_100) AT=650.025n

.meas tran vdout1_101ck1290 FIND v(dout1_101) AT=650.025n

.meas tran vdout1_102ck1290 FIND v(dout1_102) AT=650.025n

.meas tran vdout1_103ck1290 FIND v(dout1_103) AT=650.025n

.meas tran vdout1_104ck1290 FIND v(dout1_104) AT=650.025n

.meas tran vdout1_105ck1290 FIND v(dout1_105) AT=650.025n

.meas tran vdout1_106ck1290 FIND v(dout1_106) AT=650.025n

.meas tran vdout1_107ck1290 FIND v(dout1_107) AT=650.025n

.meas tran vdout1_108ck1290 FIND v(dout1_108) AT=650.025n

.meas tran vdout1_109ck1290 FIND v(dout1_109) AT=650.025n

.meas tran vdout1_110ck1290 FIND v(dout1_110) AT=650.025n

.meas tran vdout1_111ck1290 FIND v(dout1_111) AT=650.025n

.meas tran vdout1_112ck1290 FIND v(dout1_112) AT=650.025n

.meas tran vdout1_113ck1290 FIND v(dout1_113) AT=650.025n

.meas tran vdout1_114ck1290 FIND v(dout1_114) AT=650.025n

.meas tran vdout1_115ck1290 FIND v(dout1_115) AT=650.025n

.meas tran vdout1_116ck1290 FIND v(dout1_116) AT=650.025n

.meas tran vdout1_117ck1290 FIND v(dout1_117) AT=650.025n

.meas tran vdout1_118ck1290 FIND v(dout1_118) AT=650.025n

.meas tran vdout1_119ck1290 FIND v(dout1_119) AT=650.025n

.meas tran vdout1_120ck1290 FIND v(dout1_120) AT=650.025n

.meas tran vdout1_121ck1290 FIND v(dout1_121) AT=650.025n

.meas tran vdout1_122ck1290 FIND v(dout1_122) AT=650.025n

.meas tran vdout1_123ck1290 FIND v(dout1_123) AT=650.025n

.meas tran vdout1_124ck1290 FIND v(dout1_124) AT=650.025n

.meas tran vdout1_125ck1290 FIND v(dout1_125) AT=650.025n

.meas tran vdout1_126ck1290 FIND v(dout1_126) AT=650.025n

.meas tran vdout1_127ck1290 FIND v(dout1_127) AT=650.025n

.meas tran vdout1_0ck1310 FIND v(dout1_0) AT=660.025n

.meas tran vdout1_1ck1310 FIND v(dout1_1) AT=660.025n

.meas tran vdout1_2ck1310 FIND v(dout1_2) AT=660.025n

.meas tran vdout1_3ck1310 FIND v(dout1_3) AT=660.025n

.meas tran vdout1_4ck1310 FIND v(dout1_4) AT=660.025n

.meas tran vdout1_5ck1310 FIND v(dout1_5) AT=660.025n

.meas tran vdout1_6ck1310 FIND v(dout1_6) AT=660.025n

.meas tran vdout1_7ck1310 FIND v(dout1_7) AT=660.025n

.meas tran vdout1_8ck1310 FIND v(dout1_8) AT=660.025n

.meas tran vdout1_9ck1310 FIND v(dout1_9) AT=660.025n

.meas tran vdout1_10ck1310 FIND v(dout1_10) AT=660.025n

.meas tran vdout1_11ck1310 FIND v(dout1_11) AT=660.025n

.meas tran vdout1_12ck1310 FIND v(dout1_12) AT=660.025n

.meas tran vdout1_13ck1310 FIND v(dout1_13) AT=660.025n

.meas tran vdout1_14ck1310 FIND v(dout1_14) AT=660.025n

.meas tran vdout1_15ck1310 FIND v(dout1_15) AT=660.025n

.meas tran vdout1_16ck1310 FIND v(dout1_16) AT=660.025n

.meas tran vdout1_17ck1310 FIND v(dout1_17) AT=660.025n

.meas tran vdout1_18ck1310 FIND v(dout1_18) AT=660.025n

.meas tran vdout1_19ck1310 FIND v(dout1_19) AT=660.025n

.meas tran vdout1_20ck1310 FIND v(dout1_20) AT=660.025n

.meas tran vdout1_21ck1310 FIND v(dout1_21) AT=660.025n

.meas tran vdout1_22ck1310 FIND v(dout1_22) AT=660.025n

.meas tran vdout1_23ck1310 FIND v(dout1_23) AT=660.025n

.meas tran vdout1_24ck1310 FIND v(dout1_24) AT=660.025n

.meas tran vdout1_25ck1310 FIND v(dout1_25) AT=660.025n

.meas tran vdout1_26ck1310 FIND v(dout1_26) AT=660.025n

.meas tran vdout1_27ck1310 FIND v(dout1_27) AT=660.025n

.meas tran vdout1_28ck1310 FIND v(dout1_28) AT=660.025n

.meas tran vdout1_29ck1310 FIND v(dout1_29) AT=660.025n

.meas tran vdout1_30ck1310 FIND v(dout1_30) AT=660.025n

.meas tran vdout1_31ck1310 FIND v(dout1_31) AT=660.025n

.meas tran vdout1_32ck1310 FIND v(dout1_32) AT=660.025n

.meas tran vdout1_33ck1310 FIND v(dout1_33) AT=660.025n

.meas tran vdout1_34ck1310 FIND v(dout1_34) AT=660.025n

.meas tran vdout1_35ck1310 FIND v(dout1_35) AT=660.025n

.meas tran vdout1_36ck1310 FIND v(dout1_36) AT=660.025n

.meas tran vdout1_37ck1310 FIND v(dout1_37) AT=660.025n

.meas tran vdout1_38ck1310 FIND v(dout1_38) AT=660.025n

.meas tran vdout1_39ck1310 FIND v(dout1_39) AT=660.025n

.meas tran vdout1_40ck1310 FIND v(dout1_40) AT=660.025n

.meas tran vdout1_41ck1310 FIND v(dout1_41) AT=660.025n

.meas tran vdout1_42ck1310 FIND v(dout1_42) AT=660.025n

.meas tran vdout1_43ck1310 FIND v(dout1_43) AT=660.025n

.meas tran vdout1_44ck1310 FIND v(dout1_44) AT=660.025n

.meas tran vdout1_45ck1310 FIND v(dout1_45) AT=660.025n

.meas tran vdout1_46ck1310 FIND v(dout1_46) AT=660.025n

.meas tran vdout1_47ck1310 FIND v(dout1_47) AT=660.025n

.meas tran vdout1_48ck1310 FIND v(dout1_48) AT=660.025n

.meas tran vdout1_49ck1310 FIND v(dout1_49) AT=660.025n

.meas tran vdout1_50ck1310 FIND v(dout1_50) AT=660.025n

.meas tran vdout1_51ck1310 FIND v(dout1_51) AT=660.025n

.meas tran vdout1_52ck1310 FIND v(dout1_52) AT=660.025n

.meas tran vdout1_53ck1310 FIND v(dout1_53) AT=660.025n

.meas tran vdout1_54ck1310 FIND v(dout1_54) AT=660.025n

.meas tran vdout1_55ck1310 FIND v(dout1_55) AT=660.025n

.meas tran vdout1_56ck1310 FIND v(dout1_56) AT=660.025n

.meas tran vdout1_57ck1310 FIND v(dout1_57) AT=660.025n

.meas tran vdout1_58ck1310 FIND v(dout1_58) AT=660.025n

.meas tran vdout1_59ck1310 FIND v(dout1_59) AT=660.025n

.meas tran vdout1_60ck1310 FIND v(dout1_60) AT=660.025n

.meas tran vdout1_61ck1310 FIND v(dout1_61) AT=660.025n

.meas tran vdout1_62ck1310 FIND v(dout1_62) AT=660.025n

.meas tran vdout1_63ck1310 FIND v(dout1_63) AT=660.025n

.meas tran vdout1_64ck1310 FIND v(dout1_64) AT=660.025n

.meas tran vdout1_65ck1310 FIND v(dout1_65) AT=660.025n

.meas tran vdout1_66ck1310 FIND v(dout1_66) AT=660.025n

.meas tran vdout1_67ck1310 FIND v(dout1_67) AT=660.025n

.meas tran vdout1_68ck1310 FIND v(dout1_68) AT=660.025n

.meas tran vdout1_69ck1310 FIND v(dout1_69) AT=660.025n

.meas tran vdout1_70ck1310 FIND v(dout1_70) AT=660.025n

.meas tran vdout1_71ck1310 FIND v(dout1_71) AT=660.025n

.meas tran vdout1_72ck1310 FIND v(dout1_72) AT=660.025n

.meas tran vdout1_73ck1310 FIND v(dout1_73) AT=660.025n

.meas tran vdout1_74ck1310 FIND v(dout1_74) AT=660.025n

.meas tran vdout1_75ck1310 FIND v(dout1_75) AT=660.025n

.meas tran vdout1_76ck1310 FIND v(dout1_76) AT=660.025n

.meas tran vdout1_77ck1310 FIND v(dout1_77) AT=660.025n

.meas tran vdout1_78ck1310 FIND v(dout1_78) AT=660.025n

.meas tran vdout1_79ck1310 FIND v(dout1_79) AT=660.025n

.meas tran vdout1_80ck1310 FIND v(dout1_80) AT=660.025n

.meas tran vdout1_81ck1310 FIND v(dout1_81) AT=660.025n

.meas tran vdout1_82ck1310 FIND v(dout1_82) AT=660.025n

.meas tran vdout1_83ck1310 FIND v(dout1_83) AT=660.025n

.meas tran vdout1_84ck1310 FIND v(dout1_84) AT=660.025n

.meas tran vdout1_85ck1310 FIND v(dout1_85) AT=660.025n

.meas tran vdout1_86ck1310 FIND v(dout1_86) AT=660.025n

.meas tran vdout1_87ck1310 FIND v(dout1_87) AT=660.025n

.meas tran vdout1_88ck1310 FIND v(dout1_88) AT=660.025n

.meas tran vdout1_89ck1310 FIND v(dout1_89) AT=660.025n

.meas tran vdout1_90ck1310 FIND v(dout1_90) AT=660.025n

.meas tran vdout1_91ck1310 FIND v(dout1_91) AT=660.025n

.meas tran vdout1_92ck1310 FIND v(dout1_92) AT=660.025n

.meas tran vdout1_93ck1310 FIND v(dout1_93) AT=660.025n

.meas tran vdout1_94ck1310 FIND v(dout1_94) AT=660.025n

.meas tran vdout1_95ck1310 FIND v(dout1_95) AT=660.025n

.meas tran vdout1_96ck1310 FIND v(dout1_96) AT=660.025n

.meas tran vdout1_97ck1310 FIND v(dout1_97) AT=660.025n

.meas tran vdout1_98ck1310 FIND v(dout1_98) AT=660.025n

.meas tran vdout1_99ck1310 FIND v(dout1_99) AT=660.025n

.meas tran vdout1_100ck1310 FIND v(dout1_100) AT=660.025n

.meas tran vdout1_101ck1310 FIND v(dout1_101) AT=660.025n

.meas tran vdout1_102ck1310 FIND v(dout1_102) AT=660.025n

.meas tran vdout1_103ck1310 FIND v(dout1_103) AT=660.025n

.meas tran vdout1_104ck1310 FIND v(dout1_104) AT=660.025n

.meas tran vdout1_105ck1310 FIND v(dout1_105) AT=660.025n

.meas tran vdout1_106ck1310 FIND v(dout1_106) AT=660.025n

.meas tran vdout1_107ck1310 FIND v(dout1_107) AT=660.025n

.meas tran vdout1_108ck1310 FIND v(dout1_108) AT=660.025n

.meas tran vdout1_109ck1310 FIND v(dout1_109) AT=660.025n

.meas tran vdout1_110ck1310 FIND v(dout1_110) AT=660.025n

.meas tran vdout1_111ck1310 FIND v(dout1_111) AT=660.025n

.meas tran vdout1_112ck1310 FIND v(dout1_112) AT=660.025n

.meas tran vdout1_113ck1310 FIND v(dout1_113) AT=660.025n

.meas tran vdout1_114ck1310 FIND v(dout1_114) AT=660.025n

.meas tran vdout1_115ck1310 FIND v(dout1_115) AT=660.025n

.meas tran vdout1_116ck1310 FIND v(dout1_116) AT=660.025n

.meas tran vdout1_117ck1310 FIND v(dout1_117) AT=660.025n

.meas tran vdout1_118ck1310 FIND v(dout1_118) AT=660.025n

.meas tran vdout1_119ck1310 FIND v(dout1_119) AT=660.025n

.meas tran vdout1_120ck1310 FIND v(dout1_120) AT=660.025n

.meas tran vdout1_121ck1310 FIND v(dout1_121) AT=660.025n

.meas tran vdout1_122ck1310 FIND v(dout1_122) AT=660.025n

.meas tran vdout1_123ck1310 FIND v(dout1_123) AT=660.025n

.meas tran vdout1_124ck1310 FIND v(dout1_124) AT=660.025n

.meas tran vdout1_125ck1310 FIND v(dout1_125) AT=660.025n

.meas tran vdout1_126ck1310 FIND v(dout1_126) AT=660.025n

.meas tran vdout1_127ck1310 FIND v(dout1_127) AT=660.025n

.meas tran vdout1_0ck1320 FIND v(dout1_0) AT=665.025n

.meas tran vdout1_1ck1320 FIND v(dout1_1) AT=665.025n

.meas tran vdout1_2ck1320 FIND v(dout1_2) AT=665.025n

.meas tran vdout1_3ck1320 FIND v(dout1_3) AT=665.025n

.meas tran vdout1_4ck1320 FIND v(dout1_4) AT=665.025n

.meas tran vdout1_5ck1320 FIND v(dout1_5) AT=665.025n

.meas tran vdout1_6ck1320 FIND v(dout1_6) AT=665.025n

.meas tran vdout1_7ck1320 FIND v(dout1_7) AT=665.025n

.meas tran vdout1_8ck1320 FIND v(dout1_8) AT=665.025n

.meas tran vdout1_9ck1320 FIND v(dout1_9) AT=665.025n

.meas tran vdout1_10ck1320 FIND v(dout1_10) AT=665.025n

.meas tran vdout1_11ck1320 FIND v(dout1_11) AT=665.025n

.meas tran vdout1_12ck1320 FIND v(dout1_12) AT=665.025n

.meas tran vdout1_13ck1320 FIND v(dout1_13) AT=665.025n

.meas tran vdout1_14ck1320 FIND v(dout1_14) AT=665.025n

.meas tran vdout1_15ck1320 FIND v(dout1_15) AT=665.025n

.meas tran vdout1_16ck1320 FIND v(dout1_16) AT=665.025n

.meas tran vdout1_17ck1320 FIND v(dout1_17) AT=665.025n

.meas tran vdout1_18ck1320 FIND v(dout1_18) AT=665.025n

.meas tran vdout1_19ck1320 FIND v(dout1_19) AT=665.025n

.meas tran vdout1_20ck1320 FIND v(dout1_20) AT=665.025n

.meas tran vdout1_21ck1320 FIND v(dout1_21) AT=665.025n

.meas tran vdout1_22ck1320 FIND v(dout1_22) AT=665.025n

.meas tran vdout1_23ck1320 FIND v(dout1_23) AT=665.025n

.meas tran vdout1_24ck1320 FIND v(dout1_24) AT=665.025n

.meas tran vdout1_25ck1320 FIND v(dout1_25) AT=665.025n

.meas tran vdout1_26ck1320 FIND v(dout1_26) AT=665.025n

.meas tran vdout1_27ck1320 FIND v(dout1_27) AT=665.025n

.meas tran vdout1_28ck1320 FIND v(dout1_28) AT=665.025n

.meas tran vdout1_29ck1320 FIND v(dout1_29) AT=665.025n

.meas tran vdout1_30ck1320 FIND v(dout1_30) AT=665.025n

.meas tran vdout1_31ck1320 FIND v(dout1_31) AT=665.025n

.meas tran vdout1_32ck1320 FIND v(dout1_32) AT=665.025n

.meas tran vdout1_33ck1320 FIND v(dout1_33) AT=665.025n

.meas tran vdout1_34ck1320 FIND v(dout1_34) AT=665.025n

.meas tran vdout1_35ck1320 FIND v(dout1_35) AT=665.025n

.meas tran vdout1_36ck1320 FIND v(dout1_36) AT=665.025n

.meas tran vdout1_37ck1320 FIND v(dout1_37) AT=665.025n

.meas tran vdout1_38ck1320 FIND v(dout1_38) AT=665.025n

.meas tran vdout1_39ck1320 FIND v(dout1_39) AT=665.025n

.meas tran vdout1_40ck1320 FIND v(dout1_40) AT=665.025n

.meas tran vdout1_41ck1320 FIND v(dout1_41) AT=665.025n

.meas tran vdout1_42ck1320 FIND v(dout1_42) AT=665.025n

.meas tran vdout1_43ck1320 FIND v(dout1_43) AT=665.025n

.meas tran vdout1_44ck1320 FIND v(dout1_44) AT=665.025n

.meas tran vdout1_45ck1320 FIND v(dout1_45) AT=665.025n

.meas tran vdout1_46ck1320 FIND v(dout1_46) AT=665.025n

.meas tran vdout1_47ck1320 FIND v(dout1_47) AT=665.025n

.meas tran vdout1_48ck1320 FIND v(dout1_48) AT=665.025n

.meas tran vdout1_49ck1320 FIND v(dout1_49) AT=665.025n

.meas tran vdout1_50ck1320 FIND v(dout1_50) AT=665.025n

.meas tran vdout1_51ck1320 FIND v(dout1_51) AT=665.025n

.meas tran vdout1_52ck1320 FIND v(dout1_52) AT=665.025n

.meas tran vdout1_53ck1320 FIND v(dout1_53) AT=665.025n

.meas tran vdout1_54ck1320 FIND v(dout1_54) AT=665.025n

.meas tran vdout1_55ck1320 FIND v(dout1_55) AT=665.025n

.meas tran vdout1_56ck1320 FIND v(dout1_56) AT=665.025n

.meas tran vdout1_57ck1320 FIND v(dout1_57) AT=665.025n

.meas tran vdout1_58ck1320 FIND v(dout1_58) AT=665.025n

.meas tran vdout1_59ck1320 FIND v(dout1_59) AT=665.025n

.meas tran vdout1_60ck1320 FIND v(dout1_60) AT=665.025n

.meas tran vdout1_61ck1320 FIND v(dout1_61) AT=665.025n

.meas tran vdout1_62ck1320 FIND v(dout1_62) AT=665.025n

.meas tran vdout1_63ck1320 FIND v(dout1_63) AT=665.025n

.meas tran vdout1_64ck1320 FIND v(dout1_64) AT=665.025n

.meas tran vdout1_65ck1320 FIND v(dout1_65) AT=665.025n

.meas tran vdout1_66ck1320 FIND v(dout1_66) AT=665.025n

.meas tran vdout1_67ck1320 FIND v(dout1_67) AT=665.025n

.meas tran vdout1_68ck1320 FIND v(dout1_68) AT=665.025n

.meas tran vdout1_69ck1320 FIND v(dout1_69) AT=665.025n

.meas tran vdout1_70ck1320 FIND v(dout1_70) AT=665.025n

.meas tran vdout1_71ck1320 FIND v(dout1_71) AT=665.025n

.meas tran vdout1_72ck1320 FIND v(dout1_72) AT=665.025n

.meas tran vdout1_73ck1320 FIND v(dout1_73) AT=665.025n

.meas tran vdout1_74ck1320 FIND v(dout1_74) AT=665.025n

.meas tran vdout1_75ck1320 FIND v(dout1_75) AT=665.025n

.meas tran vdout1_76ck1320 FIND v(dout1_76) AT=665.025n

.meas tran vdout1_77ck1320 FIND v(dout1_77) AT=665.025n

.meas tran vdout1_78ck1320 FIND v(dout1_78) AT=665.025n

.meas tran vdout1_79ck1320 FIND v(dout1_79) AT=665.025n

.meas tran vdout1_80ck1320 FIND v(dout1_80) AT=665.025n

.meas tran vdout1_81ck1320 FIND v(dout1_81) AT=665.025n

.meas tran vdout1_82ck1320 FIND v(dout1_82) AT=665.025n

.meas tran vdout1_83ck1320 FIND v(dout1_83) AT=665.025n

.meas tran vdout1_84ck1320 FIND v(dout1_84) AT=665.025n

.meas tran vdout1_85ck1320 FIND v(dout1_85) AT=665.025n

.meas tran vdout1_86ck1320 FIND v(dout1_86) AT=665.025n

.meas tran vdout1_87ck1320 FIND v(dout1_87) AT=665.025n

.meas tran vdout1_88ck1320 FIND v(dout1_88) AT=665.025n

.meas tran vdout1_89ck1320 FIND v(dout1_89) AT=665.025n

.meas tran vdout1_90ck1320 FIND v(dout1_90) AT=665.025n

.meas tran vdout1_91ck1320 FIND v(dout1_91) AT=665.025n

.meas tran vdout1_92ck1320 FIND v(dout1_92) AT=665.025n

.meas tran vdout1_93ck1320 FIND v(dout1_93) AT=665.025n

.meas tran vdout1_94ck1320 FIND v(dout1_94) AT=665.025n

.meas tran vdout1_95ck1320 FIND v(dout1_95) AT=665.025n

.meas tran vdout1_96ck1320 FIND v(dout1_96) AT=665.025n

.meas tran vdout1_97ck1320 FIND v(dout1_97) AT=665.025n

.meas tran vdout1_98ck1320 FIND v(dout1_98) AT=665.025n

.meas tran vdout1_99ck1320 FIND v(dout1_99) AT=665.025n

.meas tran vdout1_100ck1320 FIND v(dout1_100) AT=665.025n

.meas tran vdout1_101ck1320 FIND v(dout1_101) AT=665.025n

.meas tran vdout1_102ck1320 FIND v(dout1_102) AT=665.025n

.meas tran vdout1_103ck1320 FIND v(dout1_103) AT=665.025n

.meas tran vdout1_104ck1320 FIND v(dout1_104) AT=665.025n

.meas tran vdout1_105ck1320 FIND v(dout1_105) AT=665.025n

.meas tran vdout1_106ck1320 FIND v(dout1_106) AT=665.025n

.meas tran vdout1_107ck1320 FIND v(dout1_107) AT=665.025n

.meas tran vdout1_108ck1320 FIND v(dout1_108) AT=665.025n

.meas tran vdout1_109ck1320 FIND v(dout1_109) AT=665.025n

.meas tran vdout1_110ck1320 FIND v(dout1_110) AT=665.025n

.meas tran vdout1_111ck1320 FIND v(dout1_111) AT=665.025n

.meas tran vdout1_112ck1320 FIND v(dout1_112) AT=665.025n

.meas tran vdout1_113ck1320 FIND v(dout1_113) AT=665.025n

.meas tran vdout1_114ck1320 FIND v(dout1_114) AT=665.025n

.meas tran vdout1_115ck1320 FIND v(dout1_115) AT=665.025n

.meas tran vdout1_116ck1320 FIND v(dout1_116) AT=665.025n

.meas tran vdout1_117ck1320 FIND v(dout1_117) AT=665.025n

.meas tran vdout1_118ck1320 FIND v(dout1_118) AT=665.025n

.meas tran vdout1_119ck1320 FIND v(dout1_119) AT=665.025n

.meas tran vdout1_120ck1320 FIND v(dout1_120) AT=665.025n

.meas tran vdout1_121ck1320 FIND v(dout1_121) AT=665.025n

.meas tran vdout1_122ck1320 FIND v(dout1_122) AT=665.025n

.meas tran vdout1_123ck1320 FIND v(dout1_123) AT=665.025n

.meas tran vdout1_124ck1320 FIND v(dout1_124) AT=665.025n

.meas tran vdout1_125ck1320 FIND v(dout1_125) AT=665.025n

.meas tran vdout1_126ck1320 FIND v(dout1_126) AT=665.025n

.meas tran vdout1_127ck1320 FIND v(dout1_127) AT=665.025n

.meas tran vdout1_0ck1330 FIND v(dout1_0) AT=670.025n

.meas tran vdout1_1ck1330 FIND v(dout1_1) AT=670.025n

.meas tran vdout1_2ck1330 FIND v(dout1_2) AT=670.025n

.meas tran vdout1_3ck1330 FIND v(dout1_3) AT=670.025n

.meas tran vdout1_4ck1330 FIND v(dout1_4) AT=670.025n

.meas tran vdout1_5ck1330 FIND v(dout1_5) AT=670.025n

.meas tran vdout1_6ck1330 FIND v(dout1_6) AT=670.025n

.meas tran vdout1_7ck1330 FIND v(dout1_7) AT=670.025n

.meas tran vdout1_8ck1330 FIND v(dout1_8) AT=670.025n

.meas tran vdout1_9ck1330 FIND v(dout1_9) AT=670.025n

.meas tran vdout1_10ck1330 FIND v(dout1_10) AT=670.025n

.meas tran vdout1_11ck1330 FIND v(dout1_11) AT=670.025n

.meas tran vdout1_12ck1330 FIND v(dout1_12) AT=670.025n

.meas tran vdout1_13ck1330 FIND v(dout1_13) AT=670.025n

.meas tran vdout1_14ck1330 FIND v(dout1_14) AT=670.025n

.meas tran vdout1_15ck1330 FIND v(dout1_15) AT=670.025n

.meas tran vdout1_16ck1330 FIND v(dout1_16) AT=670.025n

.meas tran vdout1_17ck1330 FIND v(dout1_17) AT=670.025n

.meas tran vdout1_18ck1330 FIND v(dout1_18) AT=670.025n

.meas tran vdout1_19ck1330 FIND v(dout1_19) AT=670.025n

.meas tran vdout1_20ck1330 FIND v(dout1_20) AT=670.025n

.meas tran vdout1_21ck1330 FIND v(dout1_21) AT=670.025n

.meas tran vdout1_22ck1330 FIND v(dout1_22) AT=670.025n

.meas tran vdout1_23ck1330 FIND v(dout1_23) AT=670.025n

.meas tran vdout1_24ck1330 FIND v(dout1_24) AT=670.025n

.meas tran vdout1_25ck1330 FIND v(dout1_25) AT=670.025n

.meas tran vdout1_26ck1330 FIND v(dout1_26) AT=670.025n

.meas tran vdout1_27ck1330 FIND v(dout1_27) AT=670.025n

.meas tran vdout1_28ck1330 FIND v(dout1_28) AT=670.025n

.meas tran vdout1_29ck1330 FIND v(dout1_29) AT=670.025n

.meas tran vdout1_30ck1330 FIND v(dout1_30) AT=670.025n

.meas tran vdout1_31ck1330 FIND v(dout1_31) AT=670.025n

.meas tran vdout1_32ck1330 FIND v(dout1_32) AT=670.025n

.meas tran vdout1_33ck1330 FIND v(dout1_33) AT=670.025n

.meas tran vdout1_34ck1330 FIND v(dout1_34) AT=670.025n

.meas tran vdout1_35ck1330 FIND v(dout1_35) AT=670.025n

.meas tran vdout1_36ck1330 FIND v(dout1_36) AT=670.025n

.meas tran vdout1_37ck1330 FIND v(dout1_37) AT=670.025n

.meas tran vdout1_38ck1330 FIND v(dout1_38) AT=670.025n

.meas tran vdout1_39ck1330 FIND v(dout1_39) AT=670.025n

.meas tran vdout1_40ck1330 FIND v(dout1_40) AT=670.025n

.meas tran vdout1_41ck1330 FIND v(dout1_41) AT=670.025n

.meas tran vdout1_42ck1330 FIND v(dout1_42) AT=670.025n

.meas tran vdout1_43ck1330 FIND v(dout1_43) AT=670.025n

.meas tran vdout1_44ck1330 FIND v(dout1_44) AT=670.025n

.meas tran vdout1_45ck1330 FIND v(dout1_45) AT=670.025n

.meas tran vdout1_46ck1330 FIND v(dout1_46) AT=670.025n

.meas tran vdout1_47ck1330 FIND v(dout1_47) AT=670.025n

.meas tran vdout1_48ck1330 FIND v(dout1_48) AT=670.025n

.meas tran vdout1_49ck1330 FIND v(dout1_49) AT=670.025n

.meas tran vdout1_50ck1330 FIND v(dout1_50) AT=670.025n

.meas tran vdout1_51ck1330 FIND v(dout1_51) AT=670.025n

.meas tran vdout1_52ck1330 FIND v(dout1_52) AT=670.025n

.meas tran vdout1_53ck1330 FIND v(dout1_53) AT=670.025n

.meas tran vdout1_54ck1330 FIND v(dout1_54) AT=670.025n

.meas tran vdout1_55ck1330 FIND v(dout1_55) AT=670.025n

.meas tran vdout1_56ck1330 FIND v(dout1_56) AT=670.025n

.meas tran vdout1_57ck1330 FIND v(dout1_57) AT=670.025n

.meas tran vdout1_58ck1330 FIND v(dout1_58) AT=670.025n

.meas tran vdout1_59ck1330 FIND v(dout1_59) AT=670.025n

.meas tran vdout1_60ck1330 FIND v(dout1_60) AT=670.025n

.meas tran vdout1_61ck1330 FIND v(dout1_61) AT=670.025n

.meas tran vdout1_62ck1330 FIND v(dout1_62) AT=670.025n

.meas tran vdout1_63ck1330 FIND v(dout1_63) AT=670.025n

.meas tran vdout1_64ck1330 FIND v(dout1_64) AT=670.025n

.meas tran vdout1_65ck1330 FIND v(dout1_65) AT=670.025n

.meas tran vdout1_66ck1330 FIND v(dout1_66) AT=670.025n

.meas tran vdout1_67ck1330 FIND v(dout1_67) AT=670.025n

.meas tran vdout1_68ck1330 FIND v(dout1_68) AT=670.025n

.meas tran vdout1_69ck1330 FIND v(dout1_69) AT=670.025n

.meas tran vdout1_70ck1330 FIND v(dout1_70) AT=670.025n

.meas tran vdout1_71ck1330 FIND v(dout1_71) AT=670.025n

.meas tran vdout1_72ck1330 FIND v(dout1_72) AT=670.025n

.meas tran vdout1_73ck1330 FIND v(dout1_73) AT=670.025n

.meas tran vdout1_74ck1330 FIND v(dout1_74) AT=670.025n

.meas tran vdout1_75ck1330 FIND v(dout1_75) AT=670.025n

.meas tran vdout1_76ck1330 FIND v(dout1_76) AT=670.025n

.meas tran vdout1_77ck1330 FIND v(dout1_77) AT=670.025n

.meas tran vdout1_78ck1330 FIND v(dout1_78) AT=670.025n

.meas tran vdout1_79ck1330 FIND v(dout1_79) AT=670.025n

.meas tran vdout1_80ck1330 FIND v(dout1_80) AT=670.025n

.meas tran vdout1_81ck1330 FIND v(dout1_81) AT=670.025n

.meas tran vdout1_82ck1330 FIND v(dout1_82) AT=670.025n

.meas tran vdout1_83ck1330 FIND v(dout1_83) AT=670.025n

.meas tran vdout1_84ck1330 FIND v(dout1_84) AT=670.025n

.meas tran vdout1_85ck1330 FIND v(dout1_85) AT=670.025n

.meas tran vdout1_86ck1330 FIND v(dout1_86) AT=670.025n

.meas tran vdout1_87ck1330 FIND v(dout1_87) AT=670.025n

.meas tran vdout1_88ck1330 FIND v(dout1_88) AT=670.025n

.meas tran vdout1_89ck1330 FIND v(dout1_89) AT=670.025n

.meas tran vdout1_90ck1330 FIND v(dout1_90) AT=670.025n

.meas tran vdout1_91ck1330 FIND v(dout1_91) AT=670.025n

.meas tran vdout1_92ck1330 FIND v(dout1_92) AT=670.025n

.meas tran vdout1_93ck1330 FIND v(dout1_93) AT=670.025n

.meas tran vdout1_94ck1330 FIND v(dout1_94) AT=670.025n

.meas tran vdout1_95ck1330 FIND v(dout1_95) AT=670.025n

.meas tran vdout1_96ck1330 FIND v(dout1_96) AT=670.025n

.meas tran vdout1_97ck1330 FIND v(dout1_97) AT=670.025n

.meas tran vdout1_98ck1330 FIND v(dout1_98) AT=670.025n

.meas tran vdout1_99ck1330 FIND v(dout1_99) AT=670.025n

.meas tran vdout1_100ck1330 FIND v(dout1_100) AT=670.025n

.meas tran vdout1_101ck1330 FIND v(dout1_101) AT=670.025n

.meas tran vdout1_102ck1330 FIND v(dout1_102) AT=670.025n

.meas tran vdout1_103ck1330 FIND v(dout1_103) AT=670.025n

.meas tran vdout1_104ck1330 FIND v(dout1_104) AT=670.025n

.meas tran vdout1_105ck1330 FIND v(dout1_105) AT=670.025n

.meas tran vdout1_106ck1330 FIND v(dout1_106) AT=670.025n

.meas tran vdout1_107ck1330 FIND v(dout1_107) AT=670.025n

.meas tran vdout1_108ck1330 FIND v(dout1_108) AT=670.025n

.meas tran vdout1_109ck1330 FIND v(dout1_109) AT=670.025n

.meas tran vdout1_110ck1330 FIND v(dout1_110) AT=670.025n

.meas tran vdout1_111ck1330 FIND v(dout1_111) AT=670.025n

.meas tran vdout1_112ck1330 FIND v(dout1_112) AT=670.025n

.meas tran vdout1_113ck1330 FIND v(dout1_113) AT=670.025n

.meas tran vdout1_114ck1330 FIND v(dout1_114) AT=670.025n

.meas tran vdout1_115ck1330 FIND v(dout1_115) AT=670.025n

.meas tran vdout1_116ck1330 FIND v(dout1_116) AT=670.025n

.meas tran vdout1_117ck1330 FIND v(dout1_117) AT=670.025n

.meas tran vdout1_118ck1330 FIND v(dout1_118) AT=670.025n

.meas tran vdout1_119ck1330 FIND v(dout1_119) AT=670.025n

.meas tran vdout1_120ck1330 FIND v(dout1_120) AT=670.025n

.meas tran vdout1_121ck1330 FIND v(dout1_121) AT=670.025n

.meas tran vdout1_122ck1330 FIND v(dout1_122) AT=670.025n

.meas tran vdout1_123ck1330 FIND v(dout1_123) AT=670.025n

.meas tran vdout1_124ck1330 FIND v(dout1_124) AT=670.025n

.meas tran vdout1_125ck1330 FIND v(dout1_125) AT=670.025n

.meas tran vdout1_126ck1330 FIND v(dout1_126) AT=670.025n

.meas tran vdout1_127ck1330 FIND v(dout1_127) AT=670.025n

.meas tran vdout1_0ck1350 FIND v(dout1_0) AT=680.025n

.meas tran vdout1_1ck1350 FIND v(dout1_1) AT=680.025n

.meas tran vdout1_2ck1350 FIND v(dout1_2) AT=680.025n

.meas tran vdout1_3ck1350 FIND v(dout1_3) AT=680.025n

.meas tran vdout1_4ck1350 FIND v(dout1_4) AT=680.025n

.meas tran vdout1_5ck1350 FIND v(dout1_5) AT=680.025n

.meas tran vdout1_6ck1350 FIND v(dout1_6) AT=680.025n

.meas tran vdout1_7ck1350 FIND v(dout1_7) AT=680.025n

.meas tran vdout1_8ck1350 FIND v(dout1_8) AT=680.025n

.meas tran vdout1_9ck1350 FIND v(dout1_9) AT=680.025n

.meas tran vdout1_10ck1350 FIND v(dout1_10) AT=680.025n

.meas tran vdout1_11ck1350 FIND v(dout1_11) AT=680.025n

.meas tran vdout1_12ck1350 FIND v(dout1_12) AT=680.025n

.meas tran vdout1_13ck1350 FIND v(dout1_13) AT=680.025n

.meas tran vdout1_14ck1350 FIND v(dout1_14) AT=680.025n

.meas tran vdout1_15ck1350 FIND v(dout1_15) AT=680.025n

.meas tran vdout1_16ck1350 FIND v(dout1_16) AT=680.025n

.meas tran vdout1_17ck1350 FIND v(dout1_17) AT=680.025n

.meas tran vdout1_18ck1350 FIND v(dout1_18) AT=680.025n

.meas tran vdout1_19ck1350 FIND v(dout1_19) AT=680.025n

.meas tran vdout1_20ck1350 FIND v(dout1_20) AT=680.025n

.meas tran vdout1_21ck1350 FIND v(dout1_21) AT=680.025n

.meas tran vdout1_22ck1350 FIND v(dout1_22) AT=680.025n

.meas tran vdout1_23ck1350 FIND v(dout1_23) AT=680.025n

.meas tran vdout1_24ck1350 FIND v(dout1_24) AT=680.025n

.meas tran vdout1_25ck1350 FIND v(dout1_25) AT=680.025n

.meas tran vdout1_26ck1350 FIND v(dout1_26) AT=680.025n

.meas tran vdout1_27ck1350 FIND v(dout1_27) AT=680.025n

.meas tran vdout1_28ck1350 FIND v(dout1_28) AT=680.025n

.meas tran vdout1_29ck1350 FIND v(dout1_29) AT=680.025n

.meas tran vdout1_30ck1350 FIND v(dout1_30) AT=680.025n

.meas tran vdout1_31ck1350 FIND v(dout1_31) AT=680.025n

.meas tran vdout1_32ck1350 FIND v(dout1_32) AT=680.025n

.meas tran vdout1_33ck1350 FIND v(dout1_33) AT=680.025n

.meas tran vdout1_34ck1350 FIND v(dout1_34) AT=680.025n

.meas tran vdout1_35ck1350 FIND v(dout1_35) AT=680.025n

.meas tran vdout1_36ck1350 FIND v(dout1_36) AT=680.025n

.meas tran vdout1_37ck1350 FIND v(dout1_37) AT=680.025n

.meas tran vdout1_38ck1350 FIND v(dout1_38) AT=680.025n

.meas tran vdout1_39ck1350 FIND v(dout1_39) AT=680.025n

.meas tran vdout1_40ck1350 FIND v(dout1_40) AT=680.025n

.meas tran vdout1_41ck1350 FIND v(dout1_41) AT=680.025n

.meas tran vdout1_42ck1350 FIND v(dout1_42) AT=680.025n

.meas tran vdout1_43ck1350 FIND v(dout1_43) AT=680.025n

.meas tran vdout1_44ck1350 FIND v(dout1_44) AT=680.025n

.meas tran vdout1_45ck1350 FIND v(dout1_45) AT=680.025n

.meas tran vdout1_46ck1350 FIND v(dout1_46) AT=680.025n

.meas tran vdout1_47ck1350 FIND v(dout1_47) AT=680.025n

.meas tran vdout1_48ck1350 FIND v(dout1_48) AT=680.025n

.meas tran vdout1_49ck1350 FIND v(dout1_49) AT=680.025n

.meas tran vdout1_50ck1350 FIND v(dout1_50) AT=680.025n

.meas tran vdout1_51ck1350 FIND v(dout1_51) AT=680.025n

.meas tran vdout1_52ck1350 FIND v(dout1_52) AT=680.025n

.meas tran vdout1_53ck1350 FIND v(dout1_53) AT=680.025n

.meas tran vdout1_54ck1350 FIND v(dout1_54) AT=680.025n

.meas tran vdout1_55ck1350 FIND v(dout1_55) AT=680.025n

.meas tran vdout1_56ck1350 FIND v(dout1_56) AT=680.025n

.meas tran vdout1_57ck1350 FIND v(dout1_57) AT=680.025n

.meas tran vdout1_58ck1350 FIND v(dout1_58) AT=680.025n

.meas tran vdout1_59ck1350 FIND v(dout1_59) AT=680.025n

.meas tran vdout1_60ck1350 FIND v(dout1_60) AT=680.025n

.meas tran vdout1_61ck1350 FIND v(dout1_61) AT=680.025n

.meas tran vdout1_62ck1350 FIND v(dout1_62) AT=680.025n

.meas tran vdout1_63ck1350 FIND v(dout1_63) AT=680.025n

.meas tran vdout1_64ck1350 FIND v(dout1_64) AT=680.025n

.meas tran vdout1_65ck1350 FIND v(dout1_65) AT=680.025n

.meas tran vdout1_66ck1350 FIND v(dout1_66) AT=680.025n

.meas tran vdout1_67ck1350 FIND v(dout1_67) AT=680.025n

.meas tran vdout1_68ck1350 FIND v(dout1_68) AT=680.025n

.meas tran vdout1_69ck1350 FIND v(dout1_69) AT=680.025n

.meas tran vdout1_70ck1350 FIND v(dout1_70) AT=680.025n

.meas tran vdout1_71ck1350 FIND v(dout1_71) AT=680.025n

.meas tran vdout1_72ck1350 FIND v(dout1_72) AT=680.025n

.meas tran vdout1_73ck1350 FIND v(dout1_73) AT=680.025n

.meas tran vdout1_74ck1350 FIND v(dout1_74) AT=680.025n

.meas tran vdout1_75ck1350 FIND v(dout1_75) AT=680.025n

.meas tran vdout1_76ck1350 FIND v(dout1_76) AT=680.025n

.meas tran vdout1_77ck1350 FIND v(dout1_77) AT=680.025n

.meas tran vdout1_78ck1350 FIND v(dout1_78) AT=680.025n

.meas tran vdout1_79ck1350 FIND v(dout1_79) AT=680.025n

.meas tran vdout1_80ck1350 FIND v(dout1_80) AT=680.025n

.meas tran vdout1_81ck1350 FIND v(dout1_81) AT=680.025n

.meas tran vdout1_82ck1350 FIND v(dout1_82) AT=680.025n

.meas tran vdout1_83ck1350 FIND v(dout1_83) AT=680.025n

.meas tran vdout1_84ck1350 FIND v(dout1_84) AT=680.025n

.meas tran vdout1_85ck1350 FIND v(dout1_85) AT=680.025n

.meas tran vdout1_86ck1350 FIND v(dout1_86) AT=680.025n

.meas tran vdout1_87ck1350 FIND v(dout1_87) AT=680.025n

.meas tran vdout1_88ck1350 FIND v(dout1_88) AT=680.025n

.meas tran vdout1_89ck1350 FIND v(dout1_89) AT=680.025n

.meas tran vdout1_90ck1350 FIND v(dout1_90) AT=680.025n

.meas tran vdout1_91ck1350 FIND v(dout1_91) AT=680.025n

.meas tran vdout1_92ck1350 FIND v(dout1_92) AT=680.025n

.meas tran vdout1_93ck1350 FIND v(dout1_93) AT=680.025n

.meas tran vdout1_94ck1350 FIND v(dout1_94) AT=680.025n

.meas tran vdout1_95ck1350 FIND v(dout1_95) AT=680.025n

.meas tran vdout1_96ck1350 FIND v(dout1_96) AT=680.025n

.meas tran vdout1_97ck1350 FIND v(dout1_97) AT=680.025n

.meas tran vdout1_98ck1350 FIND v(dout1_98) AT=680.025n

.meas tran vdout1_99ck1350 FIND v(dout1_99) AT=680.025n

.meas tran vdout1_100ck1350 FIND v(dout1_100) AT=680.025n

.meas tran vdout1_101ck1350 FIND v(dout1_101) AT=680.025n

.meas tran vdout1_102ck1350 FIND v(dout1_102) AT=680.025n

.meas tran vdout1_103ck1350 FIND v(dout1_103) AT=680.025n

.meas tran vdout1_104ck1350 FIND v(dout1_104) AT=680.025n

.meas tran vdout1_105ck1350 FIND v(dout1_105) AT=680.025n

.meas tran vdout1_106ck1350 FIND v(dout1_106) AT=680.025n

.meas tran vdout1_107ck1350 FIND v(dout1_107) AT=680.025n

.meas tran vdout1_108ck1350 FIND v(dout1_108) AT=680.025n

.meas tran vdout1_109ck1350 FIND v(dout1_109) AT=680.025n

.meas tran vdout1_110ck1350 FIND v(dout1_110) AT=680.025n

.meas tran vdout1_111ck1350 FIND v(dout1_111) AT=680.025n

.meas tran vdout1_112ck1350 FIND v(dout1_112) AT=680.025n

.meas tran vdout1_113ck1350 FIND v(dout1_113) AT=680.025n

.meas tran vdout1_114ck1350 FIND v(dout1_114) AT=680.025n

.meas tran vdout1_115ck1350 FIND v(dout1_115) AT=680.025n

.meas tran vdout1_116ck1350 FIND v(dout1_116) AT=680.025n

.meas tran vdout1_117ck1350 FIND v(dout1_117) AT=680.025n

.meas tran vdout1_118ck1350 FIND v(dout1_118) AT=680.025n

.meas tran vdout1_119ck1350 FIND v(dout1_119) AT=680.025n

.meas tran vdout1_120ck1350 FIND v(dout1_120) AT=680.025n

.meas tran vdout1_121ck1350 FIND v(dout1_121) AT=680.025n

.meas tran vdout1_122ck1350 FIND v(dout1_122) AT=680.025n

.meas tran vdout1_123ck1350 FIND v(dout1_123) AT=680.025n

.meas tran vdout1_124ck1350 FIND v(dout1_124) AT=680.025n

.meas tran vdout1_125ck1350 FIND v(dout1_125) AT=680.025n

.meas tran vdout1_126ck1350 FIND v(dout1_126) AT=680.025n

.meas tran vdout1_127ck1350 FIND v(dout1_127) AT=680.025n

.meas tran vdout1_0ck1370 FIND v(dout1_0) AT=690.025n

.meas tran vdout1_1ck1370 FIND v(dout1_1) AT=690.025n

.meas tran vdout1_2ck1370 FIND v(dout1_2) AT=690.025n

.meas tran vdout1_3ck1370 FIND v(dout1_3) AT=690.025n

.meas tran vdout1_4ck1370 FIND v(dout1_4) AT=690.025n

.meas tran vdout1_5ck1370 FIND v(dout1_5) AT=690.025n

.meas tran vdout1_6ck1370 FIND v(dout1_6) AT=690.025n

.meas tran vdout1_7ck1370 FIND v(dout1_7) AT=690.025n

.meas tran vdout1_8ck1370 FIND v(dout1_8) AT=690.025n

.meas tran vdout1_9ck1370 FIND v(dout1_9) AT=690.025n

.meas tran vdout1_10ck1370 FIND v(dout1_10) AT=690.025n

.meas tran vdout1_11ck1370 FIND v(dout1_11) AT=690.025n

.meas tran vdout1_12ck1370 FIND v(dout1_12) AT=690.025n

.meas tran vdout1_13ck1370 FIND v(dout1_13) AT=690.025n

.meas tran vdout1_14ck1370 FIND v(dout1_14) AT=690.025n

.meas tran vdout1_15ck1370 FIND v(dout1_15) AT=690.025n

.meas tran vdout1_16ck1370 FIND v(dout1_16) AT=690.025n

.meas tran vdout1_17ck1370 FIND v(dout1_17) AT=690.025n

.meas tran vdout1_18ck1370 FIND v(dout1_18) AT=690.025n

.meas tran vdout1_19ck1370 FIND v(dout1_19) AT=690.025n

.meas tran vdout1_20ck1370 FIND v(dout1_20) AT=690.025n

.meas tran vdout1_21ck1370 FIND v(dout1_21) AT=690.025n

.meas tran vdout1_22ck1370 FIND v(dout1_22) AT=690.025n

.meas tran vdout1_23ck1370 FIND v(dout1_23) AT=690.025n

.meas tran vdout1_24ck1370 FIND v(dout1_24) AT=690.025n

.meas tran vdout1_25ck1370 FIND v(dout1_25) AT=690.025n

.meas tran vdout1_26ck1370 FIND v(dout1_26) AT=690.025n

.meas tran vdout1_27ck1370 FIND v(dout1_27) AT=690.025n

.meas tran vdout1_28ck1370 FIND v(dout1_28) AT=690.025n

.meas tran vdout1_29ck1370 FIND v(dout1_29) AT=690.025n

.meas tran vdout1_30ck1370 FIND v(dout1_30) AT=690.025n

.meas tran vdout1_31ck1370 FIND v(dout1_31) AT=690.025n

.meas tran vdout1_32ck1370 FIND v(dout1_32) AT=690.025n

.meas tran vdout1_33ck1370 FIND v(dout1_33) AT=690.025n

.meas tran vdout1_34ck1370 FIND v(dout1_34) AT=690.025n

.meas tran vdout1_35ck1370 FIND v(dout1_35) AT=690.025n

.meas tran vdout1_36ck1370 FIND v(dout1_36) AT=690.025n

.meas tran vdout1_37ck1370 FIND v(dout1_37) AT=690.025n

.meas tran vdout1_38ck1370 FIND v(dout1_38) AT=690.025n

.meas tran vdout1_39ck1370 FIND v(dout1_39) AT=690.025n

.meas tran vdout1_40ck1370 FIND v(dout1_40) AT=690.025n

.meas tran vdout1_41ck1370 FIND v(dout1_41) AT=690.025n

.meas tran vdout1_42ck1370 FIND v(dout1_42) AT=690.025n

.meas tran vdout1_43ck1370 FIND v(dout1_43) AT=690.025n

.meas tran vdout1_44ck1370 FIND v(dout1_44) AT=690.025n

.meas tran vdout1_45ck1370 FIND v(dout1_45) AT=690.025n

.meas tran vdout1_46ck1370 FIND v(dout1_46) AT=690.025n

.meas tran vdout1_47ck1370 FIND v(dout1_47) AT=690.025n

.meas tran vdout1_48ck1370 FIND v(dout1_48) AT=690.025n

.meas tran vdout1_49ck1370 FIND v(dout1_49) AT=690.025n

.meas tran vdout1_50ck1370 FIND v(dout1_50) AT=690.025n

.meas tran vdout1_51ck1370 FIND v(dout1_51) AT=690.025n

.meas tran vdout1_52ck1370 FIND v(dout1_52) AT=690.025n

.meas tran vdout1_53ck1370 FIND v(dout1_53) AT=690.025n

.meas tran vdout1_54ck1370 FIND v(dout1_54) AT=690.025n

.meas tran vdout1_55ck1370 FIND v(dout1_55) AT=690.025n

.meas tran vdout1_56ck1370 FIND v(dout1_56) AT=690.025n

.meas tran vdout1_57ck1370 FIND v(dout1_57) AT=690.025n

.meas tran vdout1_58ck1370 FIND v(dout1_58) AT=690.025n

.meas tran vdout1_59ck1370 FIND v(dout1_59) AT=690.025n

.meas tran vdout1_60ck1370 FIND v(dout1_60) AT=690.025n

.meas tran vdout1_61ck1370 FIND v(dout1_61) AT=690.025n

.meas tran vdout1_62ck1370 FIND v(dout1_62) AT=690.025n

.meas tran vdout1_63ck1370 FIND v(dout1_63) AT=690.025n

.meas tran vdout1_64ck1370 FIND v(dout1_64) AT=690.025n

.meas tran vdout1_65ck1370 FIND v(dout1_65) AT=690.025n

.meas tran vdout1_66ck1370 FIND v(dout1_66) AT=690.025n

.meas tran vdout1_67ck1370 FIND v(dout1_67) AT=690.025n

.meas tran vdout1_68ck1370 FIND v(dout1_68) AT=690.025n

.meas tran vdout1_69ck1370 FIND v(dout1_69) AT=690.025n

.meas tran vdout1_70ck1370 FIND v(dout1_70) AT=690.025n

.meas tran vdout1_71ck1370 FIND v(dout1_71) AT=690.025n

.meas tran vdout1_72ck1370 FIND v(dout1_72) AT=690.025n

.meas tran vdout1_73ck1370 FIND v(dout1_73) AT=690.025n

.meas tran vdout1_74ck1370 FIND v(dout1_74) AT=690.025n

.meas tran vdout1_75ck1370 FIND v(dout1_75) AT=690.025n

.meas tran vdout1_76ck1370 FIND v(dout1_76) AT=690.025n

.meas tran vdout1_77ck1370 FIND v(dout1_77) AT=690.025n

.meas tran vdout1_78ck1370 FIND v(dout1_78) AT=690.025n

.meas tran vdout1_79ck1370 FIND v(dout1_79) AT=690.025n

.meas tran vdout1_80ck1370 FIND v(dout1_80) AT=690.025n

.meas tran vdout1_81ck1370 FIND v(dout1_81) AT=690.025n

.meas tran vdout1_82ck1370 FIND v(dout1_82) AT=690.025n

.meas tran vdout1_83ck1370 FIND v(dout1_83) AT=690.025n

.meas tran vdout1_84ck1370 FIND v(dout1_84) AT=690.025n

.meas tran vdout1_85ck1370 FIND v(dout1_85) AT=690.025n

.meas tran vdout1_86ck1370 FIND v(dout1_86) AT=690.025n

.meas tran vdout1_87ck1370 FIND v(dout1_87) AT=690.025n

.meas tran vdout1_88ck1370 FIND v(dout1_88) AT=690.025n

.meas tran vdout1_89ck1370 FIND v(dout1_89) AT=690.025n

.meas tran vdout1_90ck1370 FIND v(dout1_90) AT=690.025n

.meas tran vdout1_91ck1370 FIND v(dout1_91) AT=690.025n

.meas tran vdout1_92ck1370 FIND v(dout1_92) AT=690.025n

.meas tran vdout1_93ck1370 FIND v(dout1_93) AT=690.025n

.meas tran vdout1_94ck1370 FIND v(dout1_94) AT=690.025n

.meas tran vdout1_95ck1370 FIND v(dout1_95) AT=690.025n

.meas tran vdout1_96ck1370 FIND v(dout1_96) AT=690.025n

.meas tran vdout1_97ck1370 FIND v(dout1_97) AT=690.025n

.meas tran vdout1_98ck1370 FIND v(dout1_98) AT=690.025n

.meas tran vdout1_99ck1370 FIND v(dout1_99) AT=690.025n

.meas tran vdout1_100ck1370 FIND v(dout1_100) AT=690.025n

.meas tran vdout1_101ck1370 FIND v(dout1_101) AT=690.025n

.meas tran vdout1_102ck1370 FIND v(dout1_102) AT=690.025n

.meas tran vdout1_103ck1370 FIND v(dout1_103) AT=690.025n

.meas tran vdout1_104ck1370 FIND v(dout1_104) AT=690.025n

.meas tran vdout1_105ck1370 FIND v(dout1_105) AT=690.025n

.meas tran vdout1_106ck1370 FIND v(dout1_106) AT=690.025n

.meas tran vdout1_107ck1370 FIND v(dout1_107) AT=690.025n

.meas tran vdout1_108ck1370 FIND v(dout1_108) AT=690.025n

.meas tran vdout1_109ck1370 FIND v(dout1_109) AT=690.025n

.meas tran vdout1_110ck1370 FIND v(dout1_110) AT=690.025n

.meas tran vdout1_111ck1370 FIND v(dout1_111) AT=690.025n

.meas tran vdout1_112ck1370 FIND v(dout1_112) AT=690.025n

.meas tran vdout1_113ck1370 FIND v(dout1_113) AT=690.025n

.meas tran vdout1_114ck1370 FIND v(dout1_114) AT=690.025n

.meas tran vdout1_115ck1370 FIND v(dout1_115) AT=690.025n

.meas tran vdout1_116ck1370 FIND v(dout1_116) AT=690.025n

.meas tran vdout1_117ck1370 FIND v(dout1_117) AT=690.025n

.meas tran vdout1_118ck1370 FIND v(dout1_118) AT=690.025n

.meas tran vdout1_119ck1370 FIND v(dout1_119) AT=690.025n

.meas tran vdout1_120ck1370 FIND v(dout1_120) AT=690.025n

.meas tran vdout1_121ck1370 FIND v(dout1_121) AT=690.025n

.meas tran vdout1_122ck1370 FIND v(dout1_122) AT=690.025n

.meas tran vdout1_123ck1370 FIND v(dout1_123) AT=690.025n

.meas tran vdout1_124ck1370 FIND v(dout1_124) AT=690.025n

.meas tran vdout1_125ck1370 FIND v(dout1_125) AT=690.025n

.meas tran vdout1_126ck1370 FIND v(dout1_126) AT=690.025n

.meas tran vdout1_127ck1370 FIND v(dout1_127) AT=690.025n

.meas tran vdout1_0ck1390 FIND v(dout1_0) AT=700.025n

.meas tran vdout1_1ck1390 FIND v(dout1_1) AT=700.025n

.meas tran vdout1_2ck1390 FIND v(dout1_2) AT=700.025n

.meas tran vdout1_3ck1390 FIND v(dout1_3) AT=700.025n

.meas tran vdout1_4ck1390 FIND v(dout1_4) AT=700.025n

.meas tran vdout1_5ck1390 FIND v(dout1_5) AT=700.025n

.meas tran vdout1_6ck1390 FIND v(dout1_6) AT=700.025n

.meas tran vdout1_7ck1390 FIND v(dout1_7) AT=700.025n

.meas tran vdout1_8ck1390 FIND v(dout1_8) AT=700.025n

.meas tran vdout1_9ck1390 FIND v(dout1_9) AT=700.025n

.meas tran vdout1_10ck1390 FIND v(dout1_10) AT=700.025n

.meas tran vdout1_11ck1390 FIND v(dout1_11) AT=700.025n

.meas tran vdout1_12ck1390 FIND v(dout1_12) AT=700.025n

.meas tran vdout1_13ck1390 FIND v(dout1_13) AT=700.025n

.meas tran vdout1_14ck1390 FIND v(dout1_14) AT=700.025n

.meas tran vdout1_15ck1390 FIND v(dout1_15) AT=700.025n

.meas tran vdout1_16ck1390 FIND v(dout1_16) AT=700.025n

.meas tran vdout1_17ck1390 FIND v(dout1_17) AT=700.025n

.meas tran vdout1_18ck1390 FIND v(dout1_18) AT=700.025n

.meas tran vdout1_19ck1390 FIND v(dout1_19) AT=700.025n

.meas tran vdout1_20ck1390 FIND v(dout1_20) AT=700.025n

.meas tran vdout1_21ck1390 FIND v(dout1_21) AT=700.025n

.meas tran vdout1_22ck1390 FIND v(dout1_22) AT=700.025n

.meas tran vdout1_23ck1390 FIND v(dout1_23) AT=700.025n

.meas tran vdout1_24ck1390 FIND v(dout1_24) AT=700.025n

.meas tran vdout1_25ck1390 FIND v(dout1_25) AT=700.025n

.meas tran vdout1_26ck1390 FIND v(dout1_26) AT=700.025n

.meas tran vdout1_27ck1390 FIND v(dout1_27) AT=700.025n

.meas tran vdout1_28ck1390 FIND v(dout1_28) AT=700.025n

.meas tran vdout1_29ck1390 FIND v(dout1_29) AT=700.025n

.meas tran vdout1_30ck1390 FIND v(dout1_30) AT=700.025n

.meas tran vdout1_31ck1390 FIND v(dout1_31) AT=700.025n

.meas tran vdout1_32ck1390 FIND v(dout1_32) AT=700.025n

.meas tran vdout1_33ck1390 FIND v(dout1_33) AT=700.025n

.meas tran vdout1_34ck1390 FIND v(dout1_34) AT=700.025n

.meas tran vdout1_35ck1390 FIND v(dout1_35) AT=700.025n

.meas tran vdout1_36ck1390 FIND v(dout1_36) AT=700.025n

.meas tran vdout1_37ck1390 FIND v(dout1_37) AT=700.025n

.meas tran vdout1_38ck1390 FIND v(dout1_38) AT=700.025n

.meas tran vdout1_39ck1390 FIND v(dout1_39) AT=700.025n

.meas tran vdout1_40ck1390 FIND v(dout1_40) AT=700.025n

.meas tran vdout1_41ck1390 FIND v(dout1_41) AT=700.025n

.meas tran vdout1_42ck1390 FIND v(dout1_42) AT=700.025n

.meas tran vdout1_43ck1390 FIND v(dout1_43) AT=700.025n

.meas tran vdout1_44ck1390 FIND v(dout1_44) AT=700.025n

.meas tran vdout1_45ck1390 FIND v(dout1_45) AT=700.025n

.meas tran vdout1_46ck1390 FIND v(dout1_46) AT=700.025n

.meas tran vdout1_47ck1390 FIND v(dout1_47) AT=700.025n

.meas tran vdout1_48ck1390 FIND v(dout1_48) AT=700.025n

.meas tran vdout1_49ck1390 FIND v(dout1_49) AT=700.025n

.meas tran vdout1_50ck1390 FIND v(dout1_50) AT=700.025n

.meas tran vdout1_51ck1390 FIND v(dout1_51) AT=700.025n

.meas tran vdout1_52ck1390 FIND v(dout1_52) AT=700.025n

.meas tran vdout1_53ck1390 FIND v(dout1_53) AT=700.025n

.meas tran vdout1_54ck1390 FIND v(dout1_54) AT=700.025n

.meas tran vdout1_55ck1390 FIND v(dout1_55) AT=700.025n

.meas tran vdout1_56ck1390 FIND v(dout1_56) AT=700.025n

.meas tran vdout1_57ck1390 FIND v(dout1_57) AT=700.025n

.meas tran vdout1_58ck1390 FIND v(dout1_58) AT=700.025n

.meas tran vdout1_59ck1390 FIND v(dout1_59) AT=700.025n

.meas tran vdout1_60ck1390 FIND v(dout1_60) AT=700.025n

.meas tran vdout1_61ck1390 FIND v(dout1_61) AT=700.025n

.meas tran vdout1_62ck1390 FIND v(dout1_62) AT=700.025n

.meas tran vdout1_63ck1390 FIND v(dout1_63) AT=700.025n

.meas tran vdout1_64ck1390 FIND v(dout1_64) AT=700.025n

.meas tran vdout1_65ck1390 FIND v(dout1_65) AT=700.025n

.meas tran vdout1_66ck1390 FIND v(dout1_66) AT=700.025n

.meas tran vdout1_67ck1390 FIND v(dout1_67) AT=700.025n

.meas tran vdout1_68ck1390 FIND v(dout1_68) AT=700.025n

.meas tran vdout1_69ck1390 FIND v(dout1_69) AT=700.025n

.meas tran vdout1_70ck1390 FIND v(dout1_70) AT=700.025n

.meas tran vdout1_71ck1390 FIND v(dout1_71) AT=700.025n

.meas tran vdout1_72ck1390 FIND v(dout1_72) AT=700.025n

.meas tran vdout1_73ck1390 FIND v(dout1_73) AT=700.025n

.meas tran vdout1_74ck1390 FIND v(dout1_74) AT=700.025n

.meas tran vdout1_75ck1390 FIND v(dout1_75) AT=700.025n

.meas tran vdout1_76ck1390 FIND v(dout1_76) AT=700.025n

.meas tran vdout1_77ck1390 FIND v(dout1_77) AT=700.025n

.meas tran vdout1_78ck1390 FIND v(dout1_78) AT=700.025n

.meas tran vdout1_79ck1390 FIND v(dout1_79) AT=700.025n

.meas tran vdout1_80ck1390 FIND v(dout1_80) AT=700.025n

.meas tran vdout1_81ck1390 FIND v(dout1_81) AT=700.025n

.meas tran vdout1_82ck1390 FIND v(dout1_82) AT=700.025n

.meas tran vdout1_83ck1390 FIND v(dout1_83) AT=700.025n

.meas tran vdout1_84ck1390 FIND v(dout1_84) AT=700.025n

.meas tran vdout1_85ck1390 FIND v(dout1_85) AT=700.025n

.meas tran vdout1_86ck1390 FIND v(dout1_86) AT=700.025n

.meas tran vdout1_87ck1390 FIND v(dout1_87) AT=700.025n

.meas tran vdout1_88ck1390 FIND v(dout1_88) AT=700.025n

.meas tran vdout1_89ck1390 FIND v(dout1_89) AT=700.025n

.meas tran vdout1_90ck1390 FIND v(dout1_90) AT=700.025n

.meas tran vdout1_91ck1390 FIND v(dout1_91) AT=700.025n

.meas tran vdout1_92ck1390 FIND v(dout1_92) AT=700.025n

.meas tran vdout1_93ck1390 FIND v(dout1_93) AT=700.025n

.meas tran vdout1_94ck1390 FIND v(dout1_94) AT=700.025n

.meas tran vdout1_95ck1390 FIND v(dout1_95) AT=700.025n

.meas tran vdout1_96ck1390 FIND v(dout1_96) AT=700.025n

.meas tran vdout1_97ck1390 FIND v(dout1_97) AT=700.025n

.meas tran vdout1_98ck1390 FIND v(dout1_98) AT=700.025n

.meas tran vdout1_99ck1390 FIND v(dout1_99) AT=700.025n

.meas tran vdout1_100ck1390 FIND v(dout1_100) AT=700.025n

.meas tran vdout1_101ck1390 FIND v(dout1_101) AT=700.025n

.meas tran vdout1_102ck1390 FIND v(dout1_102) AT=700.025n

.meas tran vdout1_103ck1390 FIND v(dout1_103) AT=700.025n

.meas tran vdout1_104ck1390 FIND v(dout1_104) AT=700.025n

.meas tran vdout1_105ck1390 FIND v(dout1_105) AT=700.025n

.meas tran vdout1_106ck1390 FIND v(dout1_106) AT=700.025n

.meas tran vdout1_107ck1390 FIND v(dout1_107) AT=700.025n

.meas tran vdout1_108ck1390 FIND v(dout1_108) AT=700.025n

.meas tran vdout1_109ck1390 FIND v(dout1_109) AT=700.025n

.meas tran vdout1_110ck1390 FIND v(dout1_110) AT=700.025n

.meas tran vdout1_111ck1390 FIND v(dout1_111) AT=700.025n

.meas tran vdout1_112ck1390 FIND v(dout1_112) AT=700.025n

.meas tran vdout1_113ck1390 FIND v(dout1_113) AT=700.025n

.meas tran vdout1_114ck1390 FIND v(dout1_114) AT=700.025n

.meas tran vdout1_115ck1390 FIND v(dout1_115) AT=700.025n

.meas tran vdout1_116ck1390 FIND v(dout1_116) AT=700.025n

.meas tran vdout1_117ck1390 FIND v(dout1_117) AT=700.025n

.meas tran vdout1_118ck1390 FIND v(dout1_118) AT=700.025n

.meas tran vdout1_119ck1390 FIND v(dout1_119) AT=700.025n

.meas tran vdout1_120ck1390 FIND v(dout1_120) AT=700.025n

.meas tran vdout1_121ck1390 FIND v(dout1_121) AT=700.025n

.meas tran vdout1_122ck1390 FIND v(dout1_122) AT=700.025n

.meas tran vdout1_123ck1390 FIND v(dout1_123) AT=700.025n

.meas tran vdout1_124ck1390 FIND v(dout1_124) AT=700.025n

.meas tran vdout1_125ck1390 FIND v(dout1_125) AT=700.025n

.meas tran vdout1_126ck1390 FIND v(dout1_126) AT=700.025n

.meas tran vdout1_127ck1390 FIND v(dout1_127) AT=700.025n

.meas tran vdout1_0ck1410 FIND v(dout1_0) AT=710.025n

.meas tran vdout1_1ck1410 FIND v(dout1_1) AT=710.025n

.meas tran vdout1_2ck1410 FIND v(dout1_2) AT=710.025n

.meas tran vdout1_3ck1410 FIND v(dout1_3) AT=710.025n

.meas tran vdout1_4ck1410 FIND v(dout1_4) AT=710.025n

.meas tran vdout1_5ck1410 FIND v(dout1_5) AT=710.025n

.meas tran vdout1_6ck1410 FIND v(dout1_6) AT=710.025n

.meas tran vdout1_7ck1410 FIND v(dout1_7) AT=710.025n

.meas tran vdout1_8ck1410 FIND v(dout1_8) AT=710.025n

.meas tran vdout1_9ck1410 FIND v(dout1_9) AT=710.025n

.meas tran vdout1_10ck1410 FIND v(dout1_10) AT=710.025n

.meas tran vdout1_11ck1410 FIND v(dout1_11) AT=710.025n

.meas tran vdout1_12ck1410 FIND v(dout1_12) AT=710.025n

.meas tran vdout1_13ck1410 FIND v(dout1_13) AT=710.025n

.meas tran vdout1_14ck1410 FIND v(dout1_14) AT=710.025n

.meas tran vdout1_15ck1410 FIND v(dout1_15) AT=710.025n

.meas tran vdout1_16ck1410 FIND v(dout1_16) AT=710.025n

.meas tran vdout1_17ck1410 FIND v(dout1_17) AT=710.025n

.meas tran vdout1_18ck1410 FIND v(dout1_18) AT=710.025n

.meas tran vdout1_19ck1410 FIND v(dout1_19) AT=710.025n

.meas tran vdout1_20ck1410 FIND v(dout1_20) AT=710.025n

.meas tran vdout1_21ck1410 FIND v(dout1_21) AT=710.025n

.meas tran vdout1_22ck1410 FIND v(dout1_22) AT=710.025n

.meas tran vdout1_23ck1410 FIND v(dout1_23) AT=710.025n

.meas tran vdout1_24ck1410 FIND v(dout1_24) AT=710.025n

.meas tran vdout1_25ck1410 FIND v(dout1_25) AT=710.025n

.meas tran vdout1_26ck1410 FIND v(dout1_26) AT=710.025n

.meas tran vdout1_27ck1410 FIND v(dout1_27) AT=710.025n

.meas tran vdout1_28ck1410 FIND v(dout1_28) AT=710.025n

.meas tran vdout1_29ck1410 FIND v(dout1_29) AT=710.025n

.meas tran vdout1_30ck1410 FIND v(dout1_30) AT=710.025n

.meas tran vdout1_31ck1410 FIND v(dout1_31) AT=710.025n

.meas tran vdout1_32ck1410 FIND v(dout1_32) AT=710.025n

.meas tran vdout1_33ck1410 FIND v(dout1_33) AT=710.025n

.meas tran vdout1_34ck1410 FIND v(dout1_34) AT=710.025n

.meas tran vdout1_35ck1410 FIND v(dout1_35) AT=710.025n

.meas tran vdout1_36ck1410 FIND v(dout1_36) AT=710.025n

.meas tran vdout1_37ck1410 FIND v(dout1_37) AT=710.025n

.meas tran vdout1_38ck1410 FIND v(dout1_38) AT=710.025n

.meas tran vdout1_39ck1410 FIND v(dout1_39) AT=710.025n

.meas tran vdout1_40ck1410 FIND v(dout1_40) AT=710.025n

.meas tran vdout1_41ck1410 FIND v(dout1_41) AT=710.025n

.meas tran vdout1_42ck1410 FIND v(dout1_42) AT=710.025n

.meas tran vdout1_43ck1410 FIND v(dout1_43) AT=710.025n

.meas tran vdout1_44ck1410 FIND v(dout1_44) AT=710.025n

.meas tran vdout1_45ck1410 FIND v(dout1_45) AT=710.025n

.meas tran vdout1_46ck1410 FIND v(dout1_46) AT=710.025n

.meas tran vdout1_47ck1410 FIND v(dout1_47) AT=710.025n

.meas tran vdout1_48ck1410 FIND v(dout1_48) AT=710.025n

.meas tran vdout1_49ck1410 FIND v(dout1_49) AT=710.025n

.meas tran vdout1_50ck1410 FIND v(dout1_50) AT=710.025n

.meas tran vdout1_51ck1410 FIND v(dout1_51) AT=710.025n

.meas tran vdout1_52ck1410 FIND v(dout1_52) AT=710.025n

.meas tran vdout1_53ck1410 FIND v(dout1_53) AT=710.025n

.meas tran vdout1_54ck1410 FIND v(dout1_54) AT=710.025n

.meas tran vdout1_55ck1410 FIND v(dout1_55) AT=710.025n

.meas tran vdout1_56ck1410 FIND v(dout1_56) AT=710.025n

.meas tran vdout1_57ck1410 FIND v(dout1_57) AT=710.025n

.meas tran vdout1_58ck1410 FIND v(dout1_58) AT=710.025n

.meas tran vdout1_59ck1410 FIND v(dout1_59) AT=710.025n

.meas tran vdout1_60ck1410 FIND v(dout1_60) AT=710.025n

.meas tran vdout1_61ck1410 FIND v(dout1_61) AT=710.025n

.meas tran vdout1_62ck1410 FIND v(dout1_62) AT=710.025n

.meas tran vdout1_63ck1410 FIND v(dout1_63) AT=710.025n

.meas tran vdout1_64ck1410 FIND v(dout1_64) AT=710.025n

.meas tran vdout1_65ck1410 FIND v(dout1_65) AT=710.025n

.meas tran vdout1_66ck1410 FIND v(dout1_66) AT=710.025n

.meas tran vdout1_67ck1410 FIND v(dout1_67) AT=710.025n

.meas tran vdout1_68ck1410 FIND v(dout1_68) AT=710.025n

.meas tran vdout1_69ck1410 FIND v(dout1_69) AT=710.025n

.meas tran vdout1_70ck1410 FIND v(dout1_70) AT=710.025n

.meas tran vdout1_71ck1410 FIND v(dout1_71) AT=710.025n

.meas tran vdout1_72ck1410 FIND v(dout1_72) AT=710.025n

.meas tran vdout1_73ck1410 FIND v(dout1_73) AT=710.025n

.meas tran vdout1_74ck1410 FIND v(dout1_74) AT=710.025n

.meas tran vdout1_75ck1410 FIND v(dout1_75) AT=710.025n

.meas tran vdout1_76ck1410 FIND v(dout1_76) AT=710.025n

.meas tran vdout1_77ck1410 FIND v(dout1_77) AT=710.025n

.meas tran vdout1_78ck1410 FIND v(dout1_78) AT=710.025n

.meas tran vdout1_79ck1410 FIND v(dout1_79) AT=710.025n

.meas tran vdout1_80ck1410 FIND v(dout1_80) AT=710.025n

.meas tran vdout1_81ck1410 FIND v(dout1_81) AT=710.025n

.meas tran vdout1_82ck1410 FIND v(dout1_82) AT=710.025n

.meas tran vdout1_83ck1410 FIND v(dout1_83) AT=710.025n

.meas tran vdout1_84ck1410 FIND v(dout1_84) AT=710.025n

.meas tran vdout1_85ck1410 FIND v(dout1_85) AT=710.025n

.meas tran vdout1_86ck1410 FIND v(dout1_86) AT=710.025n

.meas tran vdout1_87ck1410 FIND v(dout1_87) AT=710.025n

.meas tran vdout1_88ck1410 FIND v(dout1_88) AT=710.025n

.meas tran vdout1_89ck1410 FIND v(dout1_89) AT=710.025n

.meas tran vdout1_90ck1410 FIND v(dout1_90) AT=710.025n

.meas tran vdout1_91ck1410 FIND v(dout1_91) AT=710.025n

.meas tran vdout1_92ck1410 FIND v(dout1_92) AT=710.025n

.meas tran vdout1_93ck1410 FIND v(dout1_93) AT=710.025n

.meas tran vdout1_94ck1410 FIND v(dout1_94) AT=710.025n

.meas tran vdout1_95ck1410 FIND v(dout1_95) AT=710.025n

.meas tran vdout1_96ck1410 FIND v(dout1_96) AT=710.025n

.meas tran vdout1_97ck1410 FIND v(dout1_97) AT=710.025n

.meas tran vdout1_98ck1410 FIND v(dout1_98) AT=710.025n

.meas tran vdout1_99ck1410 FIND v(dout1_99) AT=710.025n

.meas tran vdout1_100ck1410 FIND v(dout1_100) AT=710.025n

.meas tran vdout1_101ck1410 FIND v(dout1_101) AT=710.025n

.meas tran vdout1_102ck1410 FIND v(dout1_102) AT=710.025n

.meas tran vdout1_103ck1410 FIND v(dout1_103) AT=710.025n

.meas tran vdout1_104ck1410 FIND v(dout1_104) AT=710.025n

.meas tran vdout1_105ck1410 FIND v(dout1_105) AT=710.025n

.meas tran vdout1_106ck1410 FIND v(dout1_106) AT=710.025n

.meas tran vdout1_107ck1410 FIND v(dout1_107) AT=710.025n

.meas tran vdout1_108ck1410 FIND v(dout1_108) AT=710.025n

.meas tran vdout1_109ck1410 FIND v(dout1_109) AT=710.025n

.meas tran vdout1_110ck1410 FIND v(dout1_110) AT=710.025n

.meas tran vdout1_111ck1410 FIND v(dout1_111) AT=710.025n

.meas tran vdout1_112ck1410 FIND v(dout1_112) AT=710.025n

.meas tran vdout1_113ck1410 FIND v(dout1_113) AT=710.025n

.meas tran vdout1_114ck1410 FIND v(dout1_114) AT=710.025n

.meas tran vdout1_115ck1410 FIND v(dout1_115) AT=710.025n

.meas tran vdout1_116ck1410 FIND v(dout1_116) AT=710.025n

.meas tran vdout1_117ck1410 FIND v(dout1_117) AT=710.025n

.meas tran vdout1_118ck1410 FIND v(dout1_118) AT=710.025n

.meas tran vdout1_119ck1410 FIND v(dout1_119) AT=710.025n

.meas tran vdout1_120ck1410 FIND v(dout1_120) AT=710.025n

.meas tran vdout1_121ck1410 FIND v(dout1_121) AT=710.025n

.meas tran vdout1_122ck1410 FIND v(dout1_122) AT=710.025n

.meas tran vdout1_123ck1410 FIND v(dout1_123) AT=710.025n

.meas tran vdout1_124ck1410 FIND v(dout1_124) AT=710.025n

.meas tran vdout1_125ck1410 FIND v(dout1_125) AT=710.025n

.meas tran vdout1_126ck1410 FIND v(dout1_126) AT=710.025n

.meas tran vdout1_127ck1410 FIND v(dout1_127) AT=710.025n

.meas tran vdout1_0ck1420 FIND v(dout1_0) AT=715.025n

.meas tran vdout1_1ck1420 FIND v(dout1_1) AT=715.025n

.meas tran vdout1_2ck1420 FIND v(dout1_2) AT=715.025n

.meas tran vdout1_3ck1420 FIND v(dout1_3) AT=715.025n

.meas tran vdout1_4ck1420 FIND v(dout1_4) AT=715.025n

.meas tran vdout1_5ck1420 FIND v(dout1_5) AT=715.025n

.meas tran vdout1_6ck1420 FIND v(dout1_6) AT=715.025n

.meas tran vdout1_7ck1420 FIND v(dout1_7) AT=715.025n

.meas tran vdout1_8ck1420 FIND v(dout1_8) AT=715.025n

.meas tran vdout1_9ck1420 FIND v(dout1_9) AT=715.025n

.meas tran vdout1_10ck1420 FIND v(dout1_10) AT=715.025n

.meas tran vdout1_11ck1420 FIND v(dout1_11) AT=715.025n

.meas tran vdout1_12ck1420 FIND v(dout1_12) AT=715.025n

.meas tran vdout1_13ck1420 FIND v(dout1_13) AT=715.025n

.meas tran vdout1_14ck1420 FIND v(dout1_14) AT=715.025n

.meas tran vdout1_15ck1420 FIND v(dout1_15) AT=715.025n

.meas tran vdout1_16ck1420 FIND v(dout1_16) AT=715.025n

.meas tran vdout1_17ck1420 FIND v(dout1_17) AT=715.025n

.meas tran vdout1_18ck1420 FIND v(dout1_18) AT=715.025n

.meas tran vdout1_19ck1420 FIND v(dout1_19) AT=715.025n

.meas tran vdout1_20ck1420 FIND v(dout1_20) AT=715.025n

.meas tran vdout1_21ck1420 FIND v(dout1_21) AT=715.025n

.meas tran vdout1_22ck1420 FIND v(dout1_22) AT=715.025n

.meas tran vdout1_23ck1420 FIND v(dout1_23) AT=715.025n

.meas tran vdout1_24ck1420 FIND v(dout1_24) AT=715.025n

.meas tran vdout1_25ck1420 FIND v(dout1_25) AT=715.025n

.meas tran vdout1_26ck1420 FIND v(dout1_26) AT=715.025n

.meas tran vdout1_27ck1420 FIND v(dout1_27) AT=715.025n

.meas tran vdout1_28ck1420 FIND v(dout1_28) AT=715.025n

.meas tran vdout1_29ck1420 FIND v(dout1_29) AT=715.025n

.meas tran vdout1_30ck1420 FIND v(dout1_30) AT=715.025n

.meas tran vdout1_31ck1420 FIND v(dout1_31) AT=715.025n

.meas tran vdout1_32ck1420 FIND v(dout1_32) AT=715.025n

.meas tran vdout1_33ck1420 FIND v(dout1_33) AT=715.025n

.meas tran vdout1_34ck1420 FIND v(dout1_34) AT=715.025n

.meas tran vdout1_35ck1420 FIND v(dout1_35) AT=715.025n

.meas tran vdout1_36ck1420 FIND v(dout1_36) AT=715.025n

.meas tran vdout1_37ck1420 FIND v(dout1_37) AT=715.025n

.meas tran vdout1_38ck1420 FIND v(dout1_38) AT=715.025n

.meas tran vdout1_39ck1420 FIND v(dout1_39) AT=715.025n

.meas tran vdout1_40ck1420 FIND v(dout1_40) AT=715.025n

.meas tran vdout1_41ck1420 FIND v(dout1_41) AT=715.025n

.meas tran vdout1_42ck1420 FIND v(dout1_42) AT=715.025n

.meas tran vdout1_43ck1420 FIND v(dout1_43) AT=715.025n

.meas tran vdout1_44ck1420 FIND v(dout1_44) AT=715.025n

.meas tran vdout1_45ck1420 FIND v(dout1_45) AT=715.025n

.meas tran vdout1_46ck1420 FIND v(dout1_46) AT=715.025n

.meas tran vdout1_47ck1420 FIND v(dout1_47) AT=715.025n

.meas tran vdout1_48ck1420 FIND v(dout1_48) AT=715.025n

.meas tran vdout1_49ck1420 FIND v(dout1_49) AT=715.025n

.meas tran vdout1_50ck1420 FIND v(dout1_50) AT=715.025n

.meas tran vdout1_51ck1420 FIND v(dout1_51) AT=715.025n

.meas tran vdout1_52ck1420 FIND v(dout1_52) AT=715.025n

.meas tran vdout1_53ck1420 FIND v(dout1_53) AT=715.025n

.meas tran vdout1_54ck1420 FIND v(dout1_54) AT=715.025n

.meas tran vdout1_55ck1420 FIND v(dout1_55) AT=715.025n

.meas tran vdout1_56ck1420 FIND v(dout1_56) AT=715.025n

.meas tran vdout1_57ck1420 FIND v(dout1_57) AT=715.025n

.meas tran vdout1_58ck1420 FIND v(dout1_58) AT=715.025n

.meas tran vdout1_59ck1420 FIND v(dout1_59) AT=715.025n

.meas tran vdout1_60ck1420 FIND v(dout1_60) AT=715.025n

.meas tran vdout1_61ck1420 FIND v(dout1_61) AT=715.025n

.meas tran vdout1_62ck1420 FIND v(dout1_62) AT=715.025n

.meas tran vdout1_63ck1420 FIND v(dout1_63) AT=715.025n

.meas tran vdout1_64ck1420 FIND v(dout1_64) AT=715.025n

.meas tran vdout1_65ck1420 FIND v(dout1_65) AT=715.025n

.meas tran vdout1_66ck1420 FIND v(dout1_66) AT=715.025n

.meas tran vdout1_67ck1420 FIND v(dout1_67) AT=715.025n

.meas tran vdout1_68ck1420 FIND v(dout1_68) AT=715.025n

.meas tran vdout1_69ck1420 FIND v(dout1_69) AT=715.025n

.meas tran vdout1_70ck1420 FIND v(dout1_70) AT=715.025n

.meas tran vdout1_71ck1420 FIND v(dout1_71) AT=715.025n

.meas tran vdout1_72ck1420 FIND v(dout1_72) AT=715.025n

.meas tran vdout1_73ck1420 FIND v(dout1_73) AT=715.025n

.meas tran vdout1_74ck1420 FIND v(dout1_74) AT=715.025n

.meas tran vdout1_75ck1420 FIND v(dout1_75) AT=715.025n

.meas tran vdout1_76ck1420 FIND v(dout1_76) AT=715.025n

.meas tran vdout1_77ck1420 FIND v(dout1_77) AT=715.025n

.meas tran vdout1_78ck1420 FIND v(dout1_78) AT=715.025n

.meas tran vdout1_79ck1420 FIND v(dout1_79) AT=715.025n

.meas tran vdout1_80ck1420 FIND v(dout1_80) AT=715.025n

.meas tran vdout1_81ck1420 FIND v(dout1_81) AT=715.025n

.meas tran vdout1_82ck1420 FIND v(dout1_82) AT=715.025n

.meas tran vdout1_83ck1420 FIND v(dout1_83) AT=715.025n

.meas tran vdout1_84ck1420 FIND v(dout1_84) AT=715.025n

.meas tran vdout1_85ck1420 FIND v(dout1_85) AT=715.025n

.meas tran vdout1_86ck1420 FIND v(dout1_86) AT=715.025n

.meas tran vdout1_87ck1420 FIND v(dout1_87) AT=715.025n

.meas tran vdout1_88ck1420 FIND v(dout1_88) AT=715.025n

.meas tran vdout1_89ck1420 FIND v(dout1_89) AT=715.025n

.meas tran vdout1_90ck1420 FIND v(dout1_90) AT=715.025n

.meas tran vdout1_91ck1420 FIND v(dout1_91) AT=715.025n

.meas tran vdout1_92ck1420 FIND v(dout1_92) AT=715.025n

.meas tran vdout1_93ck1420 FIND v(dout1_93) AT=715.025n

.meas tran vdout1_94ck1420 FIND v(dout1_94) AT=715.025n

.meas tran vdout1_95ck1420 FIND v(dout1_95) AT=715.025n

.meas tran vdout1_96ck1420 FIND v(dout1_96) AT=715.025n

.meas tran vdout1_97ck1420 FIND v(dout1_97) AT=715.025n

.meas tran vdout1_98ck1420 FIND v(dout1_98) AT=715.025n

.meas tran vdout1_99ck1420 FIND v(dout1_99) AT=715.025n

.meas tran vdout1_100ck1420 FIND v(dout1_100) AT=715.025n

.meas tran vdout1_101ck1420 FIND v(dout1_101) AT=715.025n

.meas tran vdout1_102ck1420 FIND v(dout1_102) AT=715.025n

.meas tran vdout1_103ck1420 FIND v(dout1_103) AT=715.025n

.meas tran vdout1_104ck1420 FIND v(dout1_104) AT=715.025n

.meas tran vdout1_105ck1420 FIND v(dout1_105) AT=715.025n

.meas tran vdout1_106ck1420 FIND v(dout1_106) AT=715.025n

.meas tran vdout1_107ck1420 FIND v(dout1_107) AT=715.025n

.meas tran vdout1_108ck1420 FIND v(dout1_108) AT=715.025n

.meas tran vdout1_109ck1420 FIND v(dout1_109) AT=715.025n

.meas tran vdout1_110ck1420 FIND v(dout1_110) AT=715.025n

.meas tran vdout1_111ck1420 FIND v(dout1_111) AT=715.025n

.meas tran vdout1_112ck1420 FIND v(dout1_112) AT=715.025n

.meas tran vdout1_113ck1420 FIND v(dout1_113) AT=715.025n

.meas tran vdout1_114ck1420 FIND v(dout1_114) AT=715.025n

.meas tran vdout1_115ck1420 FIND v(dout1_115) AT=715.025n

.meas tran vdout1_116ck1420 FIND v(dout1_116) AT=715.025n

.meas tran vdout1_117ck1420 FIND v(dout1_117) AT=715.025n

.meas tran vdout1_118ck1420 FIND v(dout1_118) AT=715.025n

.meas tran vdout1_119ck1420 FIND v(dout1_119) AT=715.025n

.meas tran vdout1_120ck1420 FIND v(dout1_120) AT=715.025n

.meas tran vdout1_121ck1420 FIND v(dout1_121) AT=715.025n

.meas tran vdout1_122ck1420 FIND v(dout1_122) AT=715.025n

.meas tran vdout1_123ck1420 FIND v(dout1_123) AT=715.025n

.meas tran vdout1_124ck1420 FIND v(dout1_124) AT=715.025n

.meas tran vdout1_125ck1420 FIND v(dout1_125) AT=715.025n

.meas tran vdout1_126ck1420 FIND v(dout1_126) AT=715.025n

.meas tran vdout1_127ck1420 FIND v(dout1_127) AT=715.025n

.meas tran vdout1_0ck1430 FIND v(dout1_0) AT=720.025n

.meas tran vdout1_1ck1430 FIND v(dout1_1) AT=720.025n

.meas tran vdout1_2ck1430 FIND v(dout1_2) AT=720.025n

.meas tran vdout1_3ck1430 FIND v(dout1_3) AT=720.025n

.meas tran vdout1_4ck1430 FIND v(dout1_4) AT=720.025n

.meas tran vdout1_5ck1430 FIND v(dout1_5) AT=720.025n

.meas tran vdout1_6ck1430 FIND v(dout1_6) AT=720.025n

.meas tran vdout1_7ck1430 FIND v(dout1_7) AT=720.025n

.meas tran vdout1_8ck1430 FIND v(dout1_8) AT=720.025n

.meas tran vdout1_9ck1430 FIND v(dout1_9) AT=720.025n

.meas tran vdout1_10ck1430 FIND v(dout1_10) AT=720.025n

.meas tran vdout1_11ck1430 FIND v(dout1_11) AT=720.025n

.meas tran vdout1_12ck1430 FIND v(dout1_12) AT=720.025n

.meas tran vdout1_13ck1430 FIND v(dout1_13) AT=720.025n

.meas tran vdout1_14ck1430 FIND v(dout1_14) AT=720.025n

.meas tran vdout1_15ck1430 FIND v(dout1_15) AT=720.025n

.meas tran vdout1_16ck1430 FIND v(dout1_16) AT=720.025n

.meas tran vdout1_17ck1430 FIND v(dout1_17) AT=720.025n

.meas tran vdout1_18ck1430 FIND v(dout1_18) AT=720.025n

.meas tran vdout1_19ck1430 FIND v(dout1_19) AT=720.025n

.meas tran vdout1_20ck1430 FIND v(dout1_20) AT=720.025n

.meas tran vdout1_21ck1430 FIND v(dout1_21) AT=720.025n

.meas tran vdout1_22ck1430 FIND v(dout1_22) AT=720.025n

.meas tran vdout1_23ck1430 FIND v(dout1_23) AT=720.025n

.meas tran vdout1_24ck1430 FIND v(dout1_24) AT=720.025n

.meas tran vdout1_25ck1430 FIND v(dout1_25) AT=720.025n

.meas tran vdout1_26ck1430 FIND v(dout1_26) AT=720.025n

.meas tran vdout1_27ck1430 FIND v(dout1_27) AT=720.025n

.meas tran vdout1_28ck1430 FIND v(dout1_28) AT=720.025n

.meas tran vdout1_29ck1430 FIND v(dout1_29) AT=720.025n

.meas tran vdout1_30ck1430 FIND v(dout1_30) AT=720.025n

.meas tran vdout1_31ck1430 FIND v(dout1_31) AT=720.025n

.meas tran vdout1_32ck1430 FIND v(dout1_32) AT=720.025n

.meas tran vdout1_33ck1430 FIND v(dout1_33) AT=720.025n

.meas tran vdout1_34ck1430 FIND v(dout1_34) AT=720.025n

.meas tran vdout1_35ck1430 FIND v(dout1_35) AT=720.025n

.meas tran vdout1_36ck1430 FIND v(dout1_36) AT=720.025n

.meas tran vdout1_37ck1430 FIND v(dout1_37) AT=720.025n

.meas tran vdout1_38ck1430 FIND v(dout1_38) AT=720.025n

.meas tran vdout1_39ck1430 FIND v(dout1_39) AT=720.025n

.meas tran vdout1_40ck1430 FIND v(dout1_40) AT=720.025n

.meas tran vdout1_41ck1430 FIND v(dout1_41) AT=720.025n

.meas tran vdout1_42ck1430 FIND v(dout1_42) AT=720.025n

.meas tran vdout1_43ck1430 FIND v(dout1_43) AT=720.025n

.meas tran vdout1_44ck1430 FIND v(dout1_44) AT=720.025n

.meas tran vdout1_45ck1430 FIND v(dout1_45) AT=720.025n

.meas tran vdout1_46ck1430 FIND v(dout1_46) AT=720.025n

.meas tran vdout1_47ck1430 FIND v(dout1_47) AT=720.025n

.meas tran vdout1_48ck1430 FIND v(dout1_48) AT=720.025n

.meas tran vdout1_49ck1430 FIND v(dout1_49) AT=720.025n

.meas tran vdout1_50ck1430 FIND v(dout1_50) AT=720.025n

.meas tran vdout1_51ck1430 FIND v(dout1_51) AT=720.025n

.meas tran vdout1_52ck1430 FIND v(dout1_52) AT=720.025n

.meas tran vdout1_53ck1430 FIND v(dout1_53) AT=720.025n

.meas tran vdout1_54ck1430 FIND v(dout1_54) AT=720.025n

.meas tran vdout1_55ck1430 FIND v(dout1_55) AT=720.025n

.meas tran vdout1_56ck1430 FIND v(dout1_56) AT=720.025n

.meas tran vdout1_57ck1430 FIND v(dout1_57) AT=720.025n

.meas tran vdout1_58ck1430 FIND v(dout1_58) AT=720.025n

.meas tran vdout1_59ck1430 FIND v(dout1_59) AT=720.025n

.meas tran vdout1_60ck1430 FIND v(dout1_60) AT=720.025n

.meas tran vdout1_61ck1430 FIND v(dout1_61) AT=720.025n

.meas tran vdout1_62ck1430 FIND v(dout1_62) AT=720.025n

.meas tran vdout1_63ck1430 FIND v(dout1_63) AT=720.025n

.meas tran vdout1_64ck1430 FIND v(dout1_64) AT=720.025n

.meas tran vdout1_65ck1430 FIND v(dout1_65) AT=720.025n

.meas tran vdout1_66ck1430 FIND v(dout1_66) AT=720.025n

.meas tran vdout1_67ck1430 FIND v(dout1_67) AT=720.025n

.meas tran vdout1_68ck1430 FIND v(dout1_68) AT=720.025n

.meas tran vdout1_69ck1430 FIND v(dout1_69) AT=720.025n

.meas tran vdout1_70ck1430 FIND v(dout1_70) AT=720.025n

.meas tran vdout1_71ck1430 FIND v(dout1_71) AT=720.025n

.meas tran vdout1_72ck1430 FIND v(dout1_72) AT=720.025n

.meas tran vdout1_73ck1430 FIND v(dout1_73) AT=720.025n

.meas tran vdout1_74ck1430 FIND v(dout1_74) AT=720.025n

.meas tran vdout1_75ck1430 FIND v(dout1_75) AT=720.025n

.meas tran vdout1_76ck1430 FIND v(dout1_76) AT=720.025n

.meas tran vdout1_77ck1430 FIND v(dout1_77) AT=720.025n

.meas tran vdout1_78ck1430 FIND v(dout1_78) AT=720.025n

.meas tran vdout1_79ck1430 FIND v(dout1_79) AT=720.025n

.meas tran vdout1_80ck1430 FIND v(dout1_80) AT=720.025n

.meas tran vdout1_81ck1430 FIND v(dout1_81) AT=720.025n

.meas tran vdout1_82ck1430 FIND v(dout1_82) AT=720.025n

.meas tran vdout1_83ck1430 FIND v(dout1_83) AT=720.025n

.meas tran vdout1_84ck1430 FIND v(dout1_84) AT=720.025n

.meas tran vdout1_85ck1430 FIND v(dout1_85) AT=720.025n

.meas tran vdout1_86ck1430 FIND v(dout1_86) AT=720.025n

.meas tran vdout1_87ck1430 FIND v(dout1_87) AT=720.025n

.meas tran vdout1_88ck1430 FIND v(dout1_88) AT=720.025n

.meas tran vdout1_89ck1430 FIND v(dout1_89) AT=720.025n

.meas tran vdout1_90ck1430 FIND v(dout1_90) AT=720.025n

.meas tran vdout1_91ck1430 FIND v(dout1_91) AT=720.025n

.meas tran vdout1_92ck1430 FIND v(dout1_92) AT=720.025n

.meas tran vdout1_93ck1430 FIND v(dout1_93) AT=720.025n

.meas tran vdout1_94ck1430 FIND v(dout1_94) AT=720.025n

.meas tran vdout1_95ck1430 FIND v(dout1_95) AT=720.025n

.meas tran vdout1_96ck1430 FIND v(dout1_96) AT=720.025n

.meas tran vdout1_97ck1430 FIND v(dout1_97) AT=720.025n

.meas tran vdout1_98ck1430 FIND v(dout1_98) AT=720.025n

.meas tran vdout1_99ck1430 FIND v(dout1_99) AT=720.025n

.meas tran vdout1_100ck1430 FIND v(dout1_100) AT=720.025n

.meas tran vdout1_101ck1430 FIND v(dout1_101) AT=720.025n

.meas tran vdout1_102ck1430 FIND v(dout1_102) AT=720.025n

.meas tran vdout1_103ck1430 FIND v(dout1_103) AT=720.025n

.meas tran vdout1_104ck1430 FIND v(dout1_104) AT=720.025n

.meas tran vdout1_105ck1430 FIND v(dout1_105) AT=720.025n

.meas tran vdout1_106ck1430 FIND v(dout1_106) AT=720.025n

.meas tran vdout1_107ck1430 FIND v(dout1_107) AT=720.025n

.meas tran vdout1_108ck1430 FIND v(dout1_108) AT=720.025n

.meas tran vdout1_109ck1430 FIND v(dout1_109) AT=720.025n

.meas tran vdout1_110ck1430 FIND v(dout1_110) AT=720.025n

.meas tran vdout1_111ck1430 FIND v(dout1_111) AT=720.025n

.meas tran vdout1_112ck1430 FIND v(dout1_112) AT=720.025n

.meas tran vdout1_113ck1430 FIND v(dout1_113) AT=720.025n

.meas tran vdout1_114ck1430 FIND v(dout1_114) AT=720.025n

.meas tran vdout1_115ck1430 FIND v(dout1_115) AT=720.025n

.meas tran vdout1_116ck1430 FIND v(dout1_116) AT=720.025n

.meas tran vdout1_117ck1430 FIND v(dout1_117) AT=720.025n

.meas tran vdout1_118ck1430 FIND v(dout1_118) AT=720.025n

.meas tran vdout1_119ck1430 FIND v(dout1_119) AT=720.025n

.meas tran vdout1_120ck1430 FIND v(dout1_120) AT=720.025n

.meas tran vdout1_121ck1430 FIND v(dout1_121) AT=720.025n

.meas tran vdout1_122ck1430 FIND v(dout1_122) AT=720.025n

.meas tran vdout1_123ck1430 FIND v(dout1_123) AT=720.025n

.meas tran vdout1_124ck1430 FIND v(dout1_124) AT=720.025n

.meas tran vdout1_125ck1430 FIND v(dout1_125) AT=720.025n

.meas tran vdout1_126ck1430 FIND v(dout1_126) AT=720.025n

.meas tran vdout1_127ck1430 FIND v(dout1_127) AT=720.025n

.meas tran vdout1_0ck1440 FIND v(dout1_0) AT=725.025n

.meas tran vdout1_1ck1440 FIND v(dout1_1) AT=725.025n

.meas tran vdout1_2ck1440 FIND v(dout1_2) AT=725.025n

.meas tran vdout1_3ck1440 FIND v(dout1_3) AT=725.025n

.meas tran vdout1_4ck1440 FIND v(dout1_4) AT=725.025n

.meas tran vdout1_5ck1440 FIND v(dout1_5) AT=725.025n

.meas tran vdout1_6ck1440 FIND v(dout1_6) AT=725.025n

.meas tran vdout1_7ck1440 FIND v(dout1_7) AT=725.025n

.meas tran vdout1_8ck1440 FIND v(dout1_8) AT=725.025n

.meas tran vdout1_9ck1440 FIND v(dout1_9) AT=725.025n

.meas tran vdout1_10ck1440 FIND v(dout1_10) AT=725.025n

.meas tran vdout1_11ck1440 FIND v(dout1_11) AT=725.025n

.meas tran vdout1_12ck1440 FIND v(dout1_12) AT=725.025n

.meas tran vdout1_13ck1440 FIND v(dout1_13) AT=725.025n

.meas tran vdout1_14ck1440 FIND v(dout1_14) AT=725.025n

.meas tran vdout1_15ck1440 FIND v(dout1_15) AT=725.025n

.meas tran vdout1_16ck1440 FIND v(dout1_16) AT=725.025n

.meas tran vdout1_17ck1440 FIND v(dout1_17) AT=725.025n

.meas tran vdout1_18ck1440 FIND v(dout1_18) AT=725.025n

.meas tran vdout1_19ck1440 FIND v(dout1_19) AT=725.025n

.meas tran vdout1_20ck1440 FIND v(dout1_20) AT=725.025n

.meas tran vdout1_21ck1440 FIND v(dout1_21) AT=725.025n

.meas tran vdout1_22ck1440 FIND v(dout1_22) AT=725.025n

.meas tran vdout1_23ck1440 FIND v(dout1_23) AT=725.025n

.meas tran vdout1_24ck1440 FIND v(dout1_24) AT=725.025n

.meas tran vdout1_25ck1440 FIND v(dout1_25) AT=725.025n

.meas tran vdout1_26ck1440 FIND v(dout1_26) AT=725.025n

.meas tran vdout1_27ck1440 FIND v(dout1_27) AT=725.025n

.meas tran vdout1_28ck1440 FIND v(dout1_28) AT=725.025n

.meas tran vdout1_29ck1440 FIND v(dout1_29) AT=725.025n

.meas tran vdout1_30ck1440 FIND v(dout1_30) AT=725.025n

.meas tran vdout1_31ck1440 FIND v(dout1_31) AT=725.025n

.meas tran vdout1_32ck1440 FIND v(dout1_32) AT=725.025n

.meas tran vdout1_33ck1440 FIND v(dout1_33) AT=725.025n

.meas tran vdout1_34ck1440 FIND v(dout1_34) AT=725.025n

.meas tran vdout1_35ck1440 FIND v(dout1_35) AT=725.025n

.meas tran vdout1_36ck1440 FIND v(dout1_36) AT=725.025n

.meas tran vdout1_37ck1440 FIND v(dout1_37) AT=725.025n

.meas tran vdout1_38ck1440 FIND v(dout1_38) AT=725.025n

.meas tran vdout1_39ck1440 FIND v(dout1_39) AT=725.025n

.meas tran vdout1_40ck1440 FIND v(dout1_40) AT=725.025n

.meas tran vdout1_41ck1440 FIND v(dout1_41) AT=725.025n

.meas tran vdout1_42ck1440 FIND v(dout1_42) AT=725.025n

.meas tran vdout1_43ck1440 FIND v(dout1_43) AT=725.025n

.meas tran vdout1_44ck1440 FIND v(dout1_44) AT=725.025n

.meas tran vdout1_45ck1440 FIND v(dout1_45) AT=725.025n

.meas tran vdout1_46ck1440 FIND v(dout1_46) AT=725.025n

.meas tran vdout1_47ck1440 FIND v(dout1_47) AT=725.025n

.meas tran vdout1_48ck1440 FIND v(dout1_48) AT=725.025n

.meas tran vdout1_49ck1440 FIND v(dout1_49) AT=725.025n

.meas tran vdout1_50ck1440 FIND v(dout1_50) AT=725.025n

.meas tran vdout1_51ck1440 FIND v(dout1_51) AT=725.025n

.meas tran vdout1_52ck1440 FIND v(dout1_52) AT=725.025n

.meas tran vdout1_53ck1440 FIND v(dout1_53) AT=725.025n

.meas tran vdout1_54ck1440 FIND v(dout1_54) AT=725.025n

.meas tran vdout1_55ck1440 FIND v(dout1_55) AT=725.025n

.meas tran vdout1_56ck1440 FIND v(dout1_56) AT=725.025n

.meas tran vdout1_57ck1440 FIND v(dout1_57) AT=725.025n

.meas tran vdout1_58ck1440 FIND v(dout1_58) AT=725.025n

.meas tran vdout1_59ck1440 FIND v(dout1_59) AT=725.025n

.meas tran vdout1_60ck1440 FIND v(dout1_60) AT=725.025n

.meas tran vdout1_61ck1440 FIND v(dout1_61) AT=725.025n

.meas tran vdout1_62ck1440 FIND v(dout1_62) AT=725.025n

.meas tran vdout1_63ck1440 FIND v(dout1_63) AT=725.025n

.meas tran vdout1_64ck1440 FIND v(dout1_64) AT=725.025n

.meas tran vdout1_65ck1440 FIND v(dout1_65) AT=725.025n

.meas tran vdout1_66ck1440 FIND v(dout1_66) AT=725.025n

.meas tran vdout1_67ck1440 FIND v(dout1_67) AT=725.025n

.meas tran vdout1_68ck1440 FIND v(dout1_68) AT=725.025n

.meas tran vdout1_69ck1440 FIND v(dout1_69) AT=725.025n

.meas tran vdout1_70ck1440 FIND v(dout1_70) AT=725.025n

.meas tran vdout1_71ck1440 FIND v(dout1_71) AT=725.025n

.meas tran vdout1_72ck1440 FIND v(dout1_72) AT=725.025n

.meas tran vdout1_73ck1440 FIND v(dout1_73) AT=725.025n

.meas tran vdout1_74ck1440 FIND v(dout1_74) AT=725.025n

.meas tran vdout1_75ck1440 FIND v(dout1_75) AT=725.025n

.meas tran vdout1_76ck1440 FIND v(dout1_76) AT=725.025n

.meas tran vdout1_77ck1440 FIND v(dout1_77) AT=725.025n

.meas tran vdout1_78ck1440 FIND v(dout1_78) AT=725.025n

.meas tran vdout1_79ck1440 FIND v(dout1_79) AT=725.025n

.meas tran vdout1_80ck1440 FIND v(dout1_80) AT=725.025n

.meas tran vdout1_81ck1440 FIND v(dout1_81) AT=725.025n

.meas tran vdout1_82ck1440 FIND v(dout1_82) AT=725.025n

.meas tran vdout1_83ck1440 FIND v(dout1_83) AT=725.025n

.meas tran vdout1_84ck1440 FIND v(dout1_84) AT=725.025n

.meas tran vdout1_85ck1440 FIND v(dout1_85) AT=725.025n

.meas tran vdout1_86ck1440 FIND v(dout1_86) AT=725.025n

.meas tran vdout1_87ck1440 FIND v(dout1_87) AT=725.025n

.meas tran vdout1_88ck1440 FIND v(dout1_88) AT=725.025n

.meas tran vdout1_89ck1440 FIND v(dout1_89) AT=725.025n

.meas tran vdout1_90ck1440 FIND v(dout1_90) AT=725.025n

.meas tran vdout1_91ck1440 FIND v(dout1_91) AT=725.025n

.meas tran vdout1_92ck1440 FIND v(dout1_92) AT=725.025n

.meas tran vdout1_93ck1440 FIND v(dout1_93) AT=725.025n

.meas tran vdout1_94ck1440 FIND v(dout1_94) AT=725.025n

.meas tran vdout1_95ck1440 FIND v(dout1_95) AT=725.025n

.meas tran vdout1_96ck1440 FIND v(dout1_96) AT=725.025n

.meas tran vdout1_97ck1440 FIND v(dout1_97) AT=725.025n

.meas tran vdout1_98ck1440 FIND v(dout1_98) AT=725.025n

.meas tran vdout1_99ck1440 FIND v(dout1_99) AT=725.025n

.meas tran vdout1_100ck1440 FIND v(dout1_100) AT=725.025n

.meas tran vdout1_101ck1440 FIND v(dout1_101) AT=725.025n

.meas tran vdout1_102ck1440 FIND v(dout1_102) AT=725.025n

.meas tran vdout1_103ck1440 FIND v(dout1_103) AT=725.025n

.meas tran vdout1_104ck1440 FIND v(dout1_104) AT=725.025n

.meas tran vdout1_105ck1440 FIND v(dout1_105) AT=725.025n

.meas tran vdout1_106ck1440 FIND v(dout1_106) AT=725.025n

.meas tran vdout1_107ck1440 FIND v(dout1_107) AT=725.025n

.meas tran vdout1_108ck1440 FIND v(dout1_108) AT=725.025n

.meas tran vdout1_109ck1440 FIND v(dout1_109) AT=725.025n

.meas tran vdout1_110ck1440 FIND v(dout1_110) AT=725.025n

.meas tran vdout1_111ck1440 FIND v(dout1_111) AT=725.025n

.meas tran vdout1_112ck1440 FIND v(dout1_112) AT=725.025n

.meas tran vdout1_113ck1440 FIND v(dout1_113) AT=725.025n

.meas tran vdout1_114ck1440 FIND v(dout1_114) AT=725.025n

.meas tran vdout1_115ck1440 FIND v(dout1_115) AT=725.025n

.meas tran vdout1_116ck1440 FIND v(dout1_116) AT=725.025n

.meas tran vdout1_117ck1440 FIND v(dout1_117) AT=725.025n

.meas tran vdout1_118ck1440 FIND v(dout1_118) AT=725.025n

.meas tran vdout1_119ck1440 FIND v(dout1_119) AT=725.025n

.meas tran vdout1_120ck1440 FIND v(dout1_120) AT=725.025n

.meas tran vdout1_121ck1440 FIND v(dout1_121) AT=725.025n

.meas tran vdout1_122ck1440 FIND v(dout1_122) AT=725.025n

.meas tran vdout1_123ck1440 FIND v(dout1_123) AT=725.025n

.meas tran vdout1_124ck1440 FIND v(dout1_124) AT=725.025n

.meas tran vdout1_125ck1440 FIND v(dout1_125) AT=725.025n

.meas tran vdout1_126ck1440 FIND v(dout1_126) AT=725.025n

.meas tran vdout1_127ck1440 FIND v(dout1_127) AT=725.025n

.meas tran vdout1_0ck1450 FIND v(dout1_0) AT=730.025n

.meas tran vdout1_1ck1450 FIND v(dout1_1) AT=730.025n

.meas tran vdout1_2ck1450 FIND v(dout1_2) AT=730.025n

.meas tran vdout1_3ck1450 FIND v(dout1_3) AT=730.025n

.meas tran vdout1_4ck1450 FIND v(dout1_4) AT=730.025n

.meas tran vdout1_5ck1450 FIND v(dout1_5) AT=730.025n

.meas tran vdout1_6ck1450 FIND v(dout1_6) AT=730.025n

.meas tran vdout1_7ck1450 FIND v(dout1_7) AT=730.025n

.meas tran vdout1_8ck1450 FIND v(dout1_8) AT=730.025n

.meas tran vdout1_9ck1450 FIND v(dout1_9) AT=730.025n

.meas tran vdout1_10ck1450 FIND v(dout1_10) AT=730.025n

.meas tran vdout1_11ck1450 FIND v(dout1_11) AT=730.025n

.meas tran vdout1_12ck1450 FIND v(dout1_12) AT=730.025n

.meas tran vdout1_13ck1450 FIND v(dout1_13) AT=730.025n

.meas tran vdout1_14ck1450 FIND v(dout1_14) AT=730.025n

.meas tran vdout1_15ck1450 FIND v(dout1_15) AT=730.025n

.meas tran vdout1_16ck1450 FIND v(dout1_16) AT=730.025n

.meas tran vdout1_17ck1450 FIND v(dout1_17) AT=730.025n

.meas tran vdout1_18ck1450 FIND v(dout1_18) AT=730.025n

.meas tran vdout1_19ck1450 FIND v(dout1_19) AT=730.025n

.meas tran vdout1_20ck1450 FIND v(dout1_20) AT=730.025n

.meas tran vdout1_21ck1450 FIND v(dout1_21) AT=730.025n

.meas tran vdout1_22ck1450 FIND v(dout1_22) AT=730.025n

.meas tran vdout1_23ck1450 FIND v(dout1_23) AT=730.025n

.meas tran vdout1_24ck1450 FIND v(dout1_24) AT=730.025n

.meas tran vdout1_25ck1450 FIND v(dout1_25) AT=730.025n

.meas tran vdout1_26ck1450 FIND v(dout1_26) AT=730.025n

.meas tran vdout1_27ck1450 FIND v(dout1_27) AT=730.025n

.meas tran vdout1_28ck1450 FIND v(dout1_28) AT=730.025n

.meas tran vdout1_29ck1450 FIND v(dout1_29) AT=730.025n

.meas tran vdout1_30ck1450 FIND v(dout1_30) AT=730.025n

.meas tran vdout1_31ck1450 FIND v(dout1_31) AT=730.025n

.meas tran vdout1_32ck1450 FIND v(dout1_32) AT=730.025n

.meas tran vdout1_33ck1450 FIND v(dout1_33) AT=730.025n

.meas tran vdout1_34ck1450 FIND v(dout1_34) AT=730.025n

.meas tran vdout1_35ck1450 FIND v(dout1_35) AT=730.025n

.meas tran vdout1_36ck1450 FIND v(dout1_36) AT=730.025n

.meas tran vdout1_37ck1450 FIND v(dout1_37) AT=730.025n

.meas tran vdout1_38ck1450 FIND v(dout1_38) AT=730.025n

.meas tran vdout1_39ck1450 FIND v(dout1_39) AT=730.025n

.meas tran vdout1_40ck1450 FIND v(dout1_40) AT=730.025n

.meas tran vdout1_41ck1450 FIND v(dout1_41) AT=730.025n

.meas tran vdout1_42ck1450 FIND v(dout1_42) AT=730.025n

.meas tran vdout1_43ck1450 FIND v(dout1_43) AT=730.025n

.meas tran vdout1_44ck1450 FIND v(dout1_44) AT=730.025n

.meas tran vdout1_45ck1450 FIND v(dout1_45) AT=730.025n

.meas tran vdout1_46ck1450 FIND v(dout1_46) AT=730.025n

.meas tran vdout1_47ck1450 FIND v(dout1_47) AT=730.025n

.meas tran vdout1_48ck1450 FIND v(dout1_48) AT=730.025n

.meas tran vdout1_49ck1450 FIND v(dout1_49) AT=730.025n

.meas tran vdout1_50ck1450 FIND v(dout1_50) AT=730.025n

.meas tran vdout1_51ck1450 FIND v(dout1_51) AT=730.025n

.meas tran vdout1_52ck1450 FIND v(dout1_52) AT=730.025n

.meas tran vdout1_53ck1450 FIND v(dout1_53) AT=730.025n

.meas tran vdout1_54ck1450 FIND v(dout1_54) AT=730.025n

.meas tran vdout1_55ck1450 FIND v(dout1_55) AT=730.025n

.meas tran vdout1_56ck1450 FIND v(dout1_56) AT=730.025n

.meas tran vdout1_57ck1450 FIND v(dout1_57) AT=730.025n

.meas tran vdout1_58ck1450 FIND v(dout1_58) AT=730.025n

.meas tran vdout1_59ck1450 FIND v(dout1_59) AT=730.025n

.meas tran vdout1_60ck1450 FIND v(dout1_60) AT=730.025n

.meas tran vdout1_61ck1450 FIND v(dout1_61) AT=730.025n

.meas tran vdout1_62ck1450 FIND v(dout1_62) AT=730.025n

.meas tran vdout1_63ck1450 FIND v(dout1_63) AT=730.025n

.meas tran vdout1_64ck1450 FIND v(dout1_64) AT=730.025n

.meas tran vdout1_65ck1450 FIND v(dout1_65) AT=730.025n

.meas tran vdout1_66ck1450 FIND v(dout1_66) AT=730.025n

.meas tran vdout1_67ck1450 FIND v(dout1_67) AT=730.025n

.meas tran vdout1_68ck1450 FIND v(dout1_68) AT=730.025n

.meas tran vdout1_69ck1450 FIND v(dout1_69) AT=730.025n

.meas tran vdout1_70ck1450 FIND v(dout1_70) AT=730.025n

.meas tran vdout1_71ck1450 FIND v(dout1_71) AT=730.025n

.meas tran vdout1_72ck1450 FIND v(dout1_72) AT=730.025n

.meas tran vdout1_73ck1450 FIND v(dout1_73) AT=730.025n

.meas tran vdout1_74ck1450 FIND v(dout1_74) AT=730.025n

.meas tran vdout1_75ck1450 FIND v(dout1_75) AT=730.025n

.meas tran vdout1_76ck1450 FIND v(dout1_76) AT=730.025n

.meas tran vdout1_77ck1450 FIND v(dout1_77) AT=730.025n

.meas tran vdout1_78ck1450 FIND v(dout1_78) AT=730.025n

.meas tran vdout1_79ck1450 FIND v(dout1_79) AT=730.025n

.meas tran vdout1_80ck1450 FIND v(dout1_80) AT=730.025n

.meas tran vdout1_81ck1450 FIND v(dout1_81) AT=730.025n

.meas tran vdout1_82ck1450 FIND v(dout1_82) AT=730.025n

.meas tran vdout1_83ck1450 FIND v(dout1_83) AT=730.025n

.meas tran vdout1_84ck1450 FIND v(dout1_84) AT=730.025n

.meas tran vdout1_85ck1450 FIND v(dout1_85) AT=730.025n

.meas tran vdout1_86ck1450 FIND v(dout1_86) AT=730.025n

.meas tran vdout1_87ck1450 FIND v(dout1_87) AT=730.025n

.meas tran vdout1_88ck1450 FIND v(dout1_88) AT=730.025n

.meas tran vdout1_89ck1450 FIND v(dout1_89) AT=730.025n

.meas tran vdout1_90ck1450 FIND v(dout1_90) AT=730.025n

.meas tran vdout1_91ck1450 FIND v(dout1_91) AT=730.025n

.meas tran vdout1_92ck1450 FIND v(dout1_92) AT=730.025n

.meas tran vdout1_93ck1450 FIND v(dout1_93) AT=730.025n

.meas tran vdout1_94ck1450 FIND v(dout1_94) AT=730.025n

.meas tran vdout1_95ck1450 FIND v(dout1_95) AT=730.025n

.meas tran vdout1_96ck1450 FIND v(dout1_96) AT=730.025n

.meas tran vdout1_97ck1450 FIND v(dout1_97) AT=730.025n

.meas tran vdout1_98ck1450 FIND v(dout1_98) AT=730.025n

.meas tran vdout1_99ck1450 FIND v(dout1_99) AT=730.025n

.meas tran vdout1_100ck1450 FIND v(dout1_100) AT=730.025n

.meas tran vdout1_101ck1450 FIND v(dout1_101) AT=730.025n

.meas tran vdout1_102ck1450 FIND v(dout1_102) AT=730.025n

.meas tran vdout1_103ck1450 FIND v(dout1_103) AT=730.025n

.meas tran vdout1_104ck1450 FIND v(dout1_104) AT=730.025n

.meas tran vdout1_105ck1450 FIND v(dout1_105) AT=730.025n

.meas tran vdout1_106ck1450 FIND v(dout1_106) AT=730.025n

.meas tran vdout1_107ck1450 FIND v(dout1_107) AT=730.025n

.meas tran vdout1_108ck1450 FIND v(dout1_108) AT=730.025n

.meas tran vdout1_109ck1450 FIND v(dout1_109) AT=730.025n

.meas tran vdout1_110ck1450 FIND v(dout1_110) AT=730.025n

.meas tran vdout1_111ck1450 FIND v(dout1_111) AT=730.025n

.meas tran vdout1_112ck1450 FIND v(dout1_112) AT=730.025n

.meas tran vdout1_113ck1450 FIND v(dout1_113) AT=730.025n

.meas tran vdout1_114ck1450 FIND v(dout1_114) AT=730.025n

.meas tran vdout1_115ck1450 FIND v(dout1_115) AT=730.025n

.meas tran vdout1_116ck1450 FIND v(dout1_116) AT=730.025n

.meas tran vdout1_117ck1450 FIND v(dout1_117) AT=730.025n

.meas tran vdout1_118ck1450 FIND v(dout1_118) AT=730.025n

.meas tran vdout1_119ck1450 FIND v(dout1_119) AT=730.025n

.meas tran vdout1_120ck1450 FIND v(dout1_120) AT=730.025n

.meas tran vdout1_121ck1450 FIND v(dout1_121) AT=730.025n

.meas tran vdout1_122ck1450 FIND v(dout1_122) AT=730.025n

.meas tran vdout1_123ck1450 FIND v(dout1_123) AT=730.025n

.meas tran vdout1_124ck1450 FIND v(dout1_124) AT=730.025n

.meas tran vdout1_125ck1450 FIND v(dout1_125) AT=730.025n

.meas tran vdout1_126ck1450 FIND v(dout1_126) AT=730.025n

.meas tran vdout1_127ck1450 FIND v(dout1_127) AT=730.025n

.meas tran vdout1_0ck1460 FIND v(dout1_0) AT=735.025n

.meas tran vdout1_1ck1460 FIND v(dout1_1) AT=735.025n

.meas tran vdout1_2ck1460 FIND v(dout1_2) AT=735.025n

.meas tran vdout1_3ck1460 FIND v(dout1_3) AT=735.025n

.meas tran vdout1_4ck1460 FIND v(dout1_4) AT=735.025n

.meas tran vdout1_5ck1460 FIND v(dout1_5) AT=735.025n

.meas tran vdout1_6ck1460 FIND v(dout1_6) AT=735.025n

.meas tran vdout1_7ck1460 FIND v(dout1_7) AT=735.025n

.meas tran vdout1_8ck1460 FIND v(dout1_8) AT=735.025n

.meas tran vdout1_9ck1460 FIND v(dout1_9) AT=735.025n

.meas tran vdout1_10ck1460 FIND v(dout1_10) AT=735.025n

.meas tran vdout1_11ck1460 FIND v(dout1_11) AT=735.025n

.meas tran vdout1_12ck1460 FIND v(dout1_12) AT=735.025n

.meas tran vdout1_13ck1460 FIND v(dout1_13) AT=735.025n

.meas tran vdout1_14ck1460 FIND v(dout1_14) AT=735.025n

.meas tran vdout1_15ck1460 FIND v(dout1_15) AT=735.025n

.meas tran vdout1_16ck1460 FIND v(dout1_16) AT=735.025n

.meas tran vdout1_17ck1460 FIND v(dout1_17) AT=735.025n

.meas tran vdout1_18ck1460 FIND v(dout1_18) AT=735.025n

.meas tran vdout1_19ck1460 FIND v(dout1_19) AT=735.025n

.meas tran vdout1_20ck1460 FIND v(dout1_20) AT=735.025n

.meas tran vdout1_21ck1460 FIND v(dout1_21) AT=735.025n

.meas tran vdout1_22ck1460 FIND v(dout1_22) AT=735.025n

.meas tran vdout1_23ck1460 FIND v(dout1_23) AT=735.025n

.meas tran vdout1_24ck1460 FIND v(dout1_24) AT=735.025n

.meas tran vdout1_25ck1460 FIND v(dout1_25) AT=735.025n

.meas tran vdout1_26ck1460 FIND v(dout1_26) AT=735.025n

.meas tran vdout1_27ck1460 FIND v(dout1_27) AT=735.025n

.meas tran vdout1_28ck1460 FIND v(dout1_28) AT=735.025n

.meas tran vdout1_29ck1460 FIND v(dout1_29) AT=735.025n

.meas tran vdout1_30ck1460 FIND v(dout1_30) AT=735.025n

.meas tran vdout1_31ck1460 FIND v(dout1_31) AT=735.025n

.meas tran vdout1_32ck1460 FIND v(dout1_32) AT=735.025n

.meas tran vdout1_33ck1460 FIND v(dout1_33) AT=735.025n

.meas tran vdout1_34ck1460 FIND v(dout1_34) AT=735.025n

.meas tran vdout1_35ck1460 FIND v(dout1_35) AT=735.025n

.meas tran vdout1_36ck1460 FIND v(dout1_36) AT=735.025n

.meas tran vdout1_37ck1460 FIND v(dout1_37) AT=735.025n

.meas tran vdout1_38ck1460 FIND v(dout1_38) AT=735.025n

.meas tran vdout1_39ck1460 FIND v(dout1_39) AT=735.025n

.meas tran vdout1_40ck1460 FIND v(dout1_40) AT=735.025n

.meas tran vdout1_41ck1460 FIND v(dout1_41) AT=735.025n

.meas tran vdout1_42ck1460 FIND v(dout1_42) AT=735.025n

.meas tran vdout1_43ck1460 FIND v(dout1_43) AT=735.025n

.meas tran vdout1_44ck1460 FIND v(dout1_44) AT=735.025n

.meas tran vdout1_45ck1460 FIND v(dout1_45) AT=735.025n

.meas tran vdout1_46ck1460 FIND v(dout1_46) AT=735.025n

.meas tran vdout1_47ck1460 FIND v(dout1_47) AT=735.025n

.meas tran vdout1_48ck1460 FIND v(dout1_48) AT=735.025n

.meas tran vdout1_49ck1460 FIND v(dout1_49) AT=735.025n

.meas tran vdout1_50ck1460 FIND v(dout1_50) AT=735.025n

.meas tran vdout1_51ck1460 FIND v(dout1_51) AT=735.025n

.meas tran vdout1_52ck1460 FIND v(dout1_52) AT=735.025n

.meas tran vdout1_53ck1460 FIND v(dout1_53) AT=735.025n

.meas tran vdout1_54ck1460 FIND v(dout1_54) AT=735.025n

.meas tran vdout1_55ck1460 FIND v(dout1_55) AT=735.025n

.meas tran vdout1_56ck1460 FIND v(dout1_56) AT=735.025n

.meas tran vdout1_57ck1460 FIND v(dout1_57) AT=735.025n

.meas tran vdout1_58ck1460 FIND v(dout1_58) AT=735.025n

.meas tran vdout1_59ck1460 FIND v(dout1_59) AT=735.025n

.meas tran vdout1_60ck1460 FIND v(dout1_60) AT=735.025n

.meas tran vdout1_61ck1460 FIND v(dout1_61) AT=735.025n

.meas tran vdout1_62ck1460 FIND v(dout1_62) AT=735.025n

.meas tran vdout1_63ck1460 FIND v(dout1_63) AT=735.025n

.meas tran vdout1_64ck1460 FIND v(dout1_64) AT=735.025n

.meas tran vdout1_65ck1460 FIND v(dout1_65) AT=735.025n

.meas tran vdout1_66ck1460 FIND v(dout1_66) AT=735.025n

.meas tran vdout1_67ck1460 FIND v(dout1_67) AT=735.025n

.meas tran vdout1_68ck1460 FIND v(dout1_68) AT=735.025n

.meas tran vdout1_69ck1460 FIND v(dout1_69) AT=735.025n

.meas tran vdout1_70ck1460 FIND v(dout1_70) AT=735.025n

.meas tran vdout1_71ck1460 FIND v(dout1_71) AT=735.025n

.meas tran vdout1_72ck1460 FIND v(dout1_72) AT=735.025n

.meas tran vdout1_73ck1460 FIND v(dout1_73) AT=735.025n

.meas tran vdout1_74ck1460 FIND v(dout1_74) AT=735.025n

.meas tran vdout1_75ck1460 FIND v(dout1_75) AT=735.025n

.meas tran vdout1_76ck1460 FIND v(dout1_76) AT=735.025n

.meas tran vdout1_77ck1460 FIND v(dout1_77) AT=735.025n

.meas tran vdout1_78ck1460 FIND v(dout1_78) AT=735.025n

.meas tran vdout1_79ck1460 FIND v(dout1_79) AT=735.025n

.meas tran vdout1_80ck1460 FIND v(dout1_80) AT=735.025n

.meas tran vdout1_81ck1460 FIND v(dout1_81) AT=735.025n

.meas tran vdout1_82ck1460 FIND v(dout1_82) AT=735.025n

.meas tran vdout1_83ck1460 FIND v(dout1_83) AT=735.025n

.meas tran vdout1_84ck1460 FIND v(dout1_84) AT=735.025n

.meas tran vdout1_85ck1460 FIND v(dout1_85) AT=735.025n

.meas tran vdout1_86ck1460 FIND v(dout1_86) AT=735.025n

.meas tran vdout1_87ck1460 FIND v(dout1_87) AT=735.025n

.meas tran vdout1_88ck1460 FIND v(dout1_88) AT=735.025n

.meas tran vdout1_89ck1460 FIND v(dout1_89) AT=735.025n

.meas tran vdout1_90ck1460 FIND v(dout1_90) AT=735.025n

.meas tran vdout1_91ck1460 FIND v(dout1_91) AT=735.025n

.meas tran vdout1_92ck1460 FIND v(dout1_92) AT=735.025n

.meas tran vdout1_93ck1460 FIND v(dout1_93) AT=735.025n

.meas tran vdout1_94ck1460 FIND v(dout1_94) AT=735.025n

.meas tran vdout1_95ck1460 FIND v(dout1_95) AT=735.025n

.meas tran vdout1_96ck1460 FIND v(dout1_96) AT=735.025n

.meas tran vdout1_97ck1460 FIND v(dout1_97) AT=735.025n

.meas tran vdout1_98ck1460 FIND v(dout1_98) AT=735.025n

.meas tran vdout1_99ck1460 FIND v(dout1_99) AT=735.025n

.meas tran vdout1_100ck1460 FIND v(dout1_100) AT=735.025n

.meas tran vdout1_101ck1460 FIND v(dout1_101) AT=735.025n

.meas tran vdout1_102ck1460 FIND v(dout1_102) AT=735.025n

.meas tran vdout1_103ck1460 FIND v(dout1_103) AT=735.025n

.meas tran vdout1_104ck1460 FIND v(dout1_104) AT=735.025n

.meas tran vdout1_105ck1460 FIND v(dout1_105) AT=735.025n

.meas tran vdout1_106ck1460 FIND v(dout1_106) AT=735.025n

.meas tran vdout1_107ck1460 FIND v(dout1_107) AT=735.025n

.meas tran vdout1_108ck1460 FIND v(dout1_108) AT=735.025n

.meas tran vdout1_109ck1460 FIND v(dout1_109) AT=735.025n

.meas tran vdout1_110ck1460 FIND v(dout1_110) AT=735.025n

.meas tran vdout1_111ck1460 FIND v(dout1_111) AT=735.025n

.meas tran vdout1_112ck1460 FIND v(dout1_112) AT=735.025n

.meas tran vdout1_113ck1460 FIND v(dout1_113) AT=735.025n

.meas tran vdout1_114ck1460 FIND v(dout1_114) AT=735.025n

.meas tran vdout1_115ck1460 FIND v(dout1_115) AT=735.025n

.meas tran vdout1_116ck1460 FIND v(dout1_116) AT=735.025n

.meas tran vdout1_117ck1460 FIND v(dout1_117) AT=735.025n

.meas tran vdout1_118ck1460 FIND v(dout1_118) AT=735.025n

.meas tran vdout1_119ck1460 FIND v(dout1_119) AT=735.025n

.meas tran vdout1_120ck1460 FIND v(dout1_120) AT=735.025n

.meas tran vdout1_121ck1460 FIND v(dout1_121) AT=735.025n

.meas tran vdout1_122ck1460 FIND v(dout1_122) AT=735.025n

.meas tran vdout1_123ck1460 FIND v(dout1_123) AT=735.025n

.meas tran vdout1_124ck1460 FIND v(dout1_124) AT=735.025n

.meas tran vdout1_125ck1460 FIND v(dout1_125) AT=735.025n

.meas tran vdout1_126ck1460 FIND v(dout1_126) AT=735.025n

.meas tran vdout1_127ck1460 FIND v(dout1_127) AT=735.025n

.meas tran vdout1_0ck1510 FIND v(dout1_0) AT=760.025n

.meas tran vdout1_1ck1510 FIND v(dout1_1) AT=760.025n

.meas tran vdout1_2ck1510 FIND v(dout1_2) AT=760.025n

.meas tran vdout1_3ck1510 FIND v(dout1_3) AT=760.025n

.meas tran vdout1_4ck1510 FIND v(dout1_4) AT=760.025n

.meas tran vdout1_5ck1510 FIND v(dout1_5) AT=760.025n

.meas tran vdout1_6ck1510 FIND v(dout1_6) AT=760.025n

.meas tran vdout1_7ck1510 FIND v(dout1_7) AT=760.025n

.meas tran vdout1_8ck1510 FIND v(dout1_8) AT=760.025n

.meas tran vdout1_9ck1510 FIND v(dout1_9) AT=760.025n

.meas tran vdout1_10ck1510 FIND v(dout1_10) AT=760.025n

.meas tran vdout1_11ck1510 FIND v(dout1_11) AT=760.025n

.meas tran vdout1_12ck1510 FIND v(dout1_12) AT=760.025n

.meas tran vdout1_13ck1510 FIND v(dout1_13) AT=760.025n

.meas tran vdout1_14ck1510 FIND v(dout1_14) AT=760.025n

.meas tran vdout1_15ck1510 FIND v(dout1_15) AT=760.025n

.meas tran vdout1_16ck1510 FIND v(dout1_16) AT=760.025n

.meas tran vdout1_17ck1510 FIND v(dout1_17) AT=760.025n

.meas tran vdout1_18ck1510 FIND v(dout1_18) AT=760.025n

.meas tran vdout1_19ck1510 FIND v(dout1_19) AT=760.025n

.meas tran vdout1_20ck1510 FIND v(dout1_20) AT=760.025n

.meas tran vdout1_21ck1510 FIND v(dout1_21) AT=760.025n

.meas tran vdout1_22ck1510 FIND v(dout1_22) AT=760.025n

.meas tran vdout1_23ck1510 FIND v(dout1_23) AT=760.025n

.meas tran vdout1_24ck1510 FIND v(dout1_24) AT=760.025n

.meas tran vdout1_25ck1510 FIND v(dout1_25) AT=760.025n

.meas tran vdout1_26ck1510 FIND v(dout1_26) AT=760.025n

.meas tran vdout1_27ck1510 FIND v(dout1_27) AT=760.025n

.meas tran vdout1_28ck1510 FIND v(dout1_28) AT=760.025n

.meas tran vdout1_29ck1510 FIND v(dout1_29) AT=760.025n

.meas tran vdout1_30ck1510 FIND v(dout1_30) AT=760.025n

.meas tran vdout1_31ck1510 FIND v(dout1_31) AT=760.025n

.meas tran vdout1_32ck1510 FIND v(dout1_32) AT=760.025n

.meas tran vdout1_33ck1510 FIND v(dout1_33) AT=760.025n

.meas tran vdout1_34ck1510 FIND v(dout1_34) AT=760.025n

.meas tran vdout1_35ck1510 FIND v(dout1_35) AT=760.025n

.meas tran vdout1_36ck1510 FIND v(dout1_36) AT=760.025n

.meas tran vdout1_37ck1510 FIND v(dout1_37) AT=760.025n

.meas tran vdout1_38ck1510 FIND v(dout1_38) AT=760.025n

.meas tran vdout1_39ck1510 FIND v(dout1_39) AT=760.025n

.meas tran vdout1_40ck1510 FIND v(dout1_40) AT=760.025n

.meas tran vdout1_41ck1510 FIND v(dout1_41) AT=760.025n

.meas tran vdout1_42ck1510 FIND v(dout1_42) AT=760.025n

.meas tran vdout1_43ck1510 FIND v(dout1_43) AT=760.025n

.meas tran vdout1_44ck1510 FIND v(dout1_44) AT=760.025n

.meas tran vdout1_45ck1510 FIND v(dout1_45) AT=760.025n

.meas tran vdout1_46ck1510 FIND v(dout1_46) AT=760.025n

.meas tran vdout1_47ck1510 FIND v(dout1_47) AT=760.025n

.meas tran vdout1_48ck1510 FIND v(dout1_48) AT=760.025n

.meas tran vdout1_49ck1510 FIND v(dout1_49) AT=760.025n

.meas tran vdout1_50ck1510 FIND v(dout1_50) AT=760.025n

.meas tran vdout1_51ck1510 FIND v(dout1_51) AT=760.025n

.meas tran vdout1_52ck1510 FIND v(dout1_52) AT=760.025n

.meas tran vdout1_53ck1510 FIND v(dout1_53) AT=760.025n

.meas tran vdout1_54ck1510 FIND v(dout1_54) AT=760.025n

.meas tran vdout1_55ck1510 FIND v(dout1_55) AT=760.025n

.meas tran vdout1_56ck1510 FIND v(dout1_56) AT=760.025n

.meas tran vdout1_57ck1510 FIND v(dout1_57) AT=760.025n

.meas tran vdout1_58ck1510 FIND v(dout1_58) AT=760.025n

.meas tran vdout1_59ck1510 FIND v(dout1_59) AT=760.025n

.meas tran vdout1_60ck1510 FIND v(dout1_60) AT=760.025n

.meas tran vdout1_61ck1510 FIND v(dout1_61) AT=760.025n

.meas tran vdout1_62ck1510 FIND v(dout1_62) AT=760.025n

.meas tran vdout1_63ck1510 FIND v(dout1_63) AT=760.025n

.meas tran vdout1_64ck1510 FIND v(dout1_64) AT=760.025n

.meas tran vdout1_65ck1510 FIND v(dout1_65) AT=760.025n

.meas tran vdout1_66ck1510 FIND v(dout1_66) AT=760.025n

.meas tran vdout1_67ck1510 FIND v(dout1_67) AT=760.025n

.meas tran vdout1_68ck1510 FIND v(dout1_68) AT=760.025n

.meas tran vdout1_69ck1510 FIND v(dout1_69) AT=760.025n

.meas tran vdout1_70ck1510 FIND v(dout1_70) AT=760.025n

.meas tran vdout1_71ck1510 FIND v(dout1_71) AT=760.025n

.meas tran vdout1_72ck1510 FIND v(dout1_72) AT=760.025n

.meas tran vdout1_73ck1510 FIND v(dout1_73) AT=760.025n

.meas tran vdout1_74ck1510 FIND v(dout1_74) AT=760.025n

.meas tran vdout1_75ck1510 FIND v(dout1_75) AT=760.025n

.meas tran vdout1_76ck1510 FIND v(dout1_76) AT=760.025n

.meas tran vdout1_77ck1510 FIND v(dout1_77) AT=760.025n

.meas tran vdout1_78ck1510 FIND v(dout1_78) AT=760.025n

.meas tran vdout1_79ck1510 FIND v(dout1_79) AT=760.025n

.meas tran vdout1_80ck1510 FIND v(dout1_80) AT=760.025n

.meas tran vdout1_81ck1510 FIND v(dout1_81) AT=760.025n

.meas tran vdout1_82ck1510 FIND v(dout1_82) AT=760.025n

.meas tran vdout1_83ck1510 FIND v(dout1_83) AT=760.025n

.meas tran vdout1_84ck1510 FIND v(dout1_84) AT=760.025n

.meas tran vdout1_85ck1510 FIND v(dout1_85) AT=760.025n

.meas tran vdout1_86ck1510 FIND v(dout1_86) AT=760.025n

.meas tran vdout1_87ck1510 FIND v(dout1_87) AT=760.025n

.meas tran vdout1_88ck1510 FIND v(dout1_88) AT=760.025n

.meas tran vdout1_89ck1510 FIND v(dout1_89) AT=760.025n

.meas tran vdout1_90ck1510 FIND v(dout1_90) AT=760.025n

.meas tran vdout1_91ck1510 FIND v(dout1_91) AT=760.025n

.meas tran vdout1_92ck1510 FIND v(dout1_92) AT=760.025n

.meas tran vdout1_93ck1510 FIND v(dout1_93) AT=760.025n

.meas tran vdout1_94ck1510 FIND v(dout1_94) AT=760.025n

.meas tran vdout1_95ck1510 FIND v(dout1_95) AT=760.025n

.meas tran vdout1_96ck1510 FIND v(dout1_96) AT=760.025n

.meas tran vdout1_97ck1510 FIND v(dout1_97) AT=760.025n

.meas tran vdout1_98ck1510 FIND v(dout1_98) AT=760.025n

.meas tran vdout1_99ck1510 FIND v(dout1_99) AT=760.025n

.meas tran vdout1_100ck1510 FIND v(dout1_100) AT=760.025n

.meas tran vdout1_101ck1510 FIND v(dout1_101) AT=760.025n

.meas tran vdout1_102ck1510 FIND v(dout1_102) AT=760.025n

.meas tran vdout1_103ck1510 FIND v(dout1_103) AT=760.025n

.meas tran vdout1_104ck1510 FIND v(dout1_104) AT=760.025n

.meas tran vdout1_105ck1510 FIND v(dout1_105) AT=760.025n

.meas tran vdout1_106ck1510 FIND v(dout1_106) AT=760.025n

.meas tran vdout1_107ck1510 FIND v(dout1_107) AT=760.025n

.meas tran vdout1_108ck1510 FIND v(dout1_108) AT=760.025n

.meas tran vdout1_109ck1510 FIND v(dout1_109) AT=760.025n

.meas tran vdout1_110ck1510 FIND v(dout1_110) AT=760.025n

.meas tran vdout1_111ck1510 FIND v(dout1_111) AT=760.025n

.meas tran vdout1_112ck1510 FIND v(dout1_112) AT=760.025n

.meas tran vdout1_113ck1510 FIND v(dout1_113) AT=760.025n

.meas tran vdout1_114ck1510 FIND v(dout1_114) AT=760.025n

.meas tran vdout1_115ck1510 FIND v(dout1_115) AT=760.025n

.meas tran vdout1_116ck1510 FIND v(dout1_116) AT=760.025n

.meas tran vdout1_117ck1510 FIND v(dout1_117) AT=760.025n

.meas tran vdout1_118ck1510 FIND v(dout1_118) AT=760.025n

.meas tran vdout1_119ck1510 FIND v(dout1_119) AT=760.025n

.meas tran vdout1_120ck1510 FIND v(dout1_120) AT=760.025n

.meas tran vdout1_121ck1510 FIND v(dout1_121) AT=760.025n

.meas tran vdout1_122ck1510 FIND v(dout1_122) AT=760.025n

.meas tran vdout1_123ck1510 FIND v(dout1_123) AT=760.025n

.meas tran vdout1_124ck1510 FIND v(dout1_124) AT=760.025n

.meas tran vdout1_125ck1510 FIND v(dout1_125) AT=760.025n

.meas tran vdout1_126ck1510 FIND v(dout1_126) AT=760.025n

.meas tran vdout1_127ck1510 FIND v(dout1_127) AT=760.025n

.meas tran vdout1_0ck1530 FIND v(dout1_0) AT=770.025n

.meas tran vdout1_1ck1530 FIND v(dout1_1) AT=770.025n

.meas tran vdout1_2ck1530 FIND v(dout1_2) AT=770.025n

.meas tran vdout1_3ck1530 FIND v(dout1_3) AT=770.025n

.meas tran vdout1_4ck1530 FIND v(dout1_4) AT=770.025n

.meas tran vdout1_5ck1530 FIND v(dout1_5) AT=770.025n

.meas tran vdout1_6ck1530 FIND v(dout1_6) AT=770.025n

.meas tran vdout1_7ck1530 FIND v(dout1_7) AT=770.025n

.meas tran vdout1_8ck1530 FIND v(dout1_8) AT=770.025n

.meas tran vdout1_9ck1530 FIND v(dout1_9) AT=770.025n

.meas tran vdout1_10ck1530 FIND v(dout1_10) AT=770.025n

.meas tran vdout1_11ck1530 FIND v(dout1_11) AT=770.025n

.meas tran vdout1_12ck1530 FIND v(dout1_12) AT=770.025n

.meas tran vdout1_13ck1530 FIND v(dout1_13) AT=770.025n

.meas tran vdout1_14ck1530 FIND v(dout1_14) AT=770.025n

.meas tran vdout1_15ck1530 FIND v(dout1_15) AT=770.025n

.meas tran vdout1_16ck1530 FIND v(dout1_16) AT=770.025n

.meas tran vdout1_17ck1530 FIND v(dout1_17) AT=770.025n

.meas tran vdout1_18ck1530 FIND v(dout1_18) AT=770.025n

.meas tran vdout1_19ck1530 FIND v(dout1_19) AT=770.025n

.meas tran vdout1_20ck1530 FIND v(dout1_20) AT=770.025n

.meas tran vdout1_21ck1530 FIND v(dout1_21) AT=770.025n

.meas tran vdout1_22ck1530 FIND v(dout1_22) AT=770.025n

.meas tran vdout1_23ck1530 FIND v(dout1_23) AT=770.025n

.meas tran vdout1_24ck1530 FIND v(dout1_24) AT=770.025n

.meas tran vdout1_25ck1530 FIND v(dout1_25) AT=770.025n

.meas tran vdout1_26ck1530 FIND v(dout1_26) AT=770.025n

.meas tran vdout1_27ck1530 FIND v(dout1_27) AT=770.025n

.meas tran vdout1_28ck1530 FIND v(dout1_28) AT=770.025n

.meas tran vdout1_29ck1530 FIND v(dout1_29) AT=770.025n

.meas tran vdout1_30ck1530 FIND v(dout1_30) AT=770.025n

.meas tran vdout1_31ck1530 FIND v(dout1_31) AT=770.025n

.meas tran vdout1_32ck1530 FIND v(dout1_32) AT=770.025n

.meas tran vdout1_33ck1530 FIND v(dout1_33) AT=770.025n

.meas tran vdout1_34ck1530 FIND v(dout1_34) AT=770.025n

.meas tran vdout1_35ck1530 FIND v(dout1_35) AT=770.025n

.meas tran vdout1_36ck1530 FIND v(dout1_36) AT=770.025n

.meas tran vdout1_37ck1530 FIND v(dout1_37) AT=770.025n

.meas tran vdout1_38ck1530 FIND v(dout1_38) AT=770.025n

.meas tran vdout1_39ck1530 FIND v(dout1_39) AT=770.025n

.meas tran vdout1_40ck1530 FIND v(dout1_40) AT=770.025n

.meas tran vdout1_41ck1530 FIND v(dout1_41) AT=770.025n

.meas tran vdout1_42ck1530 FIND v(dout1_42) AT=770.025n

.meas tran vdout1_43ck1530 FIND v(dout1_43) AT=770.025n

.meas tran vdout1_44ck1530 FIND v(dout1_44) AT=770.025n

.meas tran vdout1_45ck1530 FIND v(dout1_45) AT=770.025n

.meas tran vdout1_46ck1530 FIND v(dout1_46) AT=770.025n

.meas tran vdout1_47ck1530 FIND v(dout1_47) AT=770.025n

.meas tran vdout1_48ck1530 FIND v(dout1_48) AT=770.025n

.meas tran vdout1_49ck1530 FIND v(dout1_49) AT=770.025n

.meas tran vdout1_50ck1530 FIND v(dout1_50) AT=770.025n

.meas tran vdout1_51ck1530 FIND v(dout1_51) AT=770.025n

.meas tran vdout1_52ck1530 FIND v(dout1_52) AT=770.025n

.meas tran vdout1_53ck1530 FIND v(dout1_53) AT=770.025n

.meas tran vdout1_54ck1530 FIND v(dout1_54) AT=770.025n

.meas tran vdout1_55ck1530 FIND v(dout1_55) AT=770.025n

.meas tran vdout1_56ck1530 FIND v(dout1_56) AT=770.025n

.meas tran vdout1_57ck1530 FIND v(dout1_57) AT=770.025n

.meas tran vdout1_58ck1530 FIND v(dout1_58) AT=770.025n

.meas tran vdout1_59ck1530 FIND v(dout1_59) AT=770.025n

.meas tran vdout1_60ck1530 FIND v(dout1_60) AT=770.025n

.meas tran vdout1_61ck1530 FIND v(dout1_61) AT=770.025n

.meas tran vdout1_62ck1530 FIND v(dout1_62) AT=770.025n

.meas tran vdout1_63ck1530 FIND v(dout1_63) AT=770.025n

.meas tran vdout1_64ck1530 FIND v(dout1_64) AT=770.025n

.meas tran vdout1_65ck1530 FIND v(dout1_65) AT=770.025n

.meas tran vdout1_66ck1530 FIND v(dout1_66) AT=770.025n

.meas tran vdout1_67ck1530 FIND v(dout1_67) AT=770.025n

.meas tran vdout1_68ck1530 FIND v(dout1_68) AT=770.025n

.meas tran vdout1_69ck1530 FIND v(dout1_69) AT=770.025n

.meas tran vdout1_70ck1530 FIND v(dout1_70) AT=770.025n

.meas tran vdout1_71ck1530 FIND v(dout1_71) AT=770.025n

.meas tran vdout1_72ck1530 FIND v(dout1_72) AT=770.025n

.meas tran vdout1_73ck1530 FIND v(dout1_73) AT=770.025n

.meas tran vdout1_74ck1530 FIND v(dout1_74) AT=770.025n

.meas tran vdout1_75ck1530 FIND v(dout1_75) AT=770.025n

.meas tran vdout1_76ck1530 FIND v(dout1_76) AT=770.025n

.meas tran vdout1_77ck1530 FIND v(dout1_77) AT=770.025n

.meas tran vdout1_78ck1530 FIND v(dout1_78) AT=770.025n

.meas tran vdout1_79ck1530 FIND v(dout1_79) AT=770.025n

.meas tran vdout1_80ck1530 FIND v(dout1_80) AT=770.025n

.meas tran vdout1_81ck1530 FIND v(dout1_81) AT=770.025n

.meas tran vdout1_82ck1530 FIND v(dout1_82) AT=770.025n

.meas tran vdout1_83ck1530 FIND v(dout1_83) AT=770.025n

.meas tran vdout1_84ck1530 FIND v(dout1_84) AT=770.025n

.meas tran vdout1_85ck1530 FIND v(dout1_85) AT=770.025n

.meas tran vdout1_86ck1530 FIND v(dout1_86) AT=770.025n

.meas tran vdout1_87ck1530 FIND v(dout1_87) AT=770.025n

.meas tran vdout1_88ck1530 FIND v(dout1_88) AT=770.025n

.meas tran vdout1_89ck1530 FIND v(dout1_89) AT=770.025n

.meas tran vdout1_90ck1530 FIND v(dout1_90) AT=770.025n

.meas tran vdout1_91ck1530 FIND v(dout1_91) AT=770.025n

.meas tran vdout1_92ck1530 FIND v(dout1_92) AT=770.025n

.meas tran vdout1_93ck1530 FIND v(dout1_93) AT=770.025n

.meas tran vdout1_94ck1530 FIND v(dout1_94) AT=770.025n

.meas tran vdout1_95ck1530 FIND v(dout1_95) AT=770.025n

.meas tran vdout1_96ck1530 FIND v(dout1_96) AT=770.025n

.meas tran vdout1_97ck1530 FIND v(dout1_97) AT=770.025n

.meas tran vdout1_98ck1530 FIND v(dout1_98) AT=770.025n

.meas tran vdout1_99ck1530 FIND v(dout1_99) AT=770.025n

.meas tran vdout1_100ck1530 FIND v(dout1_100) AT=770.025n

.meas tran vdout1_101ck1530 FIND v(dout1_101) AT=770.025n

.meas tran vdout1_102ck1530 FIND v(dout1_102) AT=770.025n

.meas tran vdout1_103ck1530 FIND v(dout1_103) AT=770.025n

.meas tran vdout1_104ck1530 FIND v(dout1_104) AT=770.025n

.meas tran vdout1_105ck1530 FIND v(dout1_105) AT=770.025n

.meas tran vdout1_106ck1530 FIND v(dout1_106) AT=770.025n

.meas tran vdout1_107ck1530 FIND v(dout1_107) AT=770.025n

.meas tran vdout1_108ck1530 FIND v(dout1_108) AT=770.025n

.meas tran vdout1_109ck1530 FIND v(dout1_109) AT=770.025n

.meas tran vdout1_110ck1530 FIND v(dout1_110) AT=770.025n

.meas tran vdout1_111ck1530 FIND v(dout1_111) AT=770.025n

.meas tran vdout1_112ck1530 FIND v(dout1_112) AT=770.025n

.meas tran vdout1_113ck1530 FIND v(dout1_113) AT=770.025n

.meas tran vdout1_114ck1530 FIND v(dout1_114) AT=770.025n

.meas tran vdout1_115ck1530 FIND v(dout1_115) AT=770.025n

.meas tran vdout1_116ck1530 FIND v(dout1_116) AT=770.025n

.meas tran vdout1_117ck1530 FIND v(dout1_117) AT=770.025n

.meas tran vdout1_118ck1530 FIND v(dout1_118) AT=770.025n

.meas tran vdout1_119ck1530 FIND v(dout1_119) AT=770.025n

.meas tran vdout1_120ck1530 FIND v(dout1_120) AT=770.025n

.meas tran vdout1_121ck1530 FIND v(dout1_121) AT=770.025n

.meas tran vdout1_122ck1530 FIND v(dout1_122) AT=770.025n

.meas tran vdout1_123ck1530 FIND v(dout1_123) AT=770.025n

.meas tran vdout1_124ck1530 FIND v(dout1_124) AT=770.025n

.meas tran vdout1_125ck1530 FIND v(dout1_125) AT=770.025n

.meas tran vdout1_126ck1530 FIND v(dout1_126) AT=770.025n

.meas tran vdout1_127ck1530 FIND v(dout1_127) AT=770.025n

.meas tran vdout1_0ck1550 FIND v(dout1_0) AT=780.025n

.meas tran vdout1_1ck1550 FIND v(dout1_1) AT=780.025n

.meas tran vdout1_2ck1550 FIND v(dout1_2) AT=780.025n

.meas tran vdout1_3ck1550 FIND v(dout1_3) AT=780.025n

.meas tran vdout1_4ck1550 FIND v(dout1_4) AT=780.025n

.meas tran vdout1_5ck1550 FIND v(dout1_5) AT=780.025n

.meas tran vdout1_6ck1550 FIND v(dout1_6) AT=780.025n

.meas tran vdout1_7ck1550 FIND v(dout1_7) AT=780.025n

.meas tran vdout1_8ck1550 FIND v(dout1_8) AT=780.025n

.meas tran vdout1_9ck1550 FIND v(dout1_9) AT=780.025n

.meas tran vdout1_10ck1550 FIND v(dout1_10) AT=780.025n

.meas tran vdout1_11ck1550 FIND v(dout1_11) AT=780.025n

.meas tran vdout1_12ck1550 FIND v(dout1_12) AT=780.025n

.meas tran vdout1_13ck1550 FIND v(dout1_13) AT=780.025n

.meas tran vdout1_14ck1550 FIND v(dout1_14) AT=780.025n

.meas tran vdout1_15ck1550 FIND v(dout1_15) AT=780.025n

.meas tran vdout1_16ck1550 FIND v(dout1_16) AT=780.025n

.meas tran vdout1_17ck1550 FIND v(dout1_17) AT=780.025n

.meas tran vdout1_18ck1550 FIND v(dout1_18) AT=780.025n

.meas tran vdout1_19ck1550 FIND v(dout1_19) AT=780.025n

.meas tran vdout1_20ck1550 FIND v(dout1_20) AT=780.025n

.meas tran vdout1_21ck1550 FIND v(dout1_21) AT=780.025n

.meas tran vdout1_22ck1550 FIND v(dout1_22) AT=780.025n

.meas tran vdout1_23ck1550 FIND v(dout1_23) AT=780.025n

.meas tran vdout1_24ck1550 FIND v(dout1_24) AT=780.025n

.meas tran vdout1_25ck1550 FIND v(dout1_25) AT=780.025n

.meas tran vdout1_26ck1550 FIND v(dout1_26) AT=780.025n

.meas tran vdout1_27ck1550 FIND v(dout1_27) AT=780.025n

.meas tran vdout1_28ck1550 FIND v(dout1_28) AT=780.025n

.meas tran vdout1_29ck1550 FIND v(dout1_29) AT=780.025n

.meas tran vdout1_30ck1550 FIND v(dout1_30) AT=780.025n

.meas tran vdout1_31ck1550 FIND v(dout1_31) AT=780.025n

.meas tran vdout1_32ck1550 FIND v(dout1_32) AT=780.025n

.meas tran vdout1_33ck1550 FIND v(dout1_33) AT=780.025n

.meas tran vdout1_34ck1550 FIND v(dout1_34) AT=780.025n

.meas tran vdout1_35ck1550 FIND v(dout1_35) AT=780.025n

.meas tran vdout1_36ck1550 FIND v(dout1_36) AT=780.025n

.meas tran vdout1_37ck1550 FIND v(dout1_37) AT=780.025n

.meas tran vdout1_38ck1550 FIND v(dout1_38) AT=780.025n

.meas tran vdout1_39ck1550 FIND v(dout1_39) AT=780.025n

.meas tran vdout1_40ck1550 FIND v(dout1_40) AT=780.025n

.meas tran vdout1_41ck1550 FIND v(dout1_41) AT=780.025n

.meas tran vdout1_42ck1550 FIND v(dout1_42) AT=780.025n

.meas tran vdout1_43ck1550 FIND v(dout1_43) AT=780.025n

.meas tran vdout1_44ck1550 FIND v(dout1_44) AT=780.025n

.meas tran vdout1_45ck1550 FIND v(dout1_45) AT=780.025n

.meas tran vdout1_46ck1550 FIND v(dout1_46) AT=780.025n

.meas tran vdout1_47ck1550 FIND v(dout1_47) AT=780.025n

.meas tran vdout1_48ck1550 FIND v(dout1_48) AT=780.025n

.meas tran vdout1_49ck1550 FIND v(dout1_49) AT=780.025n

.meas tran vdout1_50ck1550 FIND v(dout1_50) AT=780.025n

.meas tran vdout1_51ck1550 FIND v(dout1_51) AT=780.025n

.meas tran vdout1_52ck1550 FIND v(dout1_52) AT=780.025n

.meas tran vdout1_53ck1550 FIND v(dout1_53) AT=780.025n

.meas tran vdout1_54ck1550 FIND v(dout1_54) AT=780.025n

.meas tran vdout1_55ck1550 FIND v(dout1_55) AT=780.025n

.meas tran vdout1_56ck1550 FIND v(dout1_56) AT=780.025n

.meas tran vdout1_57ck1550 FIND v(dout1_57) AT=780.025n

.meas tran vdout1_58ck1550 FIND v(dout1_58) AT=780.025n

.meas tran vdout1_59ck1550 FIND v(dout1_59) AT=780.025n

.meas tran vdout1_60ck1550 FIND v(dout1_60) AT=780.025n

.meas tran vdout1_61ck1550 FIND v(dout1_61) AT=780.025n

.meas tran vdout1_62ck1550 FIND v(dout1_62) AT=780.025n

.meas tran vdout1_63ck1550 FIND v(dout1_63) AT=780.025n

.meas tran vdout1_64ck1550 FIND v(dout1_64) AT=780.025n

.meas tran vdout1_65ck1550 FIND v(dout1_65) AT=780.025n

.meas tran vdout1_66ck1550 FIND v(dout1_66) AT=780.025n

.meas tran vdout1_67ck1550 FIND v(dout1_67) AT=780.025n

.meas tran vdout1_68ck1550 FIND v(dout1_68) AT=780.025n

.meas tran vdout1_69ck1550 FIND v(dout1_69) AT=780.025n

.meas tran vdout1_70ck1550 FIND v(dout1_70) AT=780.025n

.meas tran vdout1_71ck1550 FIND v(dout1_71) AT=780.025n

.meas tran vdout1_72ck1550 FIND v(dout1_72) AT=780.025n

.meas tran vdout1_73ck1550 FIND v(dout1_73) AT=780.025n

.meas tran vdout1_74ck1550 FIND v(dout1_74) AT=780.025n

.meas tran vdout1_75ck1550 FIND v(dout1_75) AT=780.025n

.meas tran vdout1_76ck1550 FIND v(dout1_76) AT=780.025n

.meas tran vdout1_77ck1550 FIND v(dout1_77) AT=780.025n

.meas tran vdout1_78ck1550 FIND v(dout1_78) AT=780.025n

.meas tran vdout1_79ck1550 FIND v(dout1_79) AT=780.025n

.meas tran vdout1_80ck1550 FIND v(dout1_80) AT=780.025n

.meas tran vdout1_81ck1550 FIND v(dout1_81) AT=780.025n

.meas tran vdout1_82ck1550 FIND v(dout1_82) AT=780.025n

.meas tran vdout1_83ck1550 FIND v(dout1_83) AT=780.025n

.meas tran vdout1_84ck1550 FIND v(dout1_84) AT=780.025n

.meas tran vdout1_85ck1550 FIND v(dout1_85) AT=780.025n

.meas tran vdout1_86ck1550 FIND v(dout1_86) AT=780.025n

.meas tran vdout1_87ck1550 FIND v(dout1_87) AT=780.025n

.meas tran vdout1_88ck1550 FIND v(dout1_88) AT=780.025n

.meas tran vdout1_89ck1550 FIND v(dout1_89) AT=780.025n

.meas tran vdout1_90ck1550 FIND v(dout1_90) AT=780.025n

.meas tran vdout1_91ck1550 FIND v(dout1_91) AT=780.025n

.meas tran vdout1_92ck1550 FIND v(dout1_92) AT=780.025n

.meas tran vdout1_93ck1550 FIND v(dout1_93) AT=780.025n

.meas tran vdout1_94ck1550 FIND v(dout1_94) AT=780.025n

.meas tran vdout1_95ck1550 FIND v(dout1_95) AT=780.025n

.meas tran vdout1_96ck1550 FIND v(dout1_96) AT=780.025n

.meas tran vdout1_97ck1550 FIND v(dout1_97) AT=780.025n

.meas tran vdout1_98ck1550 FIND v(dout1_98) AT=780.025n

.meas tran vdout1_99ck1550 FIND v(dout1_99) AT=780.025n

.meas tran vdout1_100ck1550 FIND v(dout1_100) AT=780.025n

.meas tran vdout1_101ck1550 FIND v(dout1_101) AT=780.025n

.meas tran vdout1_102ck1550 FIND v(dout1_102) AT=780.025n

.meas tran vdout1_103ck1550 FIND v(dout1_103) AT=780.025n

.meas tran vdout1_104ck1550 FIND v(dout1_104) AT=780.025n

.meas tran vdout1_105ck1550 FIND v(dout1_105) AT=780.025n

.meas tran vdout1_106ck1550 FIND v(dout1_106) AT=780.025n

.meas tran vdout1_107ck1550 FIND v(dout1_107) AT=780.025n

.meas tran vdout1_108ck1550 FIND v(dout1_108) AT=780.025n

.meas tran vdout1_109ck1550 FIND v(dout1_109) AT=780.025n

.meas tran vdout1_110ck1550 FIND v(dout1_110) AT=780.025n

.meas tran vdout1_111ck1550 FIND v(dout1_111) AT=780.025n

.meas tran vdout1_112ck1550 FIND v(dout1_112) AT=780.025n

.meas tran vdout1_113ck1550 FIND v(dout1_113) AT=780.025n

.meas tran vdout1_114ck1550 FIND v(dout1_114) AT=780.025n

.meas tran vdout1_115ck1550 FIND v(dout1_115) AT=780.025n

.meas tran vdout1_116ck1550 FIND v(dout1_116) AT=780.025n

.meas tran vdout1_117ck1550 FIND v(dout1_117) AT=780.025n

.meas tran vdout1_118ck1550 FIND v(dout1_118) AT=780.025n

.meas tran vdout1_119ck1550 FIND v(dout1_119) AT=780.025n

.meas tran vdout1_120ck1550 FIND v(dout1_120) AT=780.025n

.meas tran vdout1_121ck1550 FIND v(dout1_121) AT=780.025n

.meas tran vdout1_122ck1550 FIND v(dout1_122) AT=780.025n

.meas tran vdout1_123ck1550 FIND v(dout1_123) AT=780.025n

.meas tran vdout1_124ck1550 FIND v(dout1_124) AT=780.025n

.meas tran vdout1_125ck1550 FIND v(dout1_125) AT=780.025n

.meas tran vdout1_126ck1550 FIND v(dout1_126) AT=780.025n

.meas tran vdout1_127ck1550 FIND v(dout1_127) AT=780.025n

.meas tran vdout1_0ck1640 FIND v(dout1_0) AT=825.025n

.meas tran vdout1_1ck1640 FIND v(dout1_1) AT=825.025n

.meas tran vdout1_2ck1640 FIND v(dout1_2) AT=825.025n

.meas tran vdout1_3ck1640 FIND v(dout1_3) AT=825.025n

.meas tran vdout1_4ck1640 FIND v(dout1_4) AT=825.025n

.meas tran vdout1_5ck1640 FIND v(dout1_5) AT=825.025n

.meas tran vdout1_6ck1640 FIND v(dout1_6) AT=825.025n

.meas tran vdout1_7ck1640 FIND v(dout1_7) AT=825.025n

.meas tran vdout1_8ck1640 FIND v(dout1_8) AT=825.025n

.meas tran vdout1_9ck1640 FIND v(dout1_9) AT=825.025n

.meas tran vdout1_10ck1640 FIND v(dout1_10) AT=825.025n

.meas tran vdout1_11ck1640 FIND v(dout1_11) AT=825.025n

.meas tran vdout1_12ck1640 FIND v(dout1_12) AT=825.025n

.meas tran vdout1_13ck1640 FIND v(dout1_13) AT=825.025n

.meas tran vdout1_14ck1640 FIND v(dout1_14) AT=825.025n

.meas tran vdout1_15ck1640 FIND v(dout1_15) AT=825.025n

.meas tran vdout1_16ck1640 FIND v(dout1_16) AT=825.025n

.meas tran vdout1_17ck1640 FIND v(dout1_17) AT=825.025n

.meas tran vdout1_18ck1640 FIND v(dout1_18) AT=825.025n

.meas tran vdout1_19ck1640 FIND v(dout1_19) AT=825.025n

.meas tran vdout1_20ck1640 FIND v(dout1_20) AT=825.025n

.meas tran vdout1_21ck1640 FIND v(dout1_21) AT=825.025n

.meas tran vdout1_22ck1640 FIND v(dout1_22) AT=825.025n

.meas tran vdout1_23ck1640 FIND v(dout1_23) AT=825.025n

.meas tran vdout1_24ck1640 FIND v(dout1_24) AT=825.025n

.meas tran vdout1_25ck1640 FIND v(dout1_25) AT=825.025n

.meas tran vdout1_26ck1640 FIND v(dout1_26) AT=825.025n

.meas tran vdout1_27ck1640 FIND v(dout1_27) AT=825.025n

.meas tran vdout1_28ck1640 FIND v(dout1_28) AT=825.025n

.meas tran vdout1_29ck1640 FIND v(dout1_29) AT=825.025n

.meas tran vdout1_30ck1640 FIND v(dout1_30) AT=825.025n

.meas tran vdout1_31ck1640 FIND v(dout1_31) AT=825.025n

.meas tran vdout1_32ck1640 FIND v(dout1_32) AT=825.025n

.meas tran vdout1_33ck1640 FIND v(dout1_33) AT=825.025n

.meas tran vdout1_34ck1640 FIND v(dout1_34) AT=825.025n

.meas tran vdout1_35ck1640 FIND v(dout1_35) AT=825.025n

.meas tran vdout1_36ck1640 FIND v(dout1_36) AT=825.025n

.meas tran vdout1_37ck1640 FIND v(dout1_37) AT=825.025n

.meas tran vdout1_38ck1640 FIND v(dout1_38) AT=825.025n

.meas tran vdout1_39ck1640 FIND v(dout1_39) AT=825.025n

.meas tran vdout1_40ck1640 FIND v(dout1_40) AT=825.025n

.meas tran vdout1_41ck1640 FIND v(dout1_41) AT=825.025n

.meas tran vdout1_42ck1640 FIND v(dout1_42) AT=825.025n

.meas tran vdout1_43ck1640 FIND v(dout1_43) AT=825.025n

.meas tran vdout1_44ck1640 FIND v(dout1_44) AT=825.025n

.meas tran vdout1_45ck1640 FIND v(dout1_45) AT=825.025n

.meas tran vdout1_46ck1640 FIND v(dout1_46) AT=825.025n

.meas tran vdout1_47ck1640 FIND v(dout1_47) AT=825.025n

.meas tran vdout1_48ck1640 FIND v(dout1_48) AT=825.025n

.meas tran vdout1_49ck1640 FIND v(dout1_49) AT=825.025n

.meas tran vdout1_50ck1640 FIND v(dout1_50) AT=825.025n

.meas tran vdout1_51ck1640 FIND v(dout1_51) AT=825.025n

.meas tran vdout1_52ck1640 FIND v(dout1_52) AT=825.025n

.meas tran vdout1_53ck1640 FIND v(dout1_53) AT=825.025n

.meas tran vdout1_54ck1640 FIND v(dout1_54) AT=825.025n

.meas tran vdout1_55ck1640 FIND v(dout1_55) AT=825.025n

.meas tran vdout1_56ck1640 FIND v(dout1_56) AT=825.025n

.meas tran vdout1_57ck1640 FIND v(dout1_57) AT=825.025n

.meas tran vdout1_58ck1640 FIND v(dout1_58) AT=825.025n

.meas tran vdout1_59ck1640 FIND v(dout1_59) AT=825.025n

.meas tran vdout1_60ck1640 FIND v(dout1_60) AT=825.025n

.meas tran vdout1_61ck1640 FIND v(dout1_61) AT=825.025n

.meas tran vdout1_62ck1640 FIND v(dout1_62) AT=825.025n

.meas tran vdout1_63ck1640 FIND v(dout1_63) AT=825.025n

.meas tran vdout1_64ck1640 FIND v(dout1_64) AT=825.025n

.meas tran vdout1_65ck1640 FIND v(dout1_65) AT=825.025n

.meas tran vdout1_66ck1640 FIND v(dout1_66) AT=825.025n

.meas tran vdout1_67ck1640 FIND v(dout1_67) AT=825.025n

.meas tran vdout1_68ck1640 FIND v(dout1_68) AT=825.025n

.meas tran vdout1_69ck1640 FIND v(dout1_69) AT=825.025n

.meas tran vdout1_70ck1640 FIND v(dout1_70) AT=825.025n

.meas tran vdout1_71ck1640 FIND v(dout1_71) AT=825.025n

.meas tran vdout1_72ck1640 FIND v(dout1_72) AT=825.025n

.meas tran vdout1_73ck1640 FIND v(dout1_73) AT=825.025n

.meas tran vdout1_74ck1640 FIND v(dout1_74) AT=825.025n

.meas tran vdout1_75ck1640 FIND v(dout1_75) AT=825.025n

.meas tran vdout1_76ck1640 FIND v(dout1_76) AT=825.025n

.meas tran vdout1_77ck1640 FIND v(dout1_77) AT=825.025n

.meas tran vdout1_78ck1640 FIND v(dout1_78) AT=825.025n

.meas tran vdout1_79ck1640 FIND v(dout1_79) AT=825.025n

.meas tran vdout1_80ck1640 FIND v(dout1_80) AT=825.025n

.meas tran vdout1_81ck1640 FIND v(dout1_81) AT=825.025n

.meas tran vdout1_82ck1640 FIND v(dout1_82) AT=825.025n

.meas tran vdout1_83ck1640 FIND v(dout1_83) AT=825.025n

.meas tran vdout1_84ck1640 FIND v(dout1_84) AT=825.025n

.meas tran vdout1_85ck1640 FIND v(dout1_85) AT=825.025n

.meas tran vdout1_86ck1640 FIND v(dout1_86) AT=825.025n

.meas tran vdout1_87ck1640 FIND v(dout1_87) AT=825.025n

.meas tran vdout1_88ck1640 FIND v(dout1_88) AT=825.025n

.meas tran vdout1_89ck1640 FIND v(dout1_89) AT=825.025n

.meas tran vdout1_90ck1640 FIND v(dout1_90) AT=825.025n

.meas tran vdout1_91ck1640 FIND v(dout1_91) AT=825.025n

.meas tran vdout1_92ck1640 FIND v(dout1_92) AT=825.025n

.meas tran vdout1_93ck1640 FIND v(dout1_93) AT=825.025n

.meas tran vdout1_94ck1640 FIND v(dout1_94) AT=825.025n

.meas tran vdout1_95ck1640 FIND v(dout1_95) AT=825.025n

.meas tran vdout1_96ck1640 FIND v(dout1_96) AT=825.025n

.meas tran vdout1_97ck1640 FIND v(dout1_97) AT=825.025n

.meas tran vdout1_98ck1640 FIND v(dout1_98) AT=825.025n

.meas tran vdout1_99ck1640 FIND v(dout1_99) AT=825.025n

.meas tran vdout1_100ck1640 FIND v(dout1_100) AT=825.025n

.meas tran vdout1_101ck1640 FIND v(dout1_101) AT=825.025n

.meas tran vdout1_102ck1640 FIND v(dout1_102) AT=825.025n

.meas tran vdout1_103ck1640 FIND v(dout1_103) AT=825.025n

.meas tran vdout1_104ck1640 FIND v(dout1_104) AT=825.025n

.meas tran vdout1_105ck1640 FIND v(dout1_105) AT=825.025n

.meas tran vdout1_106ck1640 FIND v(dout1_106) AT=825.025n

.meas tran vdout1_107ck1640 FIND v(dout1_107) AT=825.025n

.meas tran vdout1_108ck1640 FIND v(dout1_108) AT=825.025n

.meas tran vdout1_109ck1640 FIND v(dout1_109) AT=825.025n

.meas tran vdout1_110ck1640 FIND v(dout1_110) AT=825.025n

.meas tran vdout1_111ck1640 FIND v(dout1_111) AT=825.025n

.meas tran vdout1_112ck1640 FIND v(dout1_112) AT=825.025n

.meas tran vdout1_113ck1640 FIND v(dout1_113) AT=825.025n

.meas tran vdout1_114ck1640 FIND v(dout1_114) AT=825.025n

.meas tran vdout1_115ck1640 FIND v(dout1_115) AT=825.025n

.meas tran vdout1_116ck1640 FIND v(dout1_116) AT=825.025n

.meas tran vdout1_117ck1640 FIND v(dout1_117) AT=825.025n

.meas tran vdout1_118ck1640 FIND v(dout1_118) AT=825.025n

.meas tran vdout1_119ck1640 FIND v(dout1_119) AT=825.025n

.meas tran vdout1_120ck1640 FIND v(dout1_120) AT=825.025n

.meas tran vdout1_121ck1640 FIND v(dout1_121) AT=825.025n

.meas tran vdout1_122ck1640 FIND v(dout1_122) AT=825.025n

.meas tran vdout1_123ck1640 FIND v(dout1_123) AT=825.025n

.meas tran vdout1_124ck1640 FIND v(dout1_124) AT=825.025n

.meas tran vdout1_125ck1640 FIND v(dout1_125) AT=825.025n

.meas tran vdout1_126ck1640 FIND v(dout1_126) AT=825.025n

.meas tran vdout1_127ck1640 FIND v(dout1_127) AT=825.025n

.meas tran vdout1_0ck1660 FIND v(dout1_0) AT=835.025n

.meas tran vdout1_1ck1660 FIND v(dout1_1) AT=835.025n

.meas tran vdout1_2ck1660 FIND v(dout1_2) AT=835.025n

.meas tran vdout1_3ck1660 FIND v(dout1_3) AT=835.025n

.meas tran vdout1_4ck1660 FIND v(dout1_4) AT=835.025n

.meas tran vdout1_5ck1660 FIND v(dout1_5) AT=835.025n

.meas tran vdout1_6ck1660 FIND v(dout1_6) AT=835.025n

.meas tran vdout1_7ck1660 FIND v(dout1_7) AT=835.025n

.meas tran vdout1_8ck1660 FIND v(dout1_8) AT=835.025n

.meas tran vdout1_9ck1660 FIND v(dout1_9) AT=835.025n

.meas tran vdout1_10ck1660 FIND v(dout1_10) AT=835.025n

.meas tran vdout1_11ck1660 FIND v(dout1_11) AT=835.025n

.meas tran vdout1_12ck1660 FIND v(dout1_12) AT=835.025n

.meas tran vdout1_13ck1660 FIND v(dout1_13) AT=835.025n

.meas tran vdout1_14ck1660 FIND v(dout1_14) AT=835.025n

.meas tran vdout1_15ck1660 FIND v(dout1_15) AT=835.025n

.meas tran vdout1_16ck1660 FIND v(dout1_16) AT=835.025n

.meas tran vdout1_17ck1660 FIND v(dout1_17) AT=835.025n

.meas tran vdout1_18ck1660 FIND v(dout1_18) AT=835.025n

.meas tran vdout1_19ck1660 FIND v(dout1_19) AT=835.025n

.meas tran vdout1_20ck1660 FIND v(dout1_20) AT=835.025n

.meas tran vdout1_21ck1660 FIND v(dout1_21) AT=835.025n

.meas tran vdout1_22ck1660 FIND v(dout1_22) AT=835.025n

.meas tran vdout1_23ck1660 FIND v(dout1_23) AT=835.025n

.meas tran vdout1_24ck1660 FIND v(dout1_24) AT=835.025n

.meas tran vdout1_25ck1660 FIND v(dout1_25) AT=835.025n

.meas tran vdout1_26ck1660 FIND v(dout1_26) AT=835.025n

.meas tran vdout1_27ck1660 FIND v(dout1_27) AT=835.025n

.meas tran vdout1_28ck1660 FIND v(dout1_28) AT=835.025n

.meas tran vdout1_29ck1660 FIND v(dout1_29) AT=835.025n

.meas tran vdout1_30ck1660 FIND v(dout1_30) AT=835.025n

.meas tran vdout1_31ck1660 FIND v(dout1_31) AT=835.025n

.meas tran vdout1_32ck1660 FIND v(dout1_32) AT=835.025n

.meas tran vdout1_33ck1660 FIND v(dout1_33) AT=835.025n

.meas tran vdout1_34ck1660 FIND v(dout1_34) AT=835.025n

.meas tran vdout1_35ck1660 FIND v(dout1_35) AT=835.025n

.meas tran vdout1_36ck1660 FIND v(dout1_36) AT=835.025n

.meas tran vdout1_37ck1660 FIND v(dout1_37) AT=835.025n

.meas tran vdout1_38ck1660 FIND v(dout1_38) AT=835.025n

.meas tran vdout1_39ck1660 FIND v(dout1_39) AT=835.025n

.meas tran vdout1_40ck1660 FIND v(dout1_40) AT=835.025n

.meas tran vdout1_41ck1660 FIND v(dout1_41) AT=835.025n

.meas tran vdout1_42ck1660 FIND v(dout1_42) AT=835.025n

.meas tran vdout1_43ck1660 FIND v(dout1_43) AT=835.025n

.meas tran vdout1_44ck1660 FIND v(dout1_44) AT=835.025n

.meas tran vdout1_45ck1660 FIND v(dout1_45) AT=835.025n

.meas tran vdout1_46ck1660 FIND v(dout1_46) AT=835.025n

.meas tran vdout1_47ck1660 FIND v(dout1_47) AT=835.025n

.meas tran vdout1_48ck1660 FIND v(dout1_48) AT=835.025n

.meas tran vdout1_49ck1660 FIND v(dout1_49) AT=835.025n

.meas tran vdout1_50ck1660 FIND v(dout1_50) AT=835.025n

.meas tran vdout1_51ck1660 FIND v(dout1_51) AT=835.025n

.meas tran vdout1_52ck1660 FIND v(dout1_52) AT=835.025n

.meas tran vdout1_53ck1660 FIND v(dout1_53) AT=835.025n

.meas tran vdout1_54ck1660 FIND v(dout1_54) AT=835.025n

.meas tran vdout1_55ck1660 FIND v(dout1_55) AT=835.025n

.meas tran vdout1_56ck1660 FIND v(dout1_56) AT=835.025n

.meas tran vdout1_57ck1660 FIND v(dout1_57) AT=835.025n

.meas tran vdout1_58ck1660 FIND v(dout1_58) AT=835.025n

.meas tran vdout1_59ck1660 FIND v(dout1_59) AT=835.025n

.meas tran vdout1_60ck1660 FIND v(dout1_60) AT=835.025n

.meas tran vdout1_61ck1660 FIND v(dout1_61) AT=835.025n

.meas tran vdout1_62ck1660 FIND v(dout1_62) AT=835.025n

.meas tran vdout1_63ck1660 FIND v(dout1_63) AT=835.025n

.meas tran vdout1_64ck1660 FIND v(dout1_64) AT=835.025n

.meas tran vdout1_65ck1660 FIND v(dout1_65) AT=835.025n

.meas tran vdout1_66ck1660 FIND v(dout1_66) AT=835.025n

.meas tran vdout1_67ck1660 FIND v(dout1_67) AT=835.025n

.meas tran vdout1_68ck1660 FIND v(dout1_68) AT=835.025n

.meas tran vdout1_69ck1660 FIND v(dout1_69) AT=835.025n

.meas tran vdout1_70ck1660 FIND v(dout1_70) AT=835.025n

.meas tran vdout1_71ck1660 FIND v(dout1_71) AT=835.025n

.meas tran vdout1_72ck1660 FIND v(dout1_72) AT=835.025n

.meas tran vdout1_73ck1660 FIND v(dout1_73) AT=835.025n

.meas tran vdout1_74ck1660 FIND v(dout1_74) AT=835.025n

.meas tran vdout1_75ck1660 FIND v(dout1_75) AT=835.025n

.meas tran vdout1_76ck1660 FIND v(dout1_76) AT=835.025n

.meas tran vdout1_77ck1660 FIND v(dout1_77) AT=835.025n

.meas tran vdout1_78ck1660 FIND v(dout1_78) AT=835.025n

.meas tran vdout1_79ck1660 FIND v(dout1_79) AT=835.025n

.meas tran vdout1_80ck1660 FIND v(dout1_80) AT=835.025n

.meas tran vdout1_81ck1660 FIND v(dout1_81) AT=835.025n

.meas tran vdout1_82ck1660 FIND v(dout1_82) AT=835.025n

.meas tran vdout1_83ck1660 FIND v(dout1_83) AT=835.025n

.meas tran vdout1_84ck1660 FIND v(dout1_84) AT=835.025n

.meas tran vdout1_85ck1660 FIND v(dout1_85) AT=835.025n

.meas tran vdout1_86ck1660 FIND v(dout1_86) AT=835.025n

.meas tran vdout1_87ck1660 FIND v(dout1_87) AT=835.025n

.meas tran vdout1_88ck1660 FIND v(dout1_88) AT=835.025n

.meas tran vdout1_89ck1660 FIND v(dout1_89) AT=835.025n

.meas tran vdout1_90ck1660 FIND v(dout1_90) AT=835.025n

.meas tran vdout1_91ck1660 FIND v(dout1_91) AT=835.025n

.meas tran vdout1_92ck1660 FIND v(dout1_92) AT=835.025n

.meas tran vdout1_93ck1660 FIND v(dout1_93) AT=835.025n

.meas tran vdout1_94ck1660 FIND v(dout1_94) AT=835.025n

.meas tran vdout1_95ck1660 FIND v(dout1_95) AT=835.025n

.meas tran vdout1_96ck1660 FIND v(dout1_96) AT=835.025n

.meas tran vdout1_97ck1660 FIND v(dout1_97) AT=835.025n

.meas tran vdout1_98ck1660 FIND v(dout1_98) AT=835.025n

.meas tran vdout1_99ck1660 FIND v(dout1_99) AT=835.025n

.meas tran vdout1_100ck1660 FIND v(dout1_100) AT=835.025n

.meas tran vdout1_101ck1660 FIND v(dout1_101) AT=835.025n

.meas tran vdout1_102ck1660 FIND v(dout1_102) AT=835.025n

.meas tran vdout1_103ck1660 FIND v(dout1_103) AT=835.025n

.meas tran vdout1_104ck1660 FIND v(dout1_104) AT=835.025n

.meas tran vdout1_105ck1660 FIND v(dout1_105) AT=835.025n

.meas tran vdout1_106ck1660 FIND v(dout1_106) AT=835.025n

.meas tran vdout1_107ck1660 FIND v(dout1_107) AT=835.025n

.meas tran vdout1_108ck1660 FIND v(dout1_108) AT=835.025n

.meas tran vdout1_109ck1660 FIND v(dout1_109) AT=835.025n

.meas tran vdout1_110ck1660 FIND v(dout1_110) AT=835.025n

.meas tran vdout1_111ck1660 FIND v(dout1_111) AT=835.025n

.meas tran vdout1_112ck1660 FIND v(dout1_112) AT=835.025n

.meas tran vdout1_113ck1660 FIND v(dout1_113) AT=835.025n

.meas tran vdout1_114ck1660 FIND v(dout1_114) AT=835.025n

.meas tran vdout1_115ck1660 FIND v(dout1_115) AT=835.025n

.meas tran vdout1_116ck1660 FIND v(dout1_116) AT=835.025n

.meas tran vdout1_117ck1660 FIND v(dout1_117) AT=835.025n

.meas tran vdout1_118ck1660 FIND v(dout1_118) AT=835.025n

.meas tran vdout1_119ck1660 FIND v(dout1_119) AT=835.025n

.meas tran vdout1_120ck1660 FIND v(dout1_120) AT=835.025n

.meas tran vdout1_121ck1660 FIND v(dout1_121) AT=835.025n

.meas tran vdout1_122ck1660 FIND v(dout1_122) AT=835.025n

.meas tran vdout1_123ck1660 FIND v(dout1_123) AT=835.025n

.meas tran vdout1_124ck1660 FIND v(dout1_124) AT=835.025n

.meas tran vdout1_125ck1660 FIND v(dout1_125) AT=835.025n

.meas tran vdout1_126ck1660 FIND v(dout1_126) AT=835.025n

.meas tran vdout1_127ck1660 FIND v(dout1_127) AT=835.025n

.meas tran vdout1_0ck1680 FIND v(dout1_0) AT=845.025n

.meas tran vdout1_1ck1680 FIND v(dout1_1) AT=845.025n

.meas tran vdout1_2ck1680 FIND v(dout1_2) AT=845.025n

.meas tran vdout1_3ck1680 FIND v(dout1_3) AT=845.025n

.meas tran vdout1_4ck1680 FIND v(dout1_4) AT=845.025n

.meas tran vdout1_5ck1680 FIND v(dout1_5) AT=845.025n

.meas tran vdout1_6ck1680 FIND v(dout1_6) AT=845.025n

.meas tran vdout1_7ck1680 FIND v(dout1_7) AT=845.025n

.meas tran vdout1_8ck1680 FIND v(dout1_8) AT=845.025n

.meas tran vdout1_9ck1680 FIND v(dout1_9) AT=845.025n

.meas tran vdout1_10ck1680 FIND v(dout1_10) AT=845.025n

.meas tran vdout1_11ck1680 FIND v(dout1_11) AT=845.025n

.meas tran vdout1_12ck1680 FIND v(dout1_12) AT=845.025n

.meas tran vdout1_13ck1680 FIND v(dout1_13) AT=845.025n

.meas tran vdout1_14ck1680 FIND v(dout1_14) AT=845.025n

.meas tran vdout1_15ck1680 FIND v(dout1_15) AT=845.025n

.meas tran vdout1_16ck1680 FIND v(dout1_16) AT=845.025n

.meas tran vdout1_17ck1680 FIND v(dout1_17) AT=845.025n

.meas tran vdout1_18ck1680 FIND v(dout1_18) AT=845.025n

.meas tran vdout1_19ck1680 FIND v(dout1_19) AT=845.025n

.meas tran vdout1_20ck1680 FIND v(dout1_20) AT=845.025n

.meas tran vdout1_21ck1680 FIND v(dout1_21) AT=845.025n

.meas tran vdout1_22ck1680 FIND v(dout1_22) AT=845.025n

.meas tran vdout1_23ck1680 FIND v(dout1_23) AT=845.025n

.meas tran vdout1_24ck1680 FIND v(dout1_24) AT=845.025n

.meas tran vdout1_25ck1680 FIND v(dout1_25) AT=845.025n

.meas tran vdout1_26ck1680 FIND v(dout1_26) AT=845.025n

.meas tran vdout1_27ck1680 FIND v(dout1_27) AT=845.025n

.meas tran vdout1_28ck1680 FIND v(dout1_28) AT=845.025n

.meas tran vdout1_29ck1680 FIND v(dout1_29) AT=845.025n

.meas tran vdout1_30ck1680 FIND v(dout1_30) AT=845.025n

.meas tran vdout1_31ck1680 FIND v(dout1_31) AT=845.025n

.meas tran vdout1_32ck1680 FIND v(dout1_32) AT=845.025n

.meas tran vdout1_33ck1680 FIND v(dout1_33) AT=845.025n

.meas tran vdout1_34ck1680 FIND v(dout1_34) AT=845.025n

.meas tran vdout1_35ck1680 FIND v(dout1_35) AT=845.025n

.meas tran vdout1_36ck1680 FIND v(dout1_36) AT=845.025n

.meas tran vdout1_37ck1680 FIND v(dout1_37) AT=845.025n

.meas tran vdout1_38ck1680 FIND v(dout1_38) AT=845.025n

.meas tran vdout1_39ck1680 FIND v(dout1_39) AT=845.025n

.meas tran vdout1_40ck1680 FIND v(dout1_40) AT=845.025n

.meas tran vdout1_41ck1680 FIND v(dout1_41) AT=845.025n

.meas tran vdout1_42ck1680 FIND v(dout1_42) AT=845.025n

.meas tran vdout1_43ck1680 FIND v(dout1_43) AT=845.025n

.meas tran vdout1_44ck1680 FIND v(dout1_44) AT=845.025n

.meas tran vdout1_45ck1680 FIND v(dout1_45) AT=845.025n

.meas tran vdout1_46ck1680 FIND v(dout1_46) AT=845.025n

.meas tran vdout1_47ck1680 FIND v(dout1_47) AT=845.025n

.meas tran vdout1_48ck1680 FIND v(dout1_48) AT=845.025n

.meas tran vdout1_49ck1680 FIND v(dout1_49) AT=845.025n

.meas tran vdout1_50ck1680 FIND v(dout1_50) AT=845.025n

.meas tran vdout1_51ck1680 FIND v(dout1_51) AT=845.025n

.meas tran vdout1_52ck1680 FIND v(dout1_52) AT=845.025n

.meas tran vdout1_53ck1680 FIND v(dout1_53) AT=845.025n

.meas tran vdout1_54ck1680 FIND v(dout1_54) AT=845.025n

.meas tran vdout1_55ck1680 FIND v(dout1_55) AT=845.025n

.meas tran vdout1_56ck1680 FIND v(dout1_56) AT=845.025n

.meas tran vdout1_57ck1680 FIND v(dout1_57) AT=845.025n

.meas tran vdout1_58ck1680 FIND v(dout1_58) AT=845.025n

.meas tran vdout1_59ck1680 FIND v(dout1_59) AT=845.025n

.meas tran vdout1_60ck1680 FIND v(dout1_60) AT=845.025n

.meas tran vdout1_61ck1680 FIND v(dout1_61) AT=845.025n

.meas tran vdout1_62ck1680 FIND v(dout1_62) AT=845.025n

.meas tran vdout1_63ck1680 FIND v(dout1_63) AT=845.025n

.meas tran vdout1_64ck1680 FIND v(dout1_64) AT=845.025n

.meas tran vdout1_65ck1680 FIND v(dout1_65) AT=845.025n

.meas tran vdout1_66ck1680 FIND v(dout1_66) AT=845.025n

.meas tran vdout1_67ck1680 FIND v(dout1_67) AT=845.025n

.meas tran vdout1_68ck1680 FIND v(dout1_68) AT=845.025n

.meas tran vdout1_69ck1680 FIND v(dout1_69) AT=845.025n

.meas tran vdout1_70ck1680 FIND v(dout1_70) AT=845.025n

.meas tran vdout1_71ck1680 FIND v(dout1_71) AT=845.025n

.meas tran vdout1_72ck1680 FIND v(dout1_72) AT=845.025n

.meas tran vdout1_73ck1680 FIND v(dout1_73) AT=845.025n

.meas tran vdout1_74ck1680 FIND v(dout1_74) AT=845.025n

.meas tran vdout1_75ck1680 FIND v(dout1_75) AT=845.025n

.meas tran vdout1_76ck1680 FIND v(dout1_76) AT=845.025n

.meas tran vdout1_77ck1680 FIND v(dout1_77) AT=845.025n

.meas tran vdout1_78ck1680 FIND v(dout1_78) AT=845.025n

.meas tran vdout1_79ck1680 FIND v(dout1_79) AT=845.025n

.meas tran vdout1_80ck1680 FIND v(dout1_80) AT=845.025n

.meas tran vdout1_81ck1680 FIND v(dout1_81) AT=845.025n

.meas tran vdout1_82ck1680 FIND v(dout1_82) AT=845.025n

.meas tran vdout1_83ck1680 FIND v(dout1_83) AT=845.025n

.meas tran vdout1_84ck1680 FIND v(dout1_84) AT=845.025n

.meas tran vdout1_85ck1680 FIND v(dout1_85) AT=845.025n

.meas tran vdout1_86ck1680 FIND v(dout1_86) AT=845.025n

.meas tran vdout1_87ck1680 FIND v(dout1_87) AT=845.025n

.meas tran vdout1_88ck1680 FIND v(dout1_88) AT=845.025n

.meas tran vdout1_89ck1680 FIND v(dout1_89) AT=845.025n

.meas tran vdout1_90ck1680 FIND v(dout1_90) AT=845.025n

.meas tran vdout1_91ck1680 FIND v(dout1_91) AT=845.025n

.meas tran vdout1_92ck1680 FIND v(dout1_92) AT=845.025n

.meas tran vdout1_93ck1680 FIND v(dout1_93) AT=845.025n

.meas tran vdout1_94ck1680 FIND v(dout1_94) AT=845.025n

.meas tran vdout1_95ck1680 FIND v(dout1_95) AT=845.025n

.meas tran vdout1_96ck1680 FIND v(dout1_96) AT=845.025n

.meas tran vdout1_97ck1680 FIND v(dout1_97) AT=845.025n

.meas tran vdout1_98ck1680 FIND v(dout1_98) AT=845.025n

.meas tran vdout1_99ck1680 FIND v(dout1_99) AT=845.025n

.meas tran vdout1_100ck1680 FIND v(dout1_100) AT=845.025n

.meas tran vdout1_101ck1680 FIND v(dout1_101) AT=845.025n

.meas tran vdout1_102ck1680 FIND v(dout1_102) AT=845.025n

.meas tran vdout1_103ck1680 FIND v(dout1_103) AT=845.025n

.meas tran vdout1_104ck1680 FIND v(dout1_104) AT=845.025n

.meas tran vdout1_105ck1680 FIND v(dout1_105) AT=845.025n

.meas tran vdout1_106ck1680 FIND v(dout1_106) AT=845.025n

.meas tran vdout1_107ck1680 FIND v(dout1_107) AT=845.025n

.meas tran vdout1_108ck1680 FIND v(dout1_108) AT=845.025n

.meas tran vdout1_109ck1680 FIND v(dout1_109) AT=845.025n

.meas tran vdout1_110ck1680 FIND v(dout1_110) AT=845.025n

.meas tran vdout1_111ck1680 FIND v(dout1_111) AT=845.025n

.meas tran vdout1_112ck1680 FIND v(dout1_112) AT=845.025n

.meas tran vdout1_113ck1680 FIND v(dout1_113) AT=845.025n

.meas tran vdout1_114ck1680 FIND v(dout1_114) AT=845.025n

.meas tran vdout1_115ck1680 FIND v(dout1_115) AT=845.025n

.meas tran vdout1_116ck1680 FIND v(dout1_116) AT=845.025n

.meas tran vdout1_117ck1680 FIND v(dout1_117) AT=845.025n

.meas tran vdout1_118ck1680 FIND v(dout1_118) AT=845.025n

.meas tran vdout1_119ck1680 FIND v(dout1_119) AT=845.025n

.meas tran vdout1_120ck1680 FIND v(dout1_120) AT=845.025n

.meas tran vdout1_121ck1680 FIND v(dout1_121) AT=845.025n

.meas tran vdout1_122ck1680 FIND v(dout1_122) AT=845.025n

.meas tran vdout1_123ck1680 FIND v(dout1_123) AT=845.025n

.meas tran vdout1_124ck1680 FIND v(dout1_124) AT=845.025n

.meas tran vdout1_125ck1680 FIND v(dout1_125) AT=845.025n

.meas tran vdout1_126ck1680 FIND v(dout1_126) AT=845.025n

.meas tran vdout1_127ck1680 FIND v(dout1_127) AT=845.025n

.meas tran vdout1_0ck1710 FIND v(dout1_0) AT=860.025n

.meas tran vdout1_1ck1710 FIND v(dout1_1) AT=860.025n

.meas tran vdout1_2ck1710 FIND v(dout1_2) AT=860.025n

.meas tran vdout1_3ck1710 FIND v(dout1_3) AT=860.025n

.meas tran vdout1_4ck1710 FIND v(dout1_4) AT=860.025n

.meas tran vdout1_5ck1710 FIND v(dout1_5) AT=860.025n

.meas tran vdout1_6ck1710 FIND v(dout1_6) AT=860.025n

.meas tran vdout1_7ck1710 FIND v(dout1_7) AT=860.025n

.meas tran vdout1_8ck1710 FIND v(dout1_8) AT=860.025n

.meas tran vdout1_9ck1710 FIND v(dout1_9) AT=860.025n

.meas tran vdout1_10ck1710 FIND v(dout1_10) AT=860.025n

.meas tran vdout1_11ck1710 FIND v(dout1_11) AT=860.025n

.meas tran vdout1_12ck1710 FIND v(dout1_12) AT=860.025n

.meas tran vdout1_13ck1710 FIND v(dout1_13) AT=860.025n

.meas tran vdout1_14ck1710 FIND v(dout1_14) AT=860.025n

.meas tran vdout1_15ck1710 FIND v(dout1_15) AT=860.025n

.meas tran vdout1_16ck1710 FIND v(dout1_16) AT=860.025n

.meas tran vdout1_17ck1710 FIND v(dout1_17) AT=860.025n

.meas tran vdout1_18ck1710 FIND v(dout1_18) AT=860.025n

.meas tran vdout1_19ck1710 FIND v(dout1_19) AT=860.025n

.meas tran vdout1_20ck1710 FIND v(dout1_20) AT=860.025n

.meas tran vdout1_21ck1710 FIND v(dout1_21) AT=860.025n

.meas tran vdout1_22ck1710 FIND v(dout1_22) AT=860.025n

.meas tran vdout1_23ck1710 FIND v(dout1_23) AT=860.025n

.meas tran vdout1_24ck1710 FIND v(dout1_24) AT=860.025n

.meas tran vdout1_25ck1710 FIND v(dout1_25) AT=860.025n

.meas tran vdout1_26ck1710 FIND v(dout1_26) AT=860.025n

.meas tran vdout1_27ck1710 FIND v(dout1_27) AT=860.025n

.meas tran vdout1_28ck1710 FIND v(dout1_28) AT=860.025n

.meas tran vdout1_29ck1710 FIND v(dout1_29) AT=860.025n

.meas tran vdout1_30ck1710 FIND v(dout1_30) AT=860.025n

.meas tran vdout1_31ck1710 FIND v(dout1_31) AT=860.025n

.meas tran vdout1_32ck1710 FIND v(dout1_32) AT=860.025n

.meas tran vdout1_33ck1710 FIND v(dout1_33) AT=860.025n

.meas tran vdout1_34ck1710 FIND v(dout1_34) AT=860.025n

.meas tran vdout1_35ck1710 FIND v(dout1_35) AT=860.025n

.meas tran vdout1_36ck1710 FIND v(dout1_36) AT=860.025n

.meas tran vdout1_37ck1710 FIND v(dout1_37) AT=860.025n

.meas tran vdout1_38ck1710 FIND v(dout1_38) AT=860.025n

.meas tran vdout1_39ck1710 FIND v(dout1_39) AT=860.025n

.meas tran vdout1_40ck1710 FIND v(dout1_40) AT=860.025n

.meas tran vdout1_41ck1710 FIND v(dout1_41) AT=860.025n

.meas tran vdout1_42ck1710 FIND v(dout1_42) AT=860.025n

.meas tran vdout1_43ck1710 FIND v(dout1_43) AT=860.025n

.meas tran vdout1_44ck1710 FIND v(dout1_44) AT=860.025n

.meas tran vdout1_45ck1710 FIND v(dout1_45) AT=860.025n

.meas tran vdout1_46ck1710 FIND v(dout1_46) AT=860.025n

.meas tran vdout1_47ck1710 FIND v(dout1_47) AT=860.025n

.meas tran vdout1_48ck1710 FIND v(dout1_48) AT=860.025n

.meas tran vdout1_49ck1710 FIND v(dout1_49) AT=860.025n

.meas tran vdout1_50ck1710 FIND v(dout1_50) AT=860.025n

.meas tran vdout1_51ck1710 FIND v(dout1_51) AT=860.025n

.meas tran vdout1_52ck1710 FIND v(dout1_52) AT=860.025n

.meas tran vdout1_53ck1710 FIND v(dout1_53) AT=860.025n

.meas tran vdout1_54ck1710 FIND v(dout1_54) AT=860.025n

.meas tran vdout1_55ck1710 FIND v(dout1_55) AT=860.025n

.meas tran vdout1_56ck1710 FIND v(dout1_56) AT=860.025n

.meas tran vdout1_57ck1710 FIND v(dout1_57) AT=860.025n

.meas tran vdout1_58ck1710 FIND v(dout1_58) AT=860.025n

.meas tran vdout1_59ck1710 FIND v(dout1_59) AT=860.025n

.meas tran vdout1_60ck1710 FIND v(dout1_60) AT=860.025n

.meas tran vdout1_61ck1710 FIND v(dout1_61) AT=860.025n

.meas tran vdout1_62ck1710 FIND v(dout1_62) AT=860.025n

.meas tran vdout1_63ck1710 FIND v(dout1_63) AT=860.025n

.meas tran vdout1_64ck1710 FIND v(dout1_64) AT=860.025n

.meas tran vdout1_65ck1710 FIND v(dout1_65) AT=860.025n

.meas tran vdout1_66ck1710 FIND v(dout1_66) AT=860.025n

.meas tran vdout1_67ck1710 FIND v(dout1_67) AT=860.025n

.meas tran vdout1_68ck1710 FIND v(dout1_68) AT=860.025n

.meas tran vdout1_69ck1710 FIND v(dout1_69) AT=860.025n

.meas tran vdout1_70ck1710 FIND v(dout1_70) AT=860.025n

.meas tran vdout1_71ck1710 FIND v(dout1_71) AT=860.025n

.meas tran vdout1_72ck1710 FIND v(dout1_72) AT=860.025n

.meas tran vdout1_73ck1710 FIND v(dout1_73) AT=860.025n

.meas tran vdout1_74ck1710 FIND v(dout1_74) AT=860.025n

.meas tran vdout1_75ck1710 FIND v(dout1_75) AT=860.025n

.meas tran vdout1_76ck1710 FIND v(dout1_76) AT=860.025n

.meas tran vdout1_77ck1710 FIND v(dout1_77) AT=860.025n

.meas tran vdout1_78ck1710 FIND v(dout1_78) AT=860.025n

.meas tran vdout1_79ck1710 FIND v(dout1_79) AT=860.025n

.meas tran vdout1_80ck1710 FIND v(dout1_80) AT=860.025n

.meas tran vdout1_81ck1710 FIND v(dout1_81) AT=860.025n

.meas tran vdout1_82ck1710 FIND v(dout1_82) AT=860.025n

.meas tran vdout1_83ck1710 FIND v(dout1_83) AT=860.025n

.meas tran vdout1_84ck1710 FIND v(dout1_84) AT=860.025n

.meas tran vdout1_85ck1710 FIND v(dout1_85) AT=860.025n

.meas tran vdout1_86ck1710 FIND v(dout1_86) AT=860.025n

.meas tran vdout1_87ck1710 FIND v(dout1_87) AT=860.025n

.meas tran vdout1_88ck1710 FIND v(dout1_88) AT=860.025n

.meas tran vdout1_89ck1710 FIND v(dout1_89) AT=860.025n

.meas tran vdout1_90ck1710 FIND v(dout1_90) AT=860.025n

.meas tran vdout1_91ck1710 FIND v(dout1_91) AT=860.025n

.meas tran vdout1_92ck1710 FIND v(dout1_92) AT=860.025n

.meas tran vdout1_93ck1710 FIND v(dout1_93) AT=860.025n

.meas tran vdout1_94ck1710 FIND v(dout1_94) AT=860.025n

.meas tran vdout1_95ck1710 FIND v(dout1_95) AT=860.025n

.meas tran vdout1_96ck1710 FIND v(dout1_96) AT=860.025n

.meas tran vdout1_97ck1710 FIND v(dout1_97) AT=860.025n

.meas tran vdout1_98ck1710 FIND v(dout1_98) AT=860.025n

.meas tran vdout1_99ck1710 FIND v(dout1_99) AT=860.025n

.meas tran vdout1_100ck1710 FIND v(dout1_100) AT=860.025n

.meas tran vdout1_101ck1710 FIND v(dout1_101) AT=860.025n

.meas tran vdout1_102ck1710 FIND v(dout1_102) AT=860.025n

.meas tran vdout1_103ck1710 FIND v(dout1_103) AT=860.025n

.meas tran vdout1_104ck1710 FIND v(dout1_104) AT=860.025n

.meas tran vdout1_105ck1710 FIND v(dout1_105) AT=860.025n

.meas tran vdout1_106ck1710 FIND v(dout1_106) AT=860.025n

.meas tran vdout1_107ck1710 FIND v(dout1_107) AT=860.025n

.meas tran vdout1_108ck1710 FIND v(dout1_108) AT=860.025n

.meas tran vdout1_109ck1710 FIND v(dout1_109) AT=860.025n

.meas tran vdout1_110ck1710 FIND v(dout1_110) AT=860.025n

.meas tran vdout1_111ck1710 FIND v(dout1_111) AT=860.025n

.meas tran vdout1_112ck1710 FIND v(dout1_112) AT=860.025n

.meas tran vdout1_113ck1710 FIND v(dout1_113) AT=860.025n

.meas tran vdout1_114ck1710 FIND v(dout1_114) AT=860.025n

.meas tran vdout1_115ck1710 FIND v(dout1_115) AT=860.025n

.meas tran vdout1_116ck1710 FIND v(dout1_116) AT=860.025n

.meas tran vdout1_117ck1710 FIND v(dout1_117) AT=860.025n

.meas tran vdout1_118ck1710 FIND v(dout1_118) AT=860.025n

.meas tran vdout1_119ck1710 FIND v(dout1_119) AT=860.025n

.meas tran vdout1_120ck1710 FIND v(dout1_120) AT=860.025n

.meas tran vdout1_121ck1710 FIND v(dout1_121) AT=860.025n

.meas tran vdout1_122ck1710 FIND v(dout1_122) AT=860.025n

.meas tran vdout1_123ck1710 FIND v(dout1_123) AT=860.025n

.meas tran vdout1_124ck1710 FIND v(dout1_124) AT=860.025n

.meas tran vdout1_125ck1710 FIND v(dout1_125) AT=860.025n

.meas tran vdout1_126ck1710 FIND v(dout1_126) AT=860.025n

.meas tran vdout1_127ck1710 FIND v(dout1_127) AT=860.025n

.meas tran vdout1_0ck1730 FIND v(dout1_0) AT=870.025n

.meas tran vdout1_1ck1730 FIND v(dout1_1) AT=870.025n

.meas tran vdout1_2ck1730 FIND v(dout1_2) AT=870.025n

.meas tran vdout1_3ck1730 FIND v(dout1_3) AT=870.025n

.meas tran vdout1_4ck1730 FIND v(dout1_4) AT=870.025n

.meas tran vdout1_5ck1730 FIND v(dout1_5) AT=870.025n

.meas tran vdout1_6ck1730 FIND v(dout1_6) AT=870.025n

.meas tran vdout1_7ck1730 FIND v(dout1_7) AT=870.025n

.meas tran vdout1_8ck1730 FIND v(dout1_8) AT=870.025n

.meas tran vdout1_9ck1730 FIND v(dout1_9) AT=870.025n

.meas tran vdout1_10ck1730 FIND v(dout1_10) AT=870.025n

.meas tran vdout1_11ck1730 FIND v(dout1_11) AT=870.025n

.meas tran vdout1_12ck1730 FIND v(dout1_12) AT=870.025n

.meas tran vdout1_13ck1730 FIND v(dout1_13) AT=870.025n

.meas tran vdout1_14ck1730 FIND v(dout1_14) AT=870.025n

.meas tran vdout1_15ck1730 FIND v(dout1_15) AT=870.025n

.meas tran vdout1_16ck1730 FIND v(dout1_16) AT=870.025n

.meas tran vdout1_17ck1730 FIND v(dout1_17) AT=870.025n

.meas tran vdout1_18ck1730 FIND v(dout1_18) AT=870.025n

.meas tran vdout1_19ck1730 FIND v(dout1_19) AT=870.025n

.meas tran vdout1_20ck1730 FIND v(dout1_20) AT=870.025n

.meas tran vdout1_21ck1730 FIND v(dout1_21) AT=870.025n

.meas tran vdout1_22ck1730 FIND v(dout1_22) AT=870.025n

.meas tran vdout1_23ck1730 FIND v(dout1_23) AT=870.025n

.meas tran vdout1_24ck1730 FIND v(dout1_24) AT=870.025n

.meas tran vdout1_25ck1730 FIND v(dout1_25) AT=870.025n

.meas tran vdout1_26ck1730 FIND v(dout1_26) AT=870.025n

.meas tran vdout1_27ck1730 FIND v(dout1_27) AT=870.025n

.meas tran vdout1_28ck1730 FIND v(dout1_28) AT=870.025n

.meas tran vdout1_29ck1730 FIND v(dout1_29) AT=870.025n

.meas tran vdout1_30ck1730 FIND v(dout1_30) AT=870.025n

.meas tran vdout1_31ck1730 FIND v(dout1_31) AT=870.025n

.meas tran vdout1_32ck1730 FIND v(dout1_32) AT=870.025n

.meas tran vdout1_33ck1730 FIND v(dout1_33) AT=870.025n

.meas tran vdout1_34ck1730 FIND v(dout1_34) AT=870.025n

.meas tran vdout1_35ck1730 FIND v(dout1_35) AT=870.025n

.meas tran vdout1_36ck1730 FIND v(dout1_36) AT=870.025n

.meas tran vdout1_37ck1730 FIND v(dout1_37) AT=870.025n

.meas tran vdout1_38ck1730 FIND v(dout1_38) AT=870.025n

.meas tran vdout1_39ck1730 FIND v(dout1_39) AT=870.025n

.meas tran vdout1_40ck1730 FIND v(dout1_40) AT=870.025n

.meas tran vdout1_41ck1730 FIND v(dout1_41) AT=870.025n

.meas tran vdout1_42ck1730 FIND v(dout1_42) AT=870.025n

.meas tran vdout1_43ck1730 FIND v(dout1_43) AT=870.025n

.meas tran vdout1_44ck1730 FIND v(dout1_44) AT=870.025n

.meas tran vdout1_45ck1730 FIND v(dout1_45) AT=870.025n

.meas tran vdout1_46ck1730 FIND v(dout1_46) AT=870.025n

.meas tran vdout1_47ck1730 FIND v(dout1_47) AT=870.025n

.meas tran vdout1_48ck1730 FIND v(dout1_48) AT=870.025n

.meas tran vdout1_49ck1730 FIND v(dout1_49) AT=870.025n

.meas tran vdout1_50ck1730 FIND v(dout1_50) AT=870.025n

.meas tran vdout1_51ck1730 FIND v(dout1_51) AT=870.025n

.meas tran vdout1_52ck1730 FIND v(dout1_52) AT=870.025n

.meas tran vdout1_53ck1730 FIND v(dout1_53) AT=870.025n

.meas tran vdout1_54ck1730 FIND v(dout1_54) AT=870.025n

.meas tran vdout1_55ck1730 FIND v(dout1_55) AT=870.025n

.meas tran vdout1_56ck1730 FIND v(dout1_56) AT=870.025n

.meas tran vdout1_57ck1730 FIND v(dout1_57) AT=870.025n

.meas tran vdout1_58ck1730 FIND v(dout1_58) AT=870.025n

.meas tran vdout1_59ck1730 FIND v(dout1_59) AT=870.025n

.meas tran vdout1_60ck1730 FIND v(dout1_60) AT=870.025n

.meas tran vdout1_61ck1730 FIND v(dout1_61) AT=870.025n

.meas tran vdout1_62ck1730 FIND v(dout1_62) AT=870.025n

.meas tran vdout1_63ck1730 FIND v(dout1_63) AT=870.025n

.meas tran vdout1_64ck1730 FIND v(dout1_64) AT=870.025n

.meas tran vdout1_65ck1730 FIND v(dout1_65) AT=870.025n

.meas tran vdout1_66ck1730 FIND v(dout1_66) AT=870.025n

.meas tran vdout1_67ck1730 FIND v(dout1_67) AT=870.025n

.meas tran vdout1_68ck1730 FIND v(dout1_68) AT=870.025n

.meas tran vdout1_69ck1730 FIND v(dout1_69) AT=870.025n

.meas tran vdout1_70ck1730 FIND v(dout1_70) AT=870.025n

.meas tran vdout1_71ck1730 FIND v(dout1_71) AT=870.025n

.meas tran vdout1_72ck1730 FIND v(dout1_72) AT=870.025n

.meas tran vdout1_73ck1730 FIND v(dout1_73) AT=870.025n

.meas tran vdout1_74ck1730 FIND v(dout1_74) AT=870.025n

.meas tran vdout1_75ck1730 FIND v(dout1_75) AT=870.025n

.meas tran vdout1_76ck1730 FIND v(dout1_76) AT=870.025n

.meas tran vdout1_77ck1730 FIND v(dout1_77) AT=870.025n

.meas tran vdout1_78ck1730 FIND v(dout1_78) AT=870.025n

.meas tran vdout1_79ck1730 FIND v(dout1_79) AT=870.025n

.meas tran vdout1_80ck1730 FIND v(dout1_80) AT=870.025n

.meas tran vdout1_81ck1730 FIND v(dout1_81) AT=870.025n

.meas tran vdout1_82ck1730 FIND v(dout1_82) AT=870.025n

.meas tran vdout1_83ck1730 FIND v(dout1_83) AT=870.025n

.meas tran vdout1_84ck1730 FIND v(dout1_84) AT=870.025n

.meas tran vdout1_85ck1730 FIND v(dout1_85) AT=870.025n

.meas tran vdout1_86ck1730 FIND v(dout1_86) AT=870.025n

.meas tran vdout1_87ck1730 FIND v(dout1_87) AT=870.025n

.meas tran vdout1_88ck1730 FIND v(dout1_88) AT=870.025n

.meas tran vdout1_89ck1730 FIND v(dout1_89) AT=870.025n

.meas tran vdout1_90ck1730 FIND v(dout1_90) AT=870.025n

.meas tran vdout1_91ck1730 FIND v(dout1_91) AT=870.025n

.meas tran vdout1_92ck1730 FIND v(dout1_92) AT=870.025n

.meas tran vdout1_93ck1730 FIND v(dout1_93) AT=870.025n

.meas tran vdout1_94ck1730 FIND v(dout1_94) AT=870.025n

.meas tran vdout1_95ck1730 FIND v(dout1_95) AT=870.025n

.meas tran vdout1_96ck1730 FIND v(dout1_96) AT=870.025n

.meas tran vdout1_97ck1730 FIND v(dout1_97) AT=870.025n

.meas tran vdout1_98ck1730 FIND v(dout1_98) AT=870.025n

.meas tran vdout1_99ck1730 FIND v(dout1_99) AT=870.025n

.meas tran vdout1_100ck1730 FIND v(dout1_100) AT=870.025n

.meas tran vdout1_101ck1730 FIND v(dout1_101) AT=870.025n

.meas tran vdout1_102ck1730 FIND v(dout1_102) AT=870.025n

.meas tran vdout1_103ck1730 FIND v(dout1_103) AT=870.025n

.meas tran vdout1_104ck1730 FIND v(dout1_104) AT=870.025n

.meas tran vdout1_105ck1730 FIND v(dout1_105) AT=870.025n

.meas tran vdout1_106ck1730 FIND v(dout1_106) AT=870.025n

.meas tran vdout1_107ck1730 FIND v(dout1_107) AT=870.025n

.meas tran vdout1_108ck1730 FIND v(dout1_108) AT=870.025n

.meas tran vdout1_109ck1730 FIND v(dout1_109) AT=870.025n

.meas tran vdout1_110ck1730 FIND v(dout1_110) AT=870.025n

.meas tran vdout1_111ck1730 FIND v(dout1_111) AT=870.025n

.meas tran vdout1_112ck1730 FIND v(dout1_112) AT=870.025n

.meas tran vdout1_113ck1730 FIND v(dout1_113) AT=870.025n

.meas tran vdout1_114ck1730 FIND v(dout1_114) AT=870.025n

.meas tran vdout1_115ck1730 FIND v(dout1_115) AT=870.025n

.meas tran vdout1_116ck1730 FIND v(dout1_116) AT=870.025n

.meas tran vdout1_117ck1730 FIND v(dout1_117) AT=870.025n

.meas tran vdout1_118ck1730 FIND v(dout1_118) AT=870.025n

.meas tran vdout1_119ck1730 FIND v(dout1_119) AT=870.025n

.meas tran vdout1_120ck1730 FIND v(dout1_120) AT=870.025n

.meas tran vdout1_121ck1730 FIND v(dout1_121) AT=870.025n

.meas tran vdout1_122ck1730 FIND v(dout1_122) AT=870.025n

.meas tran vdout1_123ck1730 FIND v(dout1_123) AT=870.025n

.meas tran vdout1_124ck1730 FIND v(dout1_124) AT=870.025n

.meas tran vdout1_125ck1730 FIND v(dout1_125) AT=870.025n

.meas tran vdout1_126ck1730 FIND v(dout1_126) AT=870.025n

.meas tran vdout1_127ck1730 FIND v(dout1_127) AT=870.025n

.meas tran vdout1_0ck1740 FIND v(dout1_0) AT=875.025n

.meas tran vdout1_1ck1740 FIND v(dout1_1) AT=875.025n

.meas tran vdout1_2ck1740 FIND v(dout1_2) AT=875.025n

.meas tran vdout1_3ck1740 FIND v(dout1_3) AT=875.025n

.meas tran vdout1_4ck1740 FIND v(dout1_4) AT=875.025n

.meas tran vdout1_5ck1740 FIND v(dout1_5) AT=875.025n

.meas tran vdout1_6ck1740 FIND v(dout1_6) AT=875.025n

.meas tran vdout1_7ck1740 FIND v(dout1_7) AT=875.025n

.meas tran vdout1_8ck1740 FIND v(dout1_8) AT=875.025n

.meas tran vdout1_9ck1740 FIND v(dout1_9) AT=875.025n

.meas tran vdout1_10ck1740 FIND v(dout1_10) AT=875.025n

.meas tran vdout1_11ck1740 FIND v(dout1_11) AT=875.025n

.meas tran vdout1_12ck1740 FIND v(dout1_12) AT=875.025n

.meas tran vdout1_13ck1740 FIND v(dout1_13) AT=875.025n

.meas tran vdout1_14ck1740 FIND v(dout1_14) AT=875.025n

.meas tran vdout1_15ck1740 FIND v(dout1_15) AT=875.025n

.meas tran vdout1_16ck1740 FIND v(dout1_16) AT=875.025n

.meas tran vdout1_17ck1740 FIND v(dout1_17) AT=875.025n

.meas tran vdout1_18ck1740 FIND v(dout1_18) AT=875.025n

.meas tran vdout1_19ck1740 FIND v(dout1_19) AT=875.025n

.meas tran vdout1_20ck1740 FIND v(dout1_20) AT=875.025n

.meas tran vdout1_21ck1740 FIND v(dout1_21) AT=875.025n

.meas tran vdout1_22ck1740 FIND v(dout1_22) AT=875.025n

.meas tran vdout1_23ck1740 FIND v(dout1_23) AT=875.025n

.meas tran vdout1_24ck1740 FIND v(dout1_24) AT=875.025n

.meas tran vdout1_25ck1740 FIND v(dout1_25) AT=875.025n

.meas tran vdout1_26ck1740 FIND v(dout1_26) AT=875.025n

.meas tran vdout1_27ck1740 FIND v(dout1_27) AT=875.025n

.meas tran vdout1_28ck1740 FIND v(dout1_28) AT=875.025n

.meas tran vdout1_29ck1740 FIND v(dout1_29) AT=875.025n

.meas tran vdout1_30ck1740 FIND v(dout1_30) AT=875.025n

.meas tran vdout1_31ck1740 FIND v(dout1_31) AT=875.025n

.meas tran vdout1_32ck1740 FIND v(dout1_32) AT=875.025n

.meas tran vdout1_33ck1740 FIND v(dout1_33) AT=875.025n

.meas tran vdout1_34ck1740 FIND v(dout1_34) AT=875.025n

.meas tran vdout1_35ck1740 FIND v(dout1_35) AT=875.025n

.meas tran vdout1_36ck1740 FIND v(dout1_36) AT=875.025n

.meas tran vdout1_37ck1740 FIND v(dout1_37) AT=875.025n

.meas tran vdout1_38ck1740 FIND v(dout1_38) AT=875.025n

.meas tran vdout1_39ck1740 FIND v(dout1_39) AT=875.025n

.meas tran vdout1_40ck1740 FIND v(dout1_40) AT=875.025n

.meas tran vdout1_41ck1740 FIND v(dout1_41) AT=875.025n

.meas tran vdout1_42ck1740 FIND v(dout1_42) AT=875.025n

.meas tran vdout1_43ck1740 FIND v(dout1_43) AT=875.025n

.meas tran vdout1_44ck1740 FIND v(dout1_44) AT=875.025n

.meas tran vdout1_45ck1740 FIND v(dout1_45) AT=875.025n

.meas tran vdout1_46ck1740 FIND v(dout1_46) AT=875.025n

.meas tran vdout1_47ck1740 FIND v(dout1_47) AT=875.025n

.meas tran vdout1_48ck1740 FIND v(dout1_48) AT=875.025n

.meas tran vdout1_49ck1740 FIND v(dout1_49) AT=875.025n

.meas tran vdout1_50ck1740 FIND v(dout1_50) AT=875.025n

.meas tran vdout1_51ck1740 FIND v(dout1_51) AT=875.025n

.meas tran vdout1_52ck1740 FIND v(dout1_52) AT=875.025n

.meas tran vdout1_53ck1740 FIND v(dout1_53) AT=875.025n

.meas tran vdout1_54ck1740 FIND v(dout1_54) AT=875.025n

.meas tran vdout1_55ck1740 FIND v(dout1_55) AT=875.025n

.meas tran vdout1_56ck1740 FIND v(dout1_56) AT=875.025n

.meas tran vdout1_57ck1740 FIND v(dout1_57) AT=875.025n

.meas tran vdout1_58ck1740 FIND v(dout1_58) AT=875.025n

.meas tran vdout1_59ck1740 FIND v(dout1_59) AT=875.025n

.meas tran vdout1_60ck1740 FIND v(dout1_60) AT=875.025n

.meas tran vdout1_61ck1740 FIND v(dout1_61) AT=875.025n

.meas tran vdout1_62ck1740 FIND v(dout1_62) AT=875.025n

.meas tran vdout1_63ck1740 FIND v(dout1_63) AT=875.025n

.meas tran vdout1_64ck1740 FIND v(dout1_64) AT=875.025n

.meas tran vdout1_65ck1740 FIND v(dout1_65) AT=875.025n

.meas tran vdout1_66ck1740 FIND v(dout1_66) AT=875.025n

.meas tran vdout1_67ck1740 FIND v(dout1_67) AT=875.025n

.meas tran vdout1_68ck1740 FIND v(dout1_68) AT=875.025n

.meas tran vdout1_69ck1740 FIND v(dout1_69) AT=875.025n

.meas tran vdout1_70ck1740 FIND v(dout1_70) AT=875.025n

.meas tran vdout1_71ck1740 FIND v(dout1_71) AT=875.025n

.meas tran vdout1_72ck1740 FIND v(dout1_72) AT=875.025n

.meas tran vdout1_73ck1740 FIND v(dout1_73) AT=875.025n

.meas tran vdout1_74ck1740 FIND v(dout1_74) AT=875.025n

.meas tran vdout1_75ck1740 FIND v(dout1_75) AT=875.025n

.meas tran vdout1_76ck1740 FIND v(dout1_76) AT=875.025n

.meas tran vdout1_77ck1740 FIND v(dout1_77) AT=875.025n

.meas tran vdout1_78ck1740 FIND v(dout1_78) AT=875.025n

.meas tran vdout1_79ck1740 FIND v(dout1_79) AT=875.025n

.meas tran vdout1_80ck1740 FIND v(dout1_80) AT=875.025n

.meas tran vdout1_81ck1740 FIND v(dout1_81) AT=875.025n

.meas tran vdout1_82ck1740 FIND v(dout1_82) AT=875.025n

.meas tran vdout1_83ck1740 FIND v(dout1_83) AT=875.025n

.meas tran vdout1_84ck1740 FIND v(dout1_84) AT=875.025n

.meas tran vdout1_85ck1740 FIND v(dout1_85) AT=875.025n

.meas tran vdout1_86ck1740 FIND v(dout1_86) AT=875.025n

.meas tran vdout1_87ck1740 FIND v(dout1_87) AT=875.025n

.meas tran vdout1_88ck1740 FIND v(dout1_88) AT=875.025n

.meas tran vdout1_89ck1740 FIND v(dout1_89) AT=875.025n

.meas tran vdout1_90ck1740 FIND v(dout1_90) AT=875.025n

.meas tran vdout1_91ck1740 FIND v(dout1_91) AT=875.025n

.meas tran vdout1_92ck1740 FIND v(dout1_92) AT=875.025n

.meas tran vdout1_93ck1740 FIND v(dout1_93) AT=875.025n

.meas tran vdout1_94ck1740 FIND v(dout1_94) AT=875.025n

.meas tran vdout1_95ck1740 FIND v(dout1_95) AT=875.025n

.meas tran vdout1_96ck1740 FIND v(dout1_96) AT=875.025n

.meas tran vdout1_97ck1740 FIND v(dout1_97) AT=875.025n

.meas tran vdout1_98ck1740 FIND v(dout1_98) AT=875.025n

.meas tran vdout1_99ck1740 FIND v(dout1_99) AT=875.025n

.meas tran vdout1_100ck1740 FIND v(dout1_100) AT=875.025n

.meas tran vdout1_101ck1740 FIND v(dout1_101) AT=875.025n

.meas tran vdout1_102ck1740 FIND v(dout1_102) AT=875.025n

.meas tran vdout1_103ck1740 FIND v(dout1_103) AT=875.025n

.meas tran vdout1_104ck1740 FIND v(dout1_104) AT=875.025n

.meas tran vdout1_105ck1740 FIND v(dout1_105) AT=875.025n

.meas tran vdout1_106ck1740 FIND v(dout1_106) AT=875.025n

.meas tran vdout1_107ck1740 FIND v(dout1_107) AT=875.025n

.meas tran vdout1_108ck1740 FIND v(dout1_108) AT=875.025n

.meas tran vdout1_109ck1740 FIND v(dout1_109) AT=875.025n

.meas tran vdout1_110ck1740 FIND v(dout1_110) AT=875.025n

.meas tran vdout1_111ck1740 FIND v(dout1_111) AT=875.025n

.meas tran vdout1_112ck1740 FIND v(dout1_112) AT=875.025n

.meas tran vdout1_113ck1740 FIND v(dout1_113) AT=875.025n

.meas tran vdout1_114ck1740 FIND v(dout1_114) AT=875.025n

.meas tran vdout1_115ck1740 FIND v(dout1_115) AT=875.025n

.meas tran vdout1_116ck1740 FIND v(dout1_116) AT=875.025n

.meas tran vdout1_117ck1740 FIND v(dout1_117) AT=875.025n

.meas tran vdout1_118ck1740 FIND v(dout1_118) AT=875.025n

.meas tran vdout1_119ck1740 FIND v(dout1_119) AT=875.025n

.meas tran vdout1_120ck1740 FIND v(dout1_120) AT=875.025n

.meas tran vdout1_121ck1740 FIND v(dout1_121) AT=875.025n

.meas tran vdout1_122ck1740 FIND v(dout1_122) AT=875.025n

.meas tran vdout1_123ck1740 FIND v(dout1_123) AT=875.025n

.meas tran vdout1_124ck1740 FIND v(dout1_124) AT=875.025n

.meas tran vdout1_125ck1740 FIND v(dout1_125) AT=875.025n

.meas tran vdout1_126ck1740 FIND v(dout1_126) AT=875.025n

.meas tran vdout1_127ck1740 FIND v(dout1_127) AT=875.025n

.meas tran vdout1_0ck1750 FIND v(dout1_0) AT=880.025n

.meas tran vdout1_1ck1750 FIND v(dout1_1) AT=880.025n

.meas tran vdout1_2ck1750 FIND v(dout1_2) AT=880.025n

.meas tran vdout1_3ck1750 FIND v(dout1_3) AT=880.025n

.meas tran vdout1_4ck1750 FIND v(dout1_4) AT=880.025n

.meas tran vdout1_5ck1750 FIND v(dout1_5) AT=880.025n

.meas tran vdout1_6ck1750 FIND v(dout1_6) AT=880.025n

.meas tran vdout1_7ck1750 FIND v(dout1_7) AT=880.025n

.meas tran vdout1_8ck1750 FIND v(dout1_8) AT=880.025n

.meas tran vdout1_9ck1750 FIND v(dout1_9) AT=880.025n

.meas tran vdout1_10ck1750 FIND v(dout1_10) AT=880.025n

.meas tran vdout1_11ck1750 FIND v(dout1_11) AT=880.025n

.meas tran vdout1_12ck1750 FIND v(dout1_12) AT=880.025n

.meas tran vdout1_13ck1750 FIND v(dout1_13) AT=880.025n

.meas tran vdout1_14ck1750 FIND v(dout1_14) AT=880.025n

.meas tran vdout1_15ck1750 FIND v(dout1_15) AT=880.025n

.meas tran vdout1_16ck1750 FIND v(dout1_16) AT=880.025n

.meas tran vdout1_17ck1750 FIND v(dout1_17) AT=880.025n

.meas tran vdout1_18ck1750 FIND v(dout1_18) AT=880.025n

.meas tran vdout1_19ck1750 FIND v(dout1_19) AT=880.025n

.meas tran vdout1_20ck1750 FIND v(dout1_20) AT=880.025n

.meas tran vdout1_21ck1750 FIND v(dout1_21) AT=880.025n

.meas tran vdout1_22ck1750 FIND v(dout1_22) AT=880.025n

.meas tran vdout1_23ck1750 FIND v(dout1_23) AT=880.025n

.meas tran vdout1_24ck1750 FIND v(dout1_24) AT=880.025n

.meas tran vdout1_25ck1750 FIND v(dout1_25) AT=880.025n

.meas tran vdout1_26ck1750 FIND v(dout1_26) AT=880.025n

.meas tran vdout1_27ck1750 FIND v(dout1_27) AT=880.025n

.meas tran vdout1_28ck1750 FIND v(dout1_28) AT=880.025n

.meas tran vdout1_29ck1750 FIND v(dout1_29) AT=880.025n

.meas tran vdout1_30ck1750 FIND v(dout1_30) AT=880.025n

.meas tran vdout1_31ck1750 FIND v(dout1_31) AT=880.025n

.meas tran vdout1_32ck1750 FIND v(dout1_32) AT=880.025n

.meas tran vdout1_33ck1750 FIND v(dout1_33) AT=880.025n

.meas tran vdout1_34ck1750 FIND v(dout1_34) AT=880.025n

.meas tran vdout1_35ck1750 FIND v(dout1_35) AT=880.025n

.meas tran vdout1_36ck1750 FIND v(dout1_36) AT=880.025n

.meas tran vdout1_37ck1750 FIND v(dout1_37) AT=880.025n

.meas tran vdout1_38ck1750 FIND v(dout1_38) AT=880.025n

.meas tran vdout1_39ck1750 FIND v(dout1_39) AT=880.025n

.meas tran vdout1_40ck1750 FIND v(dout1_40) AT=880.025n

.meas tran vdout1_41ck1750 FIND v(dout1_41) AT=880.025n

.meas tran vdout1_42ck1750 FIND v(dout1_42) AT=880.025n

.meas tran vdout1_43ck1750 FIND v(dout1_43) AT=880.025n

.meas tran vdout1_44ck1750 FIND v(dout1_44) AT=880.025n

.meas tran vdout1_45ck1750 FIND v(dout1_45) AT=880.025n

.meas tran vdout1_46ck1750 FIND v(dout1_46) AT=880.025n

.meas tran vdout1_47ck1750 FIND v(dout1_47) AT=880.025n

.meas tran vdout1_48ck1750 FIND v(dout1_48) AT=880.025n

.meas tran vdout1_49ck1750 FIND v(dout1_49) AT=880.025n

.meas tran vdout1_50ck1750 FIND v(dout1_50) AT=880.025n

.meas tran vdout1_51ck1750 FIND v(dout1_51) AT=880.025n

.meas tran vdout1_52ck1750 FIND v(dout1_52) AT=880.025n

.meas tran vdout1_53ck1750 FIND v(dout1_53) AT=880.025n

.meas tran vdout1_54ck1750 FIND v(dout1_54) AT=880.025n

.meas tran vdout1_55ck1750 FIND v(dout1_55) AT=880.025n

.meas tran vdout1_56ck1750 FIND v(dout1_56) AT=880.025n

.meas tran vdout1_57ck1750 FIND v(dout1_57) AT=880.025n

.meas tran vdout1_58ck1750 FIND v(dout1_58) AT=880.025n

.meas tran vdout1_59ck1750 FIND v(dout1_59) AT=880.025n

.meas tran vdout1_60ck1750 FIND v(dout1_60) AT=880.025n

.meas tran vdout1_61ck1750 FIND v(dout1_61) AT=880.025n

.meas tran vdout1_62ck1750 FIND v(dout1_62) AT=880.025n

.meas tran vdout1_63ck1750 FIND v(dout1_63) AT=880.025n

.meas tran vdout1_64ck1750 FIND v(dout1_64) AT=880.025n

.meas tran vdout1_65ck1750 FIND v(dout1_65) AT=880.025n

.meas tran vdout1_66ck1750 FIND v(dout1_66) AT=880.025n

.meas tran vdout1_67ck1750 FIND v(dout1_67) AT=880.025n

.meas tran vdout1_68ck1750 FIND v(dout1_68) AT=880.025n

.meas tran vdout1_69ck1750 FIND v(dout1_69) AT=880.025n

.meas tran vdout1_70ck1750 FIND v(dout1_70) AT=880.025n

.meas tran vdout1_71ck1750 FIND v(dout1_71) AT=880.025n

.meas tran vdout1_72ck1750 FIND v(dout1_72) AT=880.025n

.meas tran vdout1_73ck1750 FIND v(dout1_73) AT=880.025n

.meas tran vdout1_74ck1750 FIND v(dout1_74) AT=880.025n

.meas tran vdout1_75ck1750 FIND v(dout1_75) AT=880.025n

.meas tran vdout1_76ck1750 FIND v(dout1_76) AT=880.025n

.meas tran vdout1_77ck1750 FIND v(dout1_77) AT=880.025n

.meas tran vdout1_78ck1750 FIND v(dout1_78) AT=880.025n

.meas tran vdout1_79ck1750 FIND v(dout1_79) AT=880.025n

.meas tran vdout1_80ck1750 FIND v(dout1_80) AT=880.025n

.meas tran vdout1_81ck1750 FIND v(dout1_81) AT=880.025n

.meas tran vdout1_82ck1750 FIND v(dout1_82) AT=880.025n

.meas tran vdout1_83ck1750 FIND v(dout1_83) AT=880.025n

.meas tran vdout1_84ck1750 FIND v(dout1_84) AT=880.025n

.meas tran vdout1_85ck1750 FIND v(dout1_85) AT=880.025n

.meas tran vdout1_86ck1750 FIND v(dout1_86) AT=880.025n

.meas tran vdout1_87ck1750 FIND v(dout1_87) AT=880.025n

.meas tran vdout1_88ck1750 FIND v(dout1_88) AT=880.025n

.meas tran vdout1_89ck1750 FIND v(dout1_89) AT=880.025n

.meas tran vdout1_90ck1750 FIND v(dout1_90) AT=880.025n

.meas tran vdout1_91ck1750 FIND v(dout1_91) AT=880.025n

.meas tran vdout1_92ck1750 FIND v(dout1_92) AT=880.025n

.meas tran vdout1_93ck1750 FIND v(dout1_93) AT=880.025n

.meas tran vdout1_94ck1750 FIND v(dout1_94) AT=880.025n

.meas tran vdout1_95ck1750 FIND v(dout1_95) AT=880.025n

.meas tran vdout1_96ck1750 FIND v(dout1_96) AT=880.025n

.meas tran vdout1_97ck1750 FIND v(dout1_97) AT=880.025n

.meas tran vdout1_98ck1750 FIND v(dout1_98) AT=880.025n

.meas tran vdout1_99ck1750 FIND v(dout1_99) AT=880.025n

.meas tran vdout1_100ck1750 FIND v(dout1_100) AT=880.025n

.meas tran vdout1_101ck1750 FIND v(dout1_101) AT=880.025n

.meas tran vdout1_102ck1750 FIND v(dout1_102) AT=880.025n

.meas tran vdout1_103ck1750 FIND v(dout1_103) AT=880.025n

.meas tran vdout1_104ck1750 FIND v(dout1_104) AT=880.025n

.meas tran vdout1_105ck1750 FIND v(dout1_105) AT=880.025n

.meas tran vdout1_106ck1750 FIND v(dout1_106) AT=880.025n

.meas tran vdout1_107ck1750 FIND v(dout1_107) AT=880.025n

.meas tran vdout1_108ck1750 FIND v(dout1_108) AT=880.025n

.meas tran vdout1_109ck1750 FIND v(dout1_109) AT=880.025n

.meas tran vdout1_110ck1750 FIND v(dout1_110) AT=880.025n

.meas tran vdout1_111ck1750 FIND v(dout1_111) AT=880.025n

.meas tran vdout1_112ck1750 FIND v(dout1_112) AT=880.025n

.meas tran vdout1_113ck1750 FIND v(dout1_113) AT=880.025n

.meas tran vdout1_114ck1750 FIND v(dout1_114) AT=880.025n

.meas tran vdout1_115ck1750 FIND v(dout1_115) AT=880.025n

.meas tran vdout1_116ck1750 FIND v(dout1_116) AT=880.025n

.meas tran vdout1_117ck1750 FIND v(dout1_117) AT=880.025n

.meas tran vdout1_118ck1750 FIND v(dout1_118) AT=880.025n

.meas tran vdout1_119ck1750 FIND v(dout1_119) AT=880.025n

.meas tran vdout1_120ck1750 FIND v(dout1_120) AT=880.025n

.meas tran vdout1_121ck1750 FIND v(dout1_121) AT=880.025n

.meas tran vdout1_122ck1750 FIND v(dout1_122) AT=880.025n

.meas tran vdout1_123ck1750 FIND v(dout1_123) AT=880.025n

.meas tran vdout1_124ck1750 FIND v(dout1_124) AT=880.025n

.meas tran vdout1_125ck1750 FIND v(dout1_125) AT=880.025n

.meas tran vdout1_126ck1750 FIND v(dout1_126) AT=880.025n

.meas tran vdout1_127ck1750 FIND v(dout1_127) AT=880.025n

.meas tran vdout1_0ck1760 FIND v(dout1_0) AT=885.025n

.meas tran vdout1_1ck1760 FIND v(dout1_1) AT=885.025n

.meas tran vdout1_2ck1760 FIND v(dout1_2) AT=885.025n

.meas tran vdout1_3ck1760 FIND v(dout1_3) AT=885.025n

.meas tran vdout1_4ck1760 FIND v(dout1_4) AT=885.025n

.meas tran vdout1_5ck1760 FIND v(dout1_5) AT=885.025n

.meas tran vdout1_6ck1760 FIND v(dout1_6) AT=885.025n

.meas tran vdout1_7ck1760 FIND v(dout1_7) AT=885.025n

.meas tran vdout1_8ck1760 FIND v(dout1_8) AT=885.025n

.meas tran vdout1_9ck1760 FIND v(dout1_9) AT=885.025n

.meas tran vdout1_10ck1760 FIND v(dout1_10) AT=885.025n

.meas tran vdout1_11ck1760 FIND v(dout1_11) AT=885.025n

.meas tran vdout1_12ck1760 FIND v(dout1_12) AT=885.025n

.meas tran vdout1_13ck1760 FIND v(dout1_13) AT=885.025n

.meas tran vdout1_14ck1760 FIND v(dout1_14) AT=885.025n

.meas tran vdout1_15ck1760 FIND v(dout1_15) AT=885.025n

.meas tran vdout1_16ck1760 FIND v(dout1_16) AT=885.025n

.meas tran vdout1_17ck1760 FIND v(dout1_17) AT=885.025n

.meas tran vdout1_18ck1760 FIND v(dout1_18) AT=885.025n

.meas tran vdout1_19ck1760 FIND v(dout1_19) AT=885.025n

.meas tran vdout1_20ck1760 FIND v(dout1_20) AT=885.025n

.meas tran vdout1_21ck1760 FIND v(dout1_21) AT=885.025n

.meas tran vdout1_22ck1760 FIND v(dout1_22) AT=885.025n

.meas tran vdout1_23ck1760 FIND v(dout1_23) AT=885.025n

.meas tran vdout1_24ck1760 FIND v(dout1_24) AT=885.025n

.meas tran vdout1_25ck1760 FIND v(dout1_25) AT=885.025n

.meas tran vdout1_26ck1760 FIND v(dout1_26) AT=885.025n

.meas tran vdout1_27ck1760 FIND v(dout1_27) AT=885.025n

.meas tran vdout1_28ck1760 FIND v(dout1_28) AT=885.025n

.meas tran vdout1_29ck1760 FIND v(dout1_29) AT=885.025n

.meas tran vdout1_30ck1760 FIND v(dout1_30) AT=885.025n

.meas tran vdout1_31ck1760 FIND v(dout1_31) AT=885.025n

.meas tran vdout1_32ck1760 FIND v(dout1_32) AT=885.025n

.meas tran vdout1_33ck1760 FIND v(dout1_33) AT=885.025n

.meas tran vdout1_34ck1760 FIND v(dout1_34) AT=885.025n

.meas tran vdout1_35ck1760 FIND v(dout1_35) AT=885.025n

.meas tran vdout1_36ck1760 FIND v(dout1_36) AT=885.025n

.meas tran vdout1_37ck1760 FIND v(dout1_37) AT=885.025n

.meas tran vdout1_38ck1760 FIND v(dout1_38) AT=885.025n

.meas tran vdout1_39ck1760 FIND v(dout1_39) AT=885.025n

.meas tran vdout1_40ck1760 FIND v(dout1_40) AT=885.025n

.meas tran vdout1_41ck1760 FIND v(dout1_41) AT=885.025n

.meas tran vdout1_42ck1760 FIND v(dout1_42) AT=885.025n

.meas tran vdout1_43ck1760 FIND v(dout1_43) AT=885.025n

.meas tran vdout1_44ck1760 FIND v(dout1_44) AT=885.025n

.meas tran vdout1_45ck1760 FIND v(dout1_45) AT=885.025n

.meas tran vdout1_46ck1760 FIND v(dout1_46) AT=885.025n

.meas tran vdout1_47ck1760 FIND v(dout1_47) AT=885.025n

.meas tran vdout1_48ck1760 FIND v(dout1_48) AT=885.025n

.meas tran vdout1_49ck1760 FIND v(dout1_49) AT=885.025n

.meas tran vdout1_50ck1760 FIND v(dout1_50) AT=885.025n

.meas tran vdout1_51ck1760 FIND v(dout1_51) AT=885.025n

.meas tran vdout1_52ck1760 FIND v(dout1_52) AT=885.025n

.meas tran vdout1_53ck1760 FIND v(dout1_53) AT=885.025n

.meas tran vdout1_54ck1760 FIND v(dout1_54) AT=885.025n

.meas tran vdout1_55ck1760 FIND v(dout1_55) AT=885.025n

.meas tran vdout1_56ck1760 FIND v(dout1_56) AT=885.025n

.meas tran vdout1_57ck1760 FIND v(dout1_57) AT=885.025n

.meas tran vdout1_58ck1760 FIND v(dout1_58) AT=885.025n

.meas tran vdout1_59ck1760 FIND v(dout1_59) AT=885.025n

.meas tran vdout1_60ck1760 FIND v(dout1_60) AT=885.025n

.meas tran vdout1_61ck1760 FIND v(dout1_61) AT=885.025n

.meas tran vdout1_62ck1760 FIND v(dout1_62) AT=885.025n

.meas tran vdout1_63ck1760 FIND v(dout1_63) AT=885.025n

.meas tran vdout1_64ck1760 FIND v(dout1_64) AT=885.025n

.meas tran vdout1_65ck1760 FIND v(dout1_65) AT=885.025n

.meas tran vdout1_66ck1760 FIND v(dout1_66) AT=885.025n

.meas tran vdout1_67ck1760 FIND v(dout1_67) AT=885.025n

.meas tran vdout1_68ck1760 FIND v(dout1_68) AT=885.025n

.meas tran vdout1_69ck1760 FIND v(dout1_69) AT=885.025n

.meas tran vdout1_70ck1760 FIND v(dout1_70) AT=885.025n

.meas tran vdout1_71ck1760 FIND v(dout1_71) AT=885.025n

.meas tran vdout1_72ck1760 FIND v(dout1_72) AT=885.025n

.meas tran vdout1_73ck1760 FIND v(dout1_73) AT=885.025n

.meas tran vdout1_74ck1760 FIND v(dout1_74) AT=885.025n

.meas tran vdout1_75ck1760 FIND v(dout1_75) AT=885.025n

.meas tran vdout1_76ck1760 FIND v(dout1_76) AT=885.025n

.meas tran vdout1_77ck1760 FIND v(dout1_77) AT=885.025n

.meas tran vdout1_78ck1760 FIND v(dout1_78) AT=885.025n

.meas tran vdout1_79ck1760 FIND v(dout1_79) AT=885.025n

.meas tran vdout1_80ck1760 FIND v(dout1_80) AT=885.025n

.meas tran vdout1_81ck1760 FIND v(dout1_81) AT=885.025n

.meas tran vdout1_82ck1760 FIND v(dout1_82) AT=885.025n

.meas tran vdout1_83ck1760 FIND v(dout1_83) AT=885.025n

.meas tran vdout1_84ck1760 FIND v(dout1_84) AT=885.025n

.meas tran vdout1_85ck1760 FIND v(dout1_85) AT=885.025n

.meas tran vdout1_86ck1760 FIND v(dout1_86) AT=885.025n

.meas tran vdout1_87ck1760 FIND v(dout1_87) AT=885.025n

.meas tran vdout1_88ck1760 FIND v(dout1_88) AT=885.025n

.meas tran vdout1_89ck1760 FIND v(dout1_89) AT=885.025n

.meas tran vdout1_90ck1760 FIND v(dout1_90) AT=885.025n

.meas tran vdout1_91ck1760 FIND v(dout1_91) AT=885.025n

.meas tran vdout1_92ck1760 FIND v(dout1_92) AT=885.025n

.meas tran vdout1_93ck1760 FIND v(dout1_93) AT=885.025n

.meas tran vdout1_94ck1760 FIND v(dout1_94) AT=885.025n

.meas tran vdout1_95ck1760 FIND v(dout1_95) AT=885.025n

.meas tran vdout1_96ck1760 FIND v(dout1_96) AT=885.025n

.meas tran vdout1_97ck1760 FIND v(dout1_97) AT=885.025n

.meas tran vdout1_98ck1760 FIND v(dout1_98) AT=885.025n

.meas tran vdout1_99ck1760 FIND v(dout1_99) AT=885.025n

.meas tran vdout1_100ck1760 FIND v(dout1_100) AT=885.025n

.meas tran vdout1_101ck1760 FIND v(dout1_101) AT=885.025n

.meas tran vdout1_102ck1760 FIND v(dout1_102) AT=885.025n

.meas tran vdout1_103ck1760 FIND v(dout1_103) AT=885.025n

.meas tran vdout1_104ck1760 FIND v(dout1_104) AT=885.025n

.meas tran vdout1_105ck1760 FIND v(dout1_105) AT=885.025n

.meas tran vdout1_106ck1760 FIND v(dout1_106) AT=885.025n

.meas tran vdout1_107ck1760 FIND v(dout1_107) AT=885.025n

.meas tran vdout1_108ck1760 FIND v(dout1_108) AT=885.025n

.meas tran vdout1_109ck1760 FIND v(dout1_109) AT=885.025n

.meas tran vdout1_110ck1760 FIND v(dout1_110) AT=885.025n

.meas tran vdout1_111ck1760 FIND v(dout1_111) AT=885.025n

.meas tran vdout1_112ck1760 FIND v(dout1_112) AT=885.025n

.meas tran vdout1_113ck1760 FIND v(dout1_113) AT=885.025n

.meas tran vdout1_114ck1760 FIND v(dout1_114) AT=885.025n

.meas tran vdout1_115ck1760 FIND v(dout1_115) AT=885.025n

.meas tran vdout1_116ck1760 FIND v(dout1_116) AT=885.025n

.meas tran vdout1_117ck1760 FIND v(dout1_117) AT=885.025n

.meas tran vdout1_118ck1760 FIND v(dout1_118) AT=885.025n

.meas tran vdout1_119ck1760 FIND v(dout1_119) AT=885.025n

.meas tran vdout1_120ck1760 FIND v(dout1_120) AT=885.025n

.meas tran vdout1_121ck1760 FIND v(dout1_121) AT=885.025n

.meas tran vdout1_122ck1760 FIND v(dout1_122) AT=885.025n

.meas tran vdout1_123ck1760 FIND v(dout1_123) AT=885.025n

.meas tran vdout1_124ck1760 FIND v(dout1_124) AT=885.025n

.meas tran vdout1_125ck1760 FIND v(dout1_125) AT=885.025n

.meas tran vdout1_126ck1760 FIND v(dout1_126) AT=885.025n

.meas tran vdout1_127ck1760 FIND v(dout1_127) AT=885.025n

.meas tran vdout1_0ck1780 FIND v(dout1_0) AT=895.025n

.meas tran vdout1_1ck1780 FIND v(dout1_1) AT=895.025n

.meas tran vdout1_2ck1780 FIND v(dout1_2) AT=895.025n

.meas tran vdout1_3ck1780 FIND v(dout1_3) AT=895.025n

.meas tran vdout1_4ck1780 FIND v(dout1_4) AT=895.025n

.meas tran vdout1_5ck1780 FIND v(dout1_5) AT=895.025n

.meas tran vdout1_6ck1780 FIND v(dout1_6) AT=895.025n

.meas tran vdout1_7ck1780 FIND v(dout1_7) AT=895.025n

.meas tran vdout1_8ck1780 FIND v(dout1_8) AT=895.025n

.meas tran vdout1_9ck1780 FIND v(dout1_9) AT=895.025n

.meas tran vdout1_10ck1780 FIND v(dout1_10) AT=895.025n

.meas tran vdout1_11ck1780 FIND v(dout1_11) AT=895.025n

.meas tran vdout1_12ck1780 FIND v(dout1_12) AT=895.025n

.meas tran vdout1_13ck1780 FIND v(dout1_13) AT=895.025n

.meas tran vdout1_14ck1780 FIND v(dout1_14) AT=895.025n

.meas tran vdout1_15ck1780 FIND v(dout1_15) AT=895.025n

.meas tran vdout1_16ck1780 FIND v(dout1_16) AT=895.025n

.meas tran vdout1_17ck1780 FIND v(dout1_17) AT=895.025n

.meas tran vdout1_18ck1780 FIND v(dout1_18) AT=895.025n

.meas tran vdout1_19ck1780 FIND v(dout1_19) AT=895.025n

.meas tran vdout1_20ck1780 FIND v(dout1_20) AT=895.025n

.meas tran vdout1_21ck1780 FIND v(dout1_21) AT=895.025n

.meas tran vdout1_22ck1780 FIND v(dout1_22) AT=895.025n

.meas tran vdout1_23ck1780 FIND v(dout1_23) AT=895.025n

.meas tran vdout1_24ck1780 FIND v(dout1_24) AT=895.025n

.meas tran vdout1_25ck1780 FIND v(dout1_25) AT=895.025n

.meas tran vdout1_26ck1780 FIND v(dout1_26) AT=895.025n

.meas tran vdout1_27ck1780 FIND v(dout1_27) AT=895.025n

.meas tran vdout1_28ck1780 FIND v(dout1_28) AT=895.025n

.meas tran vdout1_29ck1780 FIND v(dout1_29) AT=895.025n

.meas tran vdout1_30ck1780 FIND v(dout1_30) AT=895.025n

.meas tran vdout1_31ck1780 FIND v(dout1_31) AT=895.025n

.meas tran vdout1_32ck1780 FIND v(dout1_32) AT=895.025n

.meas tran vdout1_33ck1780 FIND v(dout1_33) AT=895.025n

.meas tran vdout1_34ck1780 FIND v(dout1_34) AT=895.025n

.meas tran vdout1_35ck1780 FIND v(dout1_35) AT=895.025n

.meas tran vdout1_36ck1780 FIND v(dout1_36) AT=895.025n

.meas tran vdout1_37ck1780 FIND v(dout1_37) AT=895.025n

.meas tran vdout1_38ck1780 FIND v(dout1_38) AT=895.025n

.meas tran vdout1_39ck1780 FIND v(dout1_39) AT=895.025n

.meas tran vdout1_40ck1780 FIND v(dout1_40) AT=895.025n

.meas tran vdout1_41ck1780 FIND v(dout1_41) AT=895.025n

.meas tran vdout1_42ck1780 FIND v(dout1_42) AT=895.025n

.meas tran vdout1_43ck1780 FIND v(dout1_43) AT=895.025n

.meas tran vdout1_44ck1780 FIND v(dout1_44) AT=895.025n

.meas tran vdout1_45ck1780 FIND v(dout1_45) AT=895.025n

.meas tran vdout1_46ck1780 FIND v(dout1_46) AT=895.025n

.meas tran vdout1_47ck1780 FIND v(dout1_47) AT=895.025n

.meas tran vdout1_48ck1780 FIND v(dout1_48) AT=895.025n

.meas tran vdout1_49ck1780 FIND v(dout1_49) AT=895.025n

.meas tran vdout1_50ck1780 FIND v(dout1_50) AT=895.025n

.meas tran vdout1_51ck1780 FIND v(dout1_51) AT=895.025n

.meas tran vdout1_52ck1780 FIND v(dout1_52) AT=895.025n

.meas tran vdout1_53ck1780 FIND v(dout1_53) AT=895.025n

.meas tran vdout1_54ck1780 FIND v(dout1_54) AT=895.025n

.meas tran vdout1_55ck1780 FIND v(dout1_55) AT=895.025n

.meas tran vdout1_56ck1780 FIND v(dout1_56) AT=895.025n

.meas tran vdout1_57ck1780 FIND v(dout1_57) AT=895.025n

.meas tran vdout1_58ck1780 FIND v(dout1_58) AT=895.025n

.meas tran vdout1_59ck1780 FIND v(dout1_59) AT=895.025n

.meas tran vdout1_60ck1780 FIND v(dout1_60) AT=895.025n

.meas tran vdout1_61ck1780 FIND v(dout1_61) AT=895.025n

.meas tran vdout1_62ck1780 FIND v(dout1_62) AT=895.025n

.meas tran vdout1_63ck1780 FIND v(dout1_63) AT=895.025n

.meas tran vdout1_64ck1780 FIND v(dout1_64) AT=895.025n

.meas tran vdout1_65ck1780 FIND v(dout1_65) AT=895.025n

.meas tran vdout1_66ck1780 FIND v(dout1_66) AT=895.025n

.meas tran vdout1_67ck1780 FIND v(dout1_67) AT=895.025n

.meas tran vdout1_68ck1780 FIND v(dout1_68) AT=895.025n

.meas tran vdout1_69ck1780 FIND v(dout1_69) AT=895.025n

.meas tran vdout1_70ck1780 FIND v(dout1_70) AT=895.025n

.meas tran vdout1_71ck1780 FIND v(dout1_71) AT=895.025n

.meas tran vdout1_72ck1780 FIND v(dout1_72) AT=895.025n

.meas tran vdout1_73ck1780 FIND v(dout1_73) AT=895.025n

.meas tran vdout1_74ck1780 FIND v(dout1_74) AT=895.025n

.meas tran vdout1_75ck1780 FIND v(dout1_75) AT=895.025n

.meas tran vdout1_76ck1780 FIND v(dout1_76) AT=895.025n

.meas tran vdout1_77ck1780 FIND v(dout1_77) AT=895.025n

.meas tran vdout1_78ck1780 FIND v(dout1_78) AT=895.025n

.meas tran vdout1_79ck1780 FIND v(dout1_79) AT=895.025n

.meas tran vdout1_80ck1780 FIND v(dout1_80) AT=895.025n

.meas tran vdout1_81ck1780 FIND v(dout1_81) AT=895.025n

.meas tran vdout1_82ck1780 FIND v(dout1_82) AT=895.025n

.meas tran vdout1_83ck1780 FIND v(dout1_83) AT=895.025n

.meas tran vdout1_84ck1780 FIND v(dout1_84) AT=895.025n

.meas tran vdout1_85ck1780 FIND v(dout1_85) AT=895.025n

.meas tran vdout1_86ck1780 FIND v(dout1_86) AT=895.025n

.meas tran vdout1_87ck1780 FIND v(dout1_87) AT=895.025n

.meas tran vdout1_88ck1780 FIND v(dout1_88) AT=895.025n

.meas tran vdout1_89ck1780 FIND v(dout1_89) AT=895.025n

.meas tran vdout1_90ck1780 FIND v(dout1_90) AT=895.025n

.meas tran vdout1_91ck1780 FIND v(dout1_91) AT=895.025n

.meas tran vdout1_92ck1780 FIND v(dout1_92) AT=895.025n

.meas tran vdout1_93ck1780 FIND v(dout1_93) AT=895.025n

.meas tran vdout1_94ck1780 FIND v(dout1_94) AT=895.025n

.meas tran vdout1_95ck1780 FIND v(dout1_95) AT=895.025n

.meas tran vdout1_96ck1780 FIND v(dout1_96) AT=895.025n

.meas tran vdout1_97ck1780 FIND v(dout1_97) AT=895.025n

.meas tran vdout1_98ck1780 FIND v(dout1_98) AT=895.025n

.meas tran vdout1_99ck1780 FIND v(dout1_99) AT=895.025n

.meas tran vdout1_100ck1780 FIND v(dout1_100) AT=895.025n

.meas tran vdout1_101ck1780 FIND v(dout1_101) AT=895.025n

.meas tran vdout1_102ck1780 FIND v(dout1_102) AT=895.025n

.meas tran vdout1_103ck1780 FIND v(dout1_103) AT=895.025n

.meas tran vdout1_104ck1780 FIND v(dout1_104) AT=895.025n

.meas tran vdout1_105ck1780 FIND v(dout1_105) AT=895.025n

.meas tran vdout1_106ck1780 FIND v(dout1_106) AT=895.025n

.meas tran vdout1_107ck1780 FIND v(dout1_107) AT=895.025n

.meas tran vdout1_108ck1780 FIND v(dout1_108) AT=895.025n

.meas tran vdout1_109ck1780 FIND v(dout1_109) AT=895.025n

.meas tran vdout1_110ck1780 FIND v(dout1_110) AT=895.025n

.meas tran vdout1_111ck1780 FIND v(dout1_111) AT=895.025n

.meas tran vdout1_112ck1780 FIND v(dout1_112) AT=895.025n

.meas tran vdout1_113ck1780 FIND v(dout1_113) AT=895.025n

.meas tran vdout1_114ck1780 FIND v(dout1_114) AT=895.025n

.meas tran vdout1_115ck1780 FIND v(dout1_115) AT=895.025n

.meas tran vdout1_116ck1780 FIND v(dout1_116) AT=895.025n

.meas tran vdout1_117ck1780 FIND v(dout1_117) AT=895.025n

.meas tran vdout1_118ck1780 FIND v(dout1_118) AT=895.025n

.meas tran vdout1_119ck1780 FIND v(dout1_119) AT=895.025n

.meas tran vdout1_120ck1780 FIND v(dout1_120) AT=895.025n

.meas tran vdout1_121ck1780 FIND v(dout1_121) AT=895.025n

.meas tran vdout1_122ck1780 FIND v(dout1_122) AT=895.025n

.meas tran vdout1_123ck1780 FIND v(dout1_123) AT=895.025n

.meas tran vdout1_124ck1780 FIND v(dout1_124) AT=895.025n

.meas tran vdout1_125ck1780 FIND v(dout1_125) AT=895.025n

.meas tran vdout1_126ck1780 FIND v(dout1_126) AT=895.025n

.meas tran vdout1_127ck1780 FIND v(dout1_127) AT=895.025n

.meas tran vdout1_0ck1810 FIND v(dout1_0) AT=910.025n

.meas tran vdout1_1ck1810 FIND v(dout1_1) AT=910.025n

.meas tran vdout1_2ck1810 FIND v(dout1_2) AT=910.025n

.meas tran vdout1_3ck1810 FIND v(dout1_3) AT=910.025n

.meas tran vdout1_4ck1810 FIND v(dout1_4) AT=910.025n

.meas tran vdout1_5ck1810 FIND v(dout1_5) AT=910.025n

.meas tran vdout1_6ck1810 FIND v(dout1_6) AT=910.025n

.meas tran vdout1_7ck1810 FIND v(dout1_7) AT=910.025n

.meas tran vdout1_8ck1810 FIND v(dout1_8) AT=910.025n

.meas tran vdout1_9ck1810 FIND v(dout1_9) AT=910.025n

.meas tran vdout1_10ck1810 FIND v(dout1_10) AT=910.025n

.meas tran vdout1_11ck1810 FIND v(dout1_11) AT=910.025n

.meas tran vdout1_12ck1810 FIND v(dout1_12) AT=910.025n

.meas tran vdout1_13ck1810 FIND v(dout1_13) AT=910.025n

.meas tran vdout1_14ck1810 FIND v(dout1_14) AT=910.025n

.meas tran vdout1_15ck1810 FIND v(dout1_15) AT=910.025n

.meas tran vdout1_16ck1810 FIND v(dout1_16) AT=910.025n

.meas tran vdout1_17ck1810 FIND v(dout1_17) AT=910.025n

.meas tran vdout1_18ck1810 FIND v(dout1_18) AT=910.025n

.meas tran vdout1_19ck1810 FIND v(dout1_19) AT=910.025n

.meas tran vdout1_20ck1810 FIND v(dout1_20) AT=910.025n

.meas tran vdout1_21ck1810 FIND v(dout1_21) AT=910.025n

.meas tran vdout1_22ck1810 FIND v(dout1_22) AT=910.025n

.meas tran vdout1_23ck1810 FIND v(dout1_23) AT=910.025n

.meas tran vdout1_24ck1810 FIND v(dout1_24) AT=910.025n

.meas tran vdout1_25ck1810 FIND v(dout1_25) AT=910.025n

.meas tran vdout1_26ck1810 FIND v(dout1_26) AT=910.025n

.meas tran vdout1_27ck1810 FIND v(dout1_27) AT=910.025n

.meas tran vdout1_28ck1810 FIND v(dout1_28) AT=910.025n

.meas tran vdout1_29ck1810 FIND v(dout1_29) AT=910.025n

.meas tran vdout1_30ck1810 FIND v(dout1_30) AT=910.025n

.meas tran vdout1_31ck1810 FIND v(dout1_31) AT=910.025n

.meas tran vdout1_32ck1810 FIND v(dout1_32) AT=910.025n

.meas tran vdout1_33ck1810 FIND v(dout1_33) AT=910.025n

.meas tran vdout1_34ck1810 FIND v(dout1_34) AT=910.025n

.meas tran vdout1_35ck1810 FIND v(dout1_35) AT=910.025n

.meas tran vdout1_36ck1810 FIND v(dout1_36) AT=910.025n

.meas tran vdout1_37ck1810 FIND v(dout1_37) AT=910.025n

.meas tran vdout1_38ck1810 FIND v(dout1_38) AT=910.025n

.meas tran vdout1_39ck1810 FIND v(dout1_39) AT=910.025n

.meas tran vdout1_40ck1810 FIND v(dout1_40) AT=910.025n

.meas tran vdout1_41ck1810 FIND v(dout1_41) AT=910.025n

.meas tran vdout1_42ck1810 FIND v(dout1_42) AT=910.025n

.meas tran vdout1_43ck1810 FIND v(dout1_43) AT=910.025n

.meas tran vdout1_44ck1810 FIND v(dout1_44) AT=910.025n

.meas tran vdout1_45ck1810 FIND v(dout1_45) AT=910.025n

.meas tran vdout1_46ck1810 FIND v(dout1_46) AT=910.025n

.meas tran vdout1_47ck1810 FIND v(dout1_47) AT=910.025n

.meas tran vdout1_48ck1810 FIND v(dout1_48) AT=910.025n

.meas tran vdout1_49ck1810 FIND v(dout1_49) AT=910.025n

.meas tran vdout1_50ck1810 FIND v(dout1_50) AT=910.025n

.meas tran vdout1_51ck1810 FIND v(dout1_51) AT=910.025n

.meas tran vdout1_52ck1810 FIND v(dout1_52) AT=910.025n

.meas tran vdout1_53ck1810 FIND v(dout1_53) AT=910.025n

.meas tran vdout1_54ck1810 FIND v(dout1_54) AT=910.025n

.meas tran vdout1_55ck1810 FIND v(dout1_55) AT=910.025n

.meas tran vdout1_56ck1810 FIND v(dout1_56) AT=910.025n

.meas tran vdout1_57ck1810 FIND v(dout1_57) AT=910.025n

.meas tran vdout1_58ck1810 FIND v(dout1_58) AT=910.025n

.meas tran vdout1_59ck1810 FIND v(dout1_59) AT=910.025n

.meas tran vdout1_60ck1810 FIND v(dout1_60) AT=910.025n

.meas tran vdout1_61ck1810 FIND v(dout1_61) AT=910.025n

.meas tran vdout1_62ck1810 FIND v(dout1_62) AT=910.025n

.meas tran vdout1_63ck1810 FIND v(dout1_63) AT=910.025n

.meas tran vdout1_64ck1810 FIND v(dout1_64) AT=910.025n

.meas tran vdout1_65ck1810 FIND v(dout1_65) AT=910.025n

.meas tran vdout1_66ck1810 FIND v(dout1_66) AT=910.025n

.meas tran vdout1_67ck1810 FIND v(dout1_67) AT=910.025n

.meas tran vdout1_68ck1810 FIND v(dout1_68) AT=910.025n

.meas tran vdout1_69ck1810 FIND v(dout1_69) AT=910.025n

.meas tran vdout1_70ck1810 FIND v(dout1_70) AT=910.025n

.meas tran vdout1_71ck1810 FIND v(dout1_71) AT=910.025n

.meas tran vdout1_72ck1810 FIND v(dout1_72) AT=910.025n

.meas tran vdout1_73ck1810 FIND v(dout1_73) AT=910.025n

.meas tran vdout1_74ck1810 FIND v(dout1_74) AT=910.025n

.meas tran vdout1_75ck1810 FIND v(dout1_75) AT=910.025n

.meas tran vdout1_76ck1810 FIND v(dout1_76) AT=910.025n

.meas tran vdout1_77ck1810 FIND v(dout1_77) AT=910.025n

.meas tran vdout1_78ck1810 FIND v(dout1_78) AT=910.025n

.meas tran vdout1_79ck1810 FIND v(dout1_79) AT=910.025n

.meas tran vdout1_80ck1810 FIND v(dout1_80) AT=910.025n

.meas tran vdout1_81ck1810 FIND v(dout1_81) AT=910.025n

.meas tran vdout1_82ck1810 FIND v(dout1_82) AT=910.025n

.meas tran vdout1_83ck1810 FIND v(dout1_83) AT=910.025n

.meas tran vdout1_84ck1810 FIND v(dout1_84) AT=910.025n

.meas tran vdout1_85ck1810 FIND v(dout1_85) AT=910.025n

.meas tran vdout1_86ck1810 FIND v(dout1_86) AT=910.025n

.meas tran vdout1_87ck1810 FIND v(dout1_87) AT=910.025n

.meas tran vdout1_88ck1810 FIND v(dout1_88) AT=910.025n

.meas tran vdout1_89ck1810 FIND v(dout1_89) AT=910.025n

.meas tran vdout1_90ck1810 FIND v(dout1_90) AT=910.025n

.meas tran vdout1_91ck1810 FIND v(dout1_91) AT=910.025n

.meas tran vdout1_92ck1810 FIND v(dout1_92) AT=910.025n

.meas tran vdout1_93ck1810 FIND v(dout1_93) AT=910.025n

.meas tran vdout1_94ck1810 FIND v(dout1_94) AT=910.025n

.meas tran vdout1_95ck1810 FIND v(dout1_95) AT=910.025n

.meas tran vdout1_96ck1810 FIND v(dout1_96) AT=910.025n

.meas tran vdout1_97ck1810 FIND v(dout1_97) AT=910.025n

.meas tran vdout1_98ck1810 FIND v(dout1_98) AT=910.025n

.meas tran vdout1_99ck1810 FIND v(dout1_99) AT=910.025n

.meas tran vdout1_100ck1810 FIND v(dout1_100) AT=910.025n

.meas tran vdout1_101ck1810 FIND v(dout1_101) AT=910.025n

.meas tran vdout1_102ck1810 FIND v(dout1_102) AT=910.025n

.meas tran vdout1_103ck1810 FIND v(dout1_103) AT=910.025n

.meas tran vdout1_104ck1810 FIND v(dout1_104) AT=910.025n

.meas tran vdout1_105ck1810 FIND v(dout1_105) AT=910.025n

.meas tran vdout1_106ck1810 FIND v(dout1_106) AT=910.025n

.meas tran vdout1_107ck1810 FIND v(dout1_107) AT=910.025n

.meas tran vdout1_108ck1810 FIND v(dout1_108) AT=910.025n

.meas tran vdout1_109ck1810 FIND v(dout1_109) AT=910.025n

.meas tran vdout1_110ck1810 FIND v(dout1_110) AT=910.025n

.meas tran vdout1_111ck1810 FIND v(dout1_111) AT=910.025n

.meas tran vdout1_112ck1810 FIND v(dout1_112) AT=910.025n

.meas tran vdout1_113ck1810 FIND v(dout1_113) AT=910.025n

.meas tran vdout1_114ck1810 FIND v(dout1_114) AT=910.025n

.meas tran vdout1_115ck1810 FIND v(dout1_115) AT=910.025n

.meas tran vdout1_116ck1810 FIND v(dout1_116) AT=910.025n

.meas tran vdout1_117ck1810 FIND v(dout1_117) AT=910.025n

.meas tran vdout1_118ck1810 FIND v(dout1_118) AT=910.025n

.meas tran vdout1_119ck1810 FIND v(dout1_119) AT=910.025n

.meas tran vdout1_120ck1810 FIND v(dout1_120) AT=910.025n

.meas tran vdout1_121ck1810 FIND v(dout1_121) AT=910.025n

.meas tran vdout1_122ck1810 FIND v(dout1_122) AT=910.025n

.meas tran vdout1_123ck1810 FIND v(dout1_123) AT=910.025n

.meas tran vdout1_124ck1810 FIND v(dout1_124) AT=910.025n

.meas tran vdout1_125ck1810 FIND v(dout1_125) AT=910.025n

.meas tran vdout1_126ck1810 FIND v(dout1_126) AT=910.025n

.meas tran vdout1_127ck1810 FIND v(dout1_127) AT=910.025n

.meas tran vdout1_0ck1830 FIND v(dout1_0) AT=920.025n

.meas tran vdout1_1ck1830 FIND v(dout1_1) AT=920.025n

.meas tran vdout1_2ck1830 FIND v(dout1_2) AT=920.025n

.meas tran vdout1_3ck1830 FIND v(dout1_3) AT=920.025n

.meas tran vdout1_4ck1830 FIND v(dout1_4) AT=920.025n

.meas tran vdout1_5ck1830 FIND v(dout1_5) AT=920.025n

.meas tran vdout1_6ck1830 FIND v(dout1_6) AT=920.025n

.meas tran vdout1_7ck1830 FIND v(dout1_7) AT=920.025n

.meas tran vdout1_8ck1830 FIND v(dout1_8) AT=920.025n

.meas tran vdout1_9ck1830 FIND v(dout1_9) AT=920.025n

.meas tran vdout1_10ck1830 FIND v(dout1_10) AT=920.025n

.meas tran vdout1_11ck1830 FIND v(dout1_11) AT=920.025n

.meas tran vdout1_12ck1830 FIND v(dout1_12) AT=920.025n

.meas tran vdout1_13ck1830 FIND v(dout1_13) AT=920.025n

.meas tran vdout1_14ck1830 FIND v(dout1_14) AT=920.025n

.meas tran vdout1_15ck1830 FIND v(dout1_15) AT=920.025n

.meas tran vdout1_16ck1830 FIND v(dout1_16) AT=920.025n

.meas tran vdout1_17ck1830 FIND v(dout1_17) AT=920.025n

.meas tran vdout1_18ck1830 FIND v(dout1_18) AT=920.025n

.meas tran vdout1_19ck1830 FIND v(dout1_19) AT=920.025n

.meas tran vdout1_20ck1830 FIND v(dout1_20) AT=920.025n

.meas tran vdout1_21ck1830 FIND v(dout1_21) AT=920.025n

.meas tran vdout1_22ck1830 FIND v(dout1_22) AT=920.025n

.meas tran vdout1_23ck1830 FIND v(dout1_23) AT=920.025n

.meas tran vdout1_24ck1830 FIND v(dout1_24) AT=920.025n

.meas tran vdout1_25ck1830 FIND v(dout1_25) AT=920.025n

.meas tran vdout1_26ck1830 FIND v(dout1_26) AT=920.025n

.meas tran vdout1_27ck1830 FIND v(dout1_27) AT=920.025n

.meas tran vdout1_28ck1830 FIND v(dout1_28) AT=920.025n

.meas tran vdout1_29ck1830 FIND v(dout1_29) AT=920.025n

.meas tran vdout1_30ck1830 FIND v(dout1_30) AT=920.025n

.meas tran vdout1_31ck1830 FIND v(dout1_31) AT=920.025n

.meas tran vdout1_32ck1830 FIND v(dout1_32) AT=920.025n

.meas tran vdout1_33ck1830 FIND v(dout1_33) AT=920.025n

.meas tran vdout1_34ck1830 FIND v(dout1_34) AT=920.025n

.meas tran vdout1_35ck1830 FIND v(dout1_35) AT=920.025n

.meas tran vdout1_36ck1830 FIND v(dout1_36) AT=920.025n

.meas tran vdout1_37ck1830 FIND v(dout1_37) AT=920.025n

.meas tran vdout1_38ck1830 FIND v(dout1_38) AT=920.025n

.meas tran vdout1_39ck1830 FIND v(dout1_39) AT=920.025n

.meas tran vdout1_40ck1830 FIND v(dout1_40) AT=920.025n

.meas tran vdout1_41ck1830 FIND v(dout1_41) AT=920.025n

.meas tran vdout1_42ck1830 FIND v(dout1_42) AT=920.025n

.meas tran vdout1_43ck1830 FIND v(dout1_43) AT=920.025n

.meas tran vdout1_44ck1830 FIND v(dout1_44) AT=920.025n

.meas tran vdout1_45ck1830 FIND v(dout1_45) AT=920.025n

.meas tran vdout1_46ck1830 FIND v(dout1_46) AT=920.025n

.meas tran vdout1_47ck1830 FIND v(dout1_47) AT=920.025n

.meas tran vdout1_48ck1830 FIND v(dout1_48) AT=920.025n

.meas tran vdout1_49ck1830 FIND v(dout1_49) AT=920.025n

.meas tran vdout1_50ck1830 FIND v(dout1_50) AT=920.025n

.meas tran vdout1_51ck1830 FIND v(dout1_51) AT=920.025n

.meas tran vdout1_52ck1830 FIND v(dout1_52) AT=920.025n

.meas tran vdout1_53ck1830 FIND v(dout1_53) AT=920.025n

.meas tran vdout1_54ck1830 FIND v(dout1_54) AT=920.025n

.meas tran vdout1_55ck1830 FIND v(dout1_55) AT=920.025n

.meas tran vdout1_56ck1830 FIND v(dout1_56) AT=920.025n

.meas tran vdout1_57ck1830 FIND v(dout1_57) AT=920.025n

.meas tran vdout1_58ck1830 FIND v(dout1_58) AT=920.025n

.meas tran vdout1_59ck1830 FIND v(dout1_59) AT=920.025n

.meas tran vdout1_60ck1830 FIND v(dout1_60) AT=920.025n

.meas tran vdout1_61ck1830 FIND v(dout1_61) AT=920.025n

.meas tran vdout1_62ck1830 FIND v(dout1_62) AT=920.025n

.meas tran vdout1_63ck1830 FIND v(dout1_63) AT=920.025n

.meas tran vdout1_64ck1830 FIND v(dout1_64) AT=920.025n

.meas tran vdout1_65ck1830 FIND v(dout1_65) AT=920.025n

.meas tran vdout1_66ck1830 FIND v(dout1_66) AT=920.025n

.meas tran vdout1_67ck1830 FIND v(dout1_67) AT=920.025n

.meas tran vdout1_68ck1830 FIND v(dout1_68) AT=920.025n

.meas tran vdout1_69ck1830 FIND v(dout1_69) AT=920.025n

.meas tran vdout1_70ck1830 FIND v(dout1_70) AT=920.025n

.meas tran vdout1_71ck1830 FIND v(dout1_71) AT=920.025n

.meas tran vdout1_72ck1830 FIND v(dout1_72) AT=920.025n

.meas tran vdout1_73ck1830 FIND v(dout1_73) AT=920.025n

.meas tran vdout1_74ck1830 FIND v(dout1_74) AT=920.025n

.meas tran vdout1_75ck1830 FIND v(dout1_75) AT=920.025n

.meas tran vdout1_76ck1830 FIND v(dout1_76) AT=920.025n

.meas tran vdout1_77ck1830 FIND v(dout1_77) AT=920.025n

.meas tran vdout1_78ck1830 FIND v(dout1_78) AT=920.025n

.meas tran vdout1_79ck1830 FIND v(dout1_79) AT=920.025n

.meas tran vdout1_80ck1830 FIND v(dout1_80) AT=920.025n

.meas tran vdout1_81ck1830 FIND v(dout1_81) AT=920.025n

.meas tran vdout1_82ck1830 FIND v(dout1_82) AT=920.025n

.meas tran vdout1_83ck1830 FIND v(dout1_83) AT=920.025n

.meas tran vdout1_84ck1830 FIND v(dout1_84) AT=920.025n

.meas tran vdout1_85ck1830 FIND v(dout1_85) AT=920.025n

.meas tran vdout1_86ck1830 FIND v(dout1_86) AT=920.025n

.meas tran vdout1_87ck1830 FIND v(dout1_87) AT=920.025n

.meas tran vdout1_88ck1830 FIND v(dout1_88) AT=920.025n

.meas tran vdout1_89ck1830 FIND v(dout1_89) AT=920.025n

.meas tran vdout1_90ck1830 FIND v(dout1_90) AT=920.025n

.meas tran vdout1_91ck1830 FIND v(dout1_91) AT=920.025n

.meas tran vdout1_92ck1830 FIND v(dout1_92) AT=920.025n

.meas tran vdout1_93ck1830 FIND v(dout1_93) AT=920.025n

.meas tran vdout1_94ck1830 FIND v(dout1_94) AT=920.025n

.meas tran vdout1_95ck1830 FIND v(dout1_95) AT=920.025n

.meas tran vdout1_96ck1830 FIND v(dout1_96) AT=920.025n

.meas tran vdout1_97ck1830 FIND v(dout1_97) AT=920.025n

.meas tran vdout1_98ck1830 FIND v(dout1_98) AT=920.025n

.meas tran vdout1_99ck1830 FIND v(dout1_99) AT=920.025n

.meas tran vdout1_100ck1830 FIND v(dout1_100) AT=920.025n

.meas tran vdout1_101ck1830 FIND v(dout1_101) AT=920.025n

.meas tran vdout1_102ck1830 FIND v(dout1_102) AT=920.025n

.meas tran vdout1_103ck1830 FIND v(dout1_103) AT=920.025n

.meas tran vdout1_104ck1830 FIND v(dout1_104) AT=920.025n

.meas tran vdout1_105ck1830 FIND v(dout1_105) AT=920.025n

.meas tran vdout1_106ck1830 FIND v(dout1_106) AT=920.025n

.meas tran vdout1_107ck1830 FIND v(dout1_107) AT=920.025n

.meas tran vdout1_108ck1830 FIND v(dout1_108) AT=920.025n

.meas tran vdout1_109ck1830 FIND v(dout1_109) AT=920.025n

.meas tran vdout1_110ck1830 FIND v(dout1_110) AT=920.025n

.meas tran vdout1_111ck1830 FIND v(dout1_111) AT=920.025n

.meas tran vdout1_112ck1830 FIND v(dout1_112) AT=920.025n

.meas tran vdout1_113ck1830 FIND v(dout1_113) AT=920.025n

.meas tran vdout1_114ck1830 FIND v(dout1_114) AT=920.025n

.meas tran vdout1_115ck1830 FIND v(dout1_115) AT=920.025n

.meas tran vdout1_116ck1830 FIND v(dout1_116) AT=920.025n

.meas tran vdout1_117ck1830 FIND v(dout1_117) AT=920.025n

.meas tran vdout1_118ck1830 FIND v(dout1_118) AT=920.025n

.meas tran vdout1_119ck1830 FIND v(dout1_119) AT=920.025n

.meas tran vdout1_120ck1830 FIND v(dout1_120) AT=920.025n

.meas tran vdout1_121ck1830 FIND v(dout1_121) AT=920.025n

.meas tran vdout1_122ck1830 FIND v(dout1_122) AT=920.025n

.meas tran vdout1_123ck1830 FIND v(dout1_123) AT=920.025n

.meas tran vdout1_124ck1830 FIND v(dout1_124) AT=920.025n

.meas tran vdout1_125ck1830 FIND v(dout1_125) AT=920.025n

.meas tran vdout1_126ck1830 FIND v(dout1_126) AT=920.025n

.meas tran vdout1_127ck1830 FIND v(dout1_127) AT=920.025n

.meas tran vdout1_0ck1840 FIND v(dout1_0) AT=925.025n

.meas tran vdout1_1ck1840 FIND v(dout1_1) AT=925.025n

.meas tran vdout1_2ck1840 FIND v(dout1_2) AT=925.025n

.meas tran vdout1_3ck1840 FIND v(dout1_3) AT=925.025n

.meas tran vdout1_4ck1840 FIND v(dout1_4) AT=925.025n

.meas tran vdout1_5ck1840 FIND v(dout1_5) AT=925.025n

.meas tran vdout1_6ck1840 FIND v(dout1_6) AT=925.025n

.meas tran vdout1_7ck1840 FIND v(dout1_7) AT=925.025n

.meas tran vdout1_8ck1840 FIND v(dout1_8) AT=925.025n

.meas tran vdout1_9ck1840 FIND v(dout1_9) AT=925.025n

.meas tran vdout1_10ck1840 FIND v(dout1_10) AT=925.025n

.meas tran vdout1_11ck1840 FIND v(dout1_11) AT=925.025n

.meas tran vdout1_12ck1840 FIND v(dout1_12) AT=925.025n

.meas tran vdout1_13ck1840 FIND v(dout1_13) AT=925.025n

.meas tran vdout1_14ck1840 FIND v(dout1_14) AT=925.025n

.meas tran vdout1_15ck1840 FIND v(dout1_15) AT=925.025n

.meas tran vdout1_16ck1840 FIND v(dout1_16) AT=925.025n

.meas tran vdout1_17ck1840 FIND v(dout1_17) AT=925.025n

.meas tran vdout1_18ck1840 FIND v(dout1_18) AT=925.025n

.meas tran vdout1_19ck1840 FIND v(dout1_19) AT=925.025n

.meas tran vdout1_20ck1840 FIND v(dout1_20) AT=925.025n

.meas tran vdout1_21ck1840 FIND v(dout1_21) AT=925.025n

.meas tran vdout1_22ck1840 FIND v(dout1_22) AT=925.025n

.meas tran vdout1_23ck1840 FIND v(dout1_23) AT=925.025n

.meas tran vdout1_24ck1840 FIND v(dout1_24) AT=925.025n

.meas tran vdout1_25ck1840 FIND v(dout1_25) AT=925.025n

.meas tran vdout1_26ck1840 FIND v(dout1_26) AT=925.025n

.meas tran vdout1_27ck1840 FIND v(dout1_27) AT=925.025n

.meas tran vdout1_28ck1840 FIND v(dout1_28) AT=925.025n

.meas tran vdout1_29ck1840 FIND v(dout1_29) AT=925.025n

.meas tran vdout1_30ck1840 FIND v(dout1_30) AT=925.025n

.meas tran vdout1_31ck1840 FIND v(dout1_31) AT=925.025n

.meas tran vdout1_32ck1840 FIND v(dout1_32) AT=925.025n

.meas tran vdout1_33ck1840 FIND v(dout1_33) AT=925.025n

.meas tran vdout1_34ck1840 FIND v(dout1_34) AT=925.025n

.meas tran vdout1_35ck1840 FIND v(dout1_35) AT=925.025n

.meas tran vdout1_36ck1840 FIND v(dout1_36) AT=925.025n

.meas tran vdout1_37ck1840 FIND v(dout1_37) AT=925.025n

.meas tran vdout1_38ck1840 FIND v(dout1_38) AT=925.025n

.meas tran vdout1_39ck1840 FIND v(dout1_39) AT=925.025n

.meas tran vdout1_40ck1840 FIND v(dout1_40) AT=925.025n

.meas tran vdout1_41ck1840 FIND v(dout1_41) AT=925.025n

.meas tran vdout1_42ck1840 FIND v(dout1_42) AT=925.025n

.meas tran vdout1_43ck1840 FIND v(dout1_43) AT=925.025n

.meas tran vdout1_44ck1840 FIND v(dout1_44) AT=925.025n

.meas tran vdout1_45ck1840 FIND v(dout1_45) AT=925.025n

.meas tran vdout1_46ck1840 FIND v(dout1_46) AT=925.025n

.meas tran vdout1_47ck1840 FIND v(dout1_47) AT=925.025n

.meas tran vdout1_48ck1840 FIND v(dout1_48) AT=925.025n

.meas tran vdout1_49ck1840 FIND v(dout1_49) AT=925.025n

.meas tran vdout1_50ck1840 FIND v(dout1_50) AT=925.025n

.meas tran vdout1_51ck1840 FIND v(dout1_51) AT=925.025n

.meas tran vdout1_52ck1840 FIND v(dout1_52) AT=925.025n

.meas tran vdout1_53ck1840 FIND v(dout1_53) AT=925.025n

.meas tran vdout1_54ck1840 FIND v(dout1_54) AT=925.025n

.meas tran vdout1_55ck1840 FIND v(dout1_55) AT=925.025n

.meas tran vdout1_56ck1840 FIND v(dout1_56) AT=925.025n

.meas tran vdout1_57ck1840 FIND v(dout1_57) AT=925.025n

.meas tran vdout1_58ck1840 FIND v(dout1_58) AT=925.025n

.meas tran vdout1_59ck1840 FIND v(dout1_59) AT=925.025n

.meas tran vdout1_60ck1840 FIND v(dout1_60) AT=925.025n

.meas tran vdout1_61ck1840 FIND v(dout1_61) AT=925.025n

.meas tran vdout1_62ck1840 FIND v(dout1_62) AT=925.025n

.meas tran vdout1_63ck1840 FIND v(dout1_63) AT=925.025n

.meas tran vdout1_64ck1840 FIND v(dout1_64) AT=925.025n

.meas tran vdout1_65ck1840 FIND v(dout1_65) AT=925.025n

.meas tran vdout1_66ck1840 FIND v(dout1_66) AT=925.025n

.meas tran vdout1_67ck1840 FIND v(dout1_67) AT=925.025n

.meas tran vdout1_68ck1840 FIND v(dout1_68) AT=925.025n

.meas tran vdout1_69ck1840 FIND v(dout1_69) AT=925.025n

.meas tran vdout1_70ck1840 FIND v(dout1_70) AT=925.025n

.meas tran vdout1_71ck1840 FIND v(dout1_71) AT=925.025n

.meas tran vdout1_72ck1840 FIND v(dout1_72) AT=925.025n

.meas tran vdout1_73ck1840 FIND v(dout1_73) AT=925.025n

.meas tran vdout1_74ck1840 FIND v(dout1_74) AT=925.025n

.meas tran vdout1_75ck1840 FIND v(dout1_75) AT=925.025n

.meas tran vdout1_76ck1840 FIND v(dout1_76) AT=925.025n

.meas tran vdout1_77ck1840 FIND v(dout1_77) AT=925.025n

.meas tran vdout1_78ck1840 FIND v(dout1_78) AT=925.025n

.meas tran vdout1_79ck1840 FIND v(dout1_79) AT=925.025n

.meas tran vdout1_80ck1840 FIND v(dout1_80) AT=925.025n

.meas tran vdout1_81ck1840 FIND v(dout1_81) AT=925.025n

.meas tran vdout1_82ck1840 FIND v(dout1_82) AT=925.025n

.meas tran vdout1_83ck1840 FIND v(dout1_83) AT=925.025n

.meas tran vdout1_84ck1840 FIND v(dout1_84) AT=925.025n

.meas tran vdout1_85ck1840 FIND v(dout1_85) AT=925.025n

.meas tran vdout1_86ck1840 FIND v(dout1_86) AT=925.025n

.meas tran vdout1_87ck1840 FIND v(dout1_87) AT=925.025n

.meas tran vdout1_88ck1840 FIND v(dout1_88) AT=925.025n

.meas tran vdout1_89ck1840 FIND v(dout1_89) AT=925.025n

.meas tran vdout1_90ck1840 FIND v(dout1_90) AT=925.025n

.meas tran vdout1_91ck1840 FIND v(dout1_91) AT=925.025n

.meas tran vdout1_92ck1840 FIND v(dout1_92) AT=925.025n

.meas tran vdout1_93ck1840 FIND v(dout1_93) AT=925.025n

.meas tran vdout1_94ck1840 FIND v(dout1_94) AT=925.025n

.meas tran vdout1_95ck1840 FIND v(dout1_95) AT=925.025n

.meas tran vdout1_96ck1840 FIND v(dout1_96) AT=925.025n

.meas tran vdout1_97ck1840 FIND v(dout1_97) AT=925.025n

.meas tran vdout1_98ck1840 FIND v(dout1_98) AT=925.025n

.meas tran vdout1_99ck1840 FIND v(dout1_99) AT=925.025n

.meas tran vdout1_100ck1840 FIND v(dout1_100) AT=925.025n

.meas tran vdout1_101ck1840 FIND v(dout1_101) AT=925.025n

.meas tran vdout1_102ck1840 FIND v(dout1_102) AT=925.025n

.meas tran vdout1_103ck1840 FIND v(dout1_103) AT=925.025n

.meas tran vdout1_104ck1840 FIND v(dout1_104) AT=925.025n

.meas tran vdout1_105ck1840 FIND v(dout1_105) AT=925.025n

.meas tran vdout1_106ck1840 FIND v(dout1_106) AT=925.025n

.meas tran vdout1_107ck1840 FIND v(dout1_107) AT=925.025n

.meas tran vdout1_108ck1840 FIND v(dout1_108) AT=925.025n

.meas tran vdout1_109ck1840 FIND v(dout1_109) AT=925.025n

.meas tran vdout1_110ck1840 FIND v(dout1_110) AT=925.025n

.meas tran vdout1_111ck1840 FIND v(dout1_111) AT=925.025n

.meas tran vdout1_112ck1840 FIND v(dout1_112) AT=925.025n

.meas tran vdout1_113ck1840 FIND v(dout1_113) AT=925.025n

.meas tran vdout1_114ck1840 FIND v(dout1_114) AT=925.025n

.meas tran vdout1_115ck1840 FIND v(dout1_115) AT=925.025n

.meas tran vdout1_116ck1840 FIND v(dout1_116) AT=925.025n

.meas tran vdout1_117ck1840 FIND v(dout1_117) AT=925.025n

.meas tran vdout1_118ck1840 FIND v(dout1_118) AT=925.025n

.meas tran vdout1_119ck1840 FIND v(dout1_119) AT=925.025n

.meas tran vdout1_120ck1840 FIND v(dout1_120) AT=925.025n

.meas tran vdout1_121ck1840 FIND v(dout1_121) AT=925.025n

.meas tran vdout1_122ck1840 FIND v(dout1_122) AT=925.025n

.meas tran vdout1_123ck1840 FIND v(dout1_123) AT=925.025n

.meas tran vdout1_124ck1840 FIND v(dout1_124) AT=925.025n

.meas tran vdout1_125ck1840 FIND v(dout1_125) AT=925.025n

.meas tran vdout1_126ck1840 FIND v(dout1_126) AT=925.025n

.meas tran vdout1_127ck1840 FIND v(dout1_127) AT=925.025n

.meas tran vdout1_0ck1850 FIND v(dout1_0) AT=930.025n

.meas tran vdout1_1ck1850 FIND v(dout1_1) AT=930.025n

.meas tran vdout1_2ck1850 FIND v(dout1_2) AT=930.025n

.meas tran vdout1_3ck1850 FIND v(dout1_3) AT=930.025n

.meas tran vdout1_4ck1850 FIND v(dout1_4) AT=930.025n

.meas tran vdout1_5ck1850 FIND v(dout1_5) AT=930.025n

.meas tran vdout1_6ck1850 FIND v(dout1_6) AT=930.025n

.meas tran vdout1_7ck1850 FIND v(dout1_7) AT=930.025n

.meas tran vdout1_8ck1850 FIND v(dout1_8) AT=930.025n

.meas tran vdout1_9ck1850 FIND v(dout1_9) AT=930.025n

.meas tran vdout1_10ck1850 FIND v(dout1_10) AT=930.025n

.meas tran vdout1_11ck1850 FIND v(dout1_11) AT=930.025n

.meas tran vdout1_12ck1850 FIND v(dout1_12) AT=930.025n

.meas tran vdout1_13ck1850 FIND v(dout1_13) AT=930.025n

.meas tran vdout1_14ck1850 FIND v(dout1_14) AT=930.025n

.meas tran vdout1_15ck1850 FIND v(dout1_15) AT=930.025n

.meas tran vdout1_16ck1850 FIND v(dout1_16) AT=930.025n

.meas tran vdout1_17ck1850 FIND v(dout1_17) AT=930.025n

.meas tran vdout1_18ck1850 FIND v(dout1_18) AT=930.025n

.meas tran vdout1_19ck1850 FIND v(dout1_19) AT=930.025n

.meas tran vdout1_20ck1850 FIND v(dout1_20) AT=930.025n

.meas tran vdout1_21ck1850 FIND v(dout1_21) AT=930.025n

.meas tran vdout1_22ck1850 FIND v(dout1_22) AT=930.025n

.meas tran vdout1_23ck1850 FIND v(dout1_23) AT=930.025n

.meas tran vdout1_24ck1850 FIND v(dout1_24) AT=930.025n

.meas tran vdout1_25ck1850 FIND v(dout1_25) AT=930.025n

.meas tran vdout1_26ck1850 FIND v(dout1_26) AT=930.025n

.meas tran vdout1_27ck1850 FIND v(dout1_27) AT=930.025n

.meas tran vdout1_28ck1850 FIND v(dout1_28) AT=930.025n

.meas tran vdout1_29ck1850 FIND v(dout1_29) AT=930.025n

.meas tran vdout1_30ck1850 FIND v(dout1_30) AT=930.025n

.meas tran vdout1_31ck1850 FIND v(dout1_31) AT=930.025n

.meas tran vdout1_32ck1850 FIND v(dout1_32) AT=930.025n

.meas tran vdout1_33ck1850 FIND v(dout1_33) AT=930.025n

.meas tran vdout1_34ck1850 FIND v(dout1_34) AT=930.025n

.meas tran vdout1_35ck1850 FIND v(dout1_35) AT=930.025n

.meas tran vdout1_36ck1850 FIND v(dout1_36) AT=930.025n

.meas tran vdout1_37ck1850 FIND v(dout1_37) AT=930.025n

.meas tran vdout1_38ck1850 FIND v(dout1_38) AT=930.025n

.meas tran vdout1_39ck1850 FIND v(dout1_39) AT=930.025n

.meas tran vdout1_40ck1850 FIND v(dout1_40) AT=930.025n

.meas tran vdout1_41ck1850 FIND v(dout1_41) AT=930.025n

.meas tran vdout1_42ck1850 FIND v(dout1_42) AT=930.025n

.meas tran vdout1_43ck1850 FIND v(dout1_43) AT=930.025n

.meas tran vdout1_44ck1850 FIND v(dout1_44) AT=930.025n

.meas tran vdout1_45ck1850 FIND v(dout1_45) AT=930.025n

.meas tran vdout1_46ck1850 FIND v(dout1_46) AT=930.025n

.meas tran vdout1_47ck1850 FIND v(dout1_47) AT=930.025n

.meas tran vdout1_48ck1850 FIND v(dout1_48) AT=930.025n

.meas tran vdout1_49ck1850 FIND v(dout1_49) AT=930.025n

.meas tran vdout1_50ck1850 FIND v(dout1_50) AT=930.025n

.meas tran vdout1_51ck1850 FIND v(dout1_51) AT=930.025n

.meas tran vdout1_52ck1850 FIND v(dout1_52) AT=930.025n

.meas tran vdout1_53ck1850 FIND v(dout1_53) AT=930.025n

.meas tran vdout1_54ck1850 FIND v(dout1_54) AT=930.025n

.meas tran vdout1_55ck1850 FIND v(dout1_55) AT=930.025n

.meas tran vdout1_56ck1850 FIND v(dout1_56) AT=930.025n

.meas tran vdout1_57ck1850 FIND v(dout1_57) AT=930.025n

.meas tran vdout1_58ck1850 FIND v(dout1_58) AT=930.025n

.meas tran vdout1_59ck1850 FIND v(dout1_59) AT=930.025n

.meas tran vdout1_60ck1850 FIND v(dout1_60) AT=930.025n

.meas tran vdout1_61ck1850 FIND v(dout1_61) AT=930.025n

.meas tran vdout1_62ck1850 FIND v(dout1_62) AT=930.025n

.meas tran vdout1_63ck1850 FIND v(dout1_63) AT=930.025n

.meas tran vdout1_64ck1850 FIND v(dout1_64) AT=930.025n

.meas tran vdout1_65ck1850 FIND v(dout1_65) AT=930.025n

.meas tran vdout1_66ck1850 FIND v(dout1_66) AT=930.025n

.meas tran vdout1_67ck1850 FIND v(dout1_67) AT=930.025n

.meas tran vdout1_68ck1850 FIND v(dout1_68) AT=930.025n

.meas tran vdout1_69ck1850 FIND v(dout1_69) AT=930.025n

.meas tran vdout1_70ck1850 FIND v(dout1_70) AT=930.025n

.meas tran vdout1_71ck1850 FIND v(dout1_71) AT=930.025n

.meas tran vdout1_72ck1850 FIND v(dout1_72) AT=930.025n

.meas tran vdout1_73ck1850 FIND v(dout1_73) AT=930.025n

.meas tran vdout1_74ck1850 FIND v(dout1_74) AT=930.025n

.meas tran vdout1_75ck1850 FIND v(dout1_75) AT=930.025n

.meas tran vdout1_76ck1850 FIND v(dout1_76) AT=930.025n

.meas tran vdout1_77ck1850 FIND v(dout1_77) AT=930.025n

.meas tran vdout1_78ck1850 FIND v(dout1_78) AT=930.025n

.meas tran vdout1_79ck1850 FIND v(dout1_79) AT=930.025n

.meas tran vdout1_80ck1850 FIND v(dout1_80) AT=930.025n

.meas tran vdout1_81ck1850 FIND v(dout1_81) AT=930.025n

.meas tran vdout1_82ck1850 FIND v(dout1_82) AT=930.025n

.meas tran vdout1_83ck1850 FIND v(dout1_83) AT=930.025n

.meas tran vdout1_84ck1850 FIND v(dout1_84) AT=930.025n

.meas tran vdout1_85ck1850 FIND v(dout1_85) AT=930.025n

.meas tran vdout1_86ck1850 FIND v(dout1_86) AT=930.025n

.meas tran vdout1_87ck1850 FIND v(dout1_87) AT=930.025n

.meas tran vdout1_88ck1850 FIND v(dout1_88) AT=930.025n

.meas tran vdout1_89ck1850 FIND v(dout1_89) AT=930.025n

.meas tran vdout1_90ck1850 FIND v(dout1_90) AT=930.025n

.meas tran vdout1_91ck1850 FIND v(dout1_91) AT=930.025n

.meas tran vdout1_92ck1850 FIND v(dout1_92) AT=930.025n

.meas tran vdout1_93ck1850 FIND v(dout1_93) AT=930.025n

.meas tran vdout1_94ck1850 FIND v(dout1_94) AT=930.025n

.meas tran vdout1_95ck1850 FIND v(dout1_95) AT=930.025n

.meas tran vdout1_96ck1850 FIND v(dout1_96) AT=930.025n

.meas tran vdout1_97ck1850 FIND v(dout1_97) AT=930.025n

.meas tran vdout1_98ck1850 FIND v(dout1_98) AT=930.025n

.meas tran vdout1_99ck1850 FIND v(dout1_99) AT=930.025n

.meas tran vdout1_100ck1850 FIND v(dout1_100) AT=930.025n

.meas tran vdout1_101ck1850 FIND v(dout1_101) AT=930.025n

.meas tran vdout1_102ck1850 FIND v(dout1_102) AT=930.025n

.meas tran vdout1_103ck1850 FIND v(dout1_103) AT=930.025n

.meas tran vdout1_104ck1850 FIND v(dout1_104) AT=930.025n

.meas tran vdout1_105ck1850 FIND v(dout1_105) AT=930.025n

.meas tran vdout1_106ck1850 FIND v(dout1_106) AT=930.025n

.meas tran vdout1_107ck1850 FIND v(dout1_107) AT=930.025n

.meas tran vdout1_108ck1850 FIND v(dout1_108) AT=930.025n

.meas tran vdout1_109ck1850 FIND v(dout1_109) AT=930.025n

.meas tran vdout1_110ck1850 FIND v(dout1_110) AT=930.025n

.meas tran vdout1_111ck1850 FIND v(dout1_111) AT=930.025n

.meas tran vdout1_112ck1850 FIND v(dout1_112) AT=930.025n

.meas tran vdout1_113ck1850 FIND v(dout1_113) AT=930.025n

.meas tran vdout1_114ck1850 FIND v(dout1_114) AT=930.025n

.meas tran vdout1_115ck1850 FIND v(dout1_115) AT=930.025n

.meas tran vdout1_116ck1850 FIND v(dout1_116) AT=930.025n

.meas tran vdout1_117ck1850 FIND v(dout1_117) AT=930.025n

.meas tran vdout1_118ck1850 FIND v(dout1_118) AT=930.025n

.meas tran vdout1_119ck1850 FIND v(dout1_119) AT=930.025n

.meas tran vdout1_120ck1850 FIND v(dout1_120) AT=930.025n

.meas tran vdout1_121ck1850 FIND v(dout1_121) AT=930.025n

.meas tran vdout1_122ck1850 FIND v(dout1_122) AT=930.025n

.meas tran vdout1_123ck1850 FIND v(dout1_123) AT=930.025n

.meas tran vdout1_124ck1850 FIND v(dout1_124) AT=930.025n

.meas tran vdout1_125ck1850 FIND v(dout1_125) AT=930.025n

.meas tran vdout1_126ck1850 FIND v(dout1_126) AT=930.025n

.meas tran vdout1_127ck1850 FIND v(dout1_127) AT=930.025n

.meas tran vdout1_0ck1870 FIND v(dout1_0) AT=940.025n

.meas tran vdout1_1ck1870 FIND v(dout1_1) AT=940.025n

.meas tran vdout1_2ck1870 FIND v(dout1_2) AT=940.025n

.meas tran vdout1_3ck1870 FIND v(dout1_3) AT=940.025n

.meas tran vdout1_4ck1870 FIND v(dout1_4) AT=940.025n

.meas tran vdout1_5ck1870 FIND v(dout1_5) AT=940.025n

.meas tran vdout1_6ck1870 FIND v(dout1_6) AT=940.025n

.meas tran vdout1_7ck1870 FIND v(dout1_7) AT=940.025n

.meas tran vdout1_8ck1870 FIND v(dout1_8) AT=940.025n

.meas tran vdout1_9ck1870 FIND v(dout1_9) AT=940.025n

.meas tran vdout1_10ck1870 FIND v(dout1_10) AT=940.025n

.meas tran vdout1_11ck1870 FIND v(dout1_11) AT=940.025n

.meas tran vdout1_12ck1870 FIND v(dout1_12) AT=940.025n

.meas tran vdout1_13ck1870 FIND v(dout1_13) AT=940.025n

.meas tran vdout1_14ck1870 FIND v(dout1_14) AT=940.025n

.meas tran vdout1_15ck1870 FIND v(dout1_15) AT=940.025n

.meas tran vdout1_16ck1870 FIND v(dout1_16) AT=940.025n

.meas tran vdout1_17ck1870 FIND v(dout1_17) AT=940.025n

.meas tran vdout1_18ck1870 FIND v(dout1_18) AT=940.025n

.meas tran vdout1_19ck1870 FIND v(dout1_19) AT=940.025n

.meas tran vdout1_20ck1870 FIND v(dout1_20) AT=940.025n

.meas tran vdout1_21ck1870 FIND v(dout1_21) AT=940.025n

.meas tran vdout1_22ck1870 FIND v(dout1_22) AT=940.025n

.meas tran vdout1_23ck1870 FIND v(dout1_23) AT=940.025n

.meas tran vdout1_24ck1870 FIND v(dout1_24) AT=940.025n

.meas tran vdout1_25ck1870 FIND v(dout1_25) AT=940.025n

.meas tran vdout1_26ck1870 FIND v(dout1_26) AT=940.025n

.meas tran vdout1_27ck1870 FIND v(dout1_27) AT=940.025n

.meas tran vdout1_28ck1870 FIND v(dout1_28) AT=940.025n

.meas tran vdout1_29ck1870 FIND v(dout1_29) AT=940.025n

.meas tran vdout1_30ck1870 FIND v(dout1_30) AT=940.025n

.meas tran vdout1_31ck1870 FIND v(dout1_31) AT=940.025n

.meas tran vdout1_32ck1870 FIND v(dout1_32) AT=940.025n

.meas tran vdout1_33ck1870 FIND v(dout1_33) AT=940.025n

.meas tran vdout1_34ck1870 FIND v(dout1_34) AT=940.025n

.meas tran vdout1_35ck1870 FIND v(dout1_35) AT=940.025n

.meas tran vdout1_36ck1870 FIND v(dout1_36) AT=940.025n

.meas tran vdout1_37ck1870 FIND v(dout1_37) AT=940.025n

.meas tran vdout1_38ck1870 FIND v(dout1_38) AT=940.025n

.meas tran vdout1_39ck1870 FIND v(dout1_39) AT=940.025n

.meas tran vdout1_40ck1870 FIND v(dout1_40) AT=940.025n

.meas tran vdout1_41ck1870 FIND v(dout1_41) AT=940.025n

.meas tran vdout1_42ck1870 FIND v(dout1_42) AT=940.025n

.meas tran vdout1_43ck1870 FIND v(dout1_43) AT=940.025n

.meas tran vdout1_44ck1870 FIND v(dout1_44) AT=940.025n

.meas tran vdout1_45ck1870 FIND v(dout1_45) AT=940.025n

.meas tran vdout1_46ck1870 FIND v(dout1_46) AT=940.025n

.meas tran vdout1_47ck1870 FIND v(dout1_47) AT=940.025n

.meas tran vdout1_48ck1870 FIND v(dout1_48) AT=940.025n

.meas tran vdout1_49ck1870 FIND v(dout1_49) AT=940.025n

.meas tran vdout1_50ck1870 FIND v(dout1_50) AT=940.025n

.meas tran vdout1_51ck1870 FIND v(dout1_51) AT=940.025n

.meas tran vdout1_52ck1870 FIND v(dout1_52) AT=940.025n

.meas tran vdout1_53ck1870 FIND v(dout1_53) AT=940.025n

.meas tran vdout1_54ck1870 FIND v(dout1_54) AT=940.025n

.meas tran vdout1_55ck1870 FIND v(dout1_55) AT=940.025n

.meas tran vdout1_56ck1870 FIND v(dout1_56) AT=940.025n

.meas tran vdout1_57ck1870 FIND v(dout1_57) AT=940.025n

.meas tran vdout1_58ck1870 FIND v(dout1_58) AT=940.025n

.meas tran vdout1_59ck1870 FIND v(dout1_59) AT=940.025n

.meas tran vdout1_60ck1870 FIND v(dout1_60) AT=940.025n

.meas tran vdout1_61ck1870 FIND v(dout1_61) AT=940.025n

.meas tran vdout1_62ck1870 FIND v(dout1_62) AT=940.025n

.meas tran vdout1_63ck1870 FIND v(dout1_63) AT=940.025n

.meas tran vdout1_64ck1870 FIND v(dout1_64) AT=940.025n

.meas tran vdout1_65ck1870 FIND v(dout1_65) AT=940.025n

.meas tran vdout1_66ck1870 FIND v(dout1_66) AT=940.025n

.meas tran vdout1_67ck1870 FIND v(dout1_67) AT=940.025n

.meas tran vdout1_68ck1870 FIND v(dout1_68) AT=940.025n

.meas tran vdout1_69ck1870 FIND v(dout1_69) AT=940.025n

.meas tran vdout1_70ck1870 FIND v(dout1_70) AT=940.025n

.meas tran vdout1_71ck1870 FIND v(dout1_71) AT=940.025n

.meas tran vdout1_72ck1870 FIND v(dout1_72) AT=940.025n

.meas tran vdout1_73ck1870 FIND v(dout1_73) AT=940.025n

.meas tran vdout1_74ck1870 FIND v(dout1_74) AT=940.025n

.meas tran vdout1_75ck1870 FIND v(dout1_75) AT=940.025n

.meas tran vdout1_76ck1870 FIND v(dout1_76) AT=940.025n

.meas tran vdout1_77ck1870 FIND v(dout1_77) AT=940.025n

.meas tran vdout1_78ck1870 FIND v(dout1_78) AT=940.025n

.meas tran vdout1_79ck1870 FIND v(dout1_79) AT=940.025n

.meas tran vdout1_80ck1870 FIND v(dout1_80) AT=940.025n

.meas tran vdout1_81ck1870 FIND v(dout1_81) AT=940.025n

.meas tran vdout1_82ck1870 FIND v(dout1_82) AT=940.025n

.meas tran vdout1_83ck1870 FIND v(dout1_83) AT=940.025n

.meas tran vdout1_84ck1870 FIND v(dout1_84) AT=940.025n

.meas tran vdout1_85ck1870 FIND v(dout1_85) AT=940.025n

.meas tran vdout1_86ck1870 FIND v(dout1_86) AT=940.025n

.meas tran vdout1_87ck1870 FIND v(dout1_87) AT=940.025n

.meas tran vdout1_88ck1870 FIND v(dout1_88) AT=940.025n

.meas tran vdout1_89ck1870 FIND v(dout1_89) AT=940.025n

.meas tran vdout1_90ck1870 FIND v(dout1_90) AT=940.025n

.meas tran vdout1_91ck1870 FIND v(dout1_91) AT=940.025n

.meas tran vdout1_92ck1870 FIND v(dout1_92) AT=940.025n

.meas tran vdout1_93ck1870 FIND v(dout1_93) AT=940.025n

.meas tran vdout1_94ck1870 FIND v(dout1_94) AT=940.025n

.meas tran vdout1_95ck1870 FIND v(dout1_95) AT=940.025n

.meas tran vdout1_96ck1870 FIND v(dout1_96) AT=940.025n

.meas tran vdout1_97ck1870 FIND v(dout1_97) AT=940.025n

.meas tran vdout1_98ck1870 FIND v(dout1_98) AT=940.025n

.meas tran vdout1_99ck1870 FIND v(dout1_99) AT=940.025n

.meas tran vdout1_100ck1870 FIND v(dout1_100) AT=940.025n

.meas tran vdout1_101ck1870 FIND v(dout1_101) AT=940.025n

.meas tran vdout1_102ck1870 FIND v(dout1_102) AT=940.025n

.meas tran vdout1_103ck1870 FIND v(dout1_103) AT=940.025n

.meas tran vdout1_104ck1870 FIND v(dout1_104) AT=940.025n

.meas tran vdout1_105ck1870 FIND v(dout1_105) AT=940.025n

.meas tran vdout1_106ck1870 FIND v(dout1_106) AT=940.025n

.meas tran vdout1_107ck1870 FIND v(dout1_107) AT=940.025n

.meas tran vdout1_108ck1870 FIND v(dout1_108) AT=940.025n

.meas tran vdout1_109ck1870 FIND v(dout1_109) AT=940.025n

.meas tran vdout1_110ck1870 FIND v(dout1_110) AT=940.025n

.meas tran vdout1_111ck1870 FIND v(dout1_111) AT=940.025n

.meas tran vdout1_112ck1870 FIND v(dout1_112) AT=940.025n

.meas tran vdout1_113ck1870 FIND v(dout1_113) AT=940.025n

.meas tran vdout1_114ck1870 FIND v(dout1_114) AT=940.025n

.meas tran vdout1_115ck1870 FIND v(dout1_115) AT=940.025n

.meas tran vdout1_116ck1870 FIND v(dout1_116) AT=940.025n

.meas tran vdout1_117ck1870 FIND v(dout1_117) AT=940.025n

.meas tran vdout1_118ck1870 FIND v(dout1_118) AT=940.025n

.meas tran vdout1_119ck1870 FIND v(dout1_119) AT=940.025n

.meas tran vdout1_120ck1870 FIND v(dout1_120) AT=940.025n

.meas tran vdout1_121ck1870 FIND v(dout1_121) AT=940.025n

.meas tran vdout1_122ck1870 FIND v(dout1_122) AT=940.025n

.meas tran vdout1_123ck1870 FIND v(dout1_123) AT=940.025n

.meas tran vdout1_124ck1870 FIND v(dout1_124) AT=940.025n

.meas tran vdout1_125ck1870 FIND v(dout1_125) AT=940.025n

.meas tran vdout1_126ck1870 FIND v(dout1_126) AT=940.025n

.meas tran vdout1_127ck1870 FIND v(dout1_127) AT=940.025n

.meas tran vdout1_0ck1900 FIND v(dout1_0) AT=955.025n

.meas tran vdout1_1ck1900 FIND v(dout1_1) AT=955.025n

.meas tran vdout1_2ck1900 FIND v(dout1_2) AT=955.025n

.meas tran vdout1_3ck1900 FIND v(dout1_3) AT=955.025n

.meas tran vdout1_4ck1900 FIND v(dout1_4) AT=955.025n

.meas tran vdout1_5ck1900 FIND v(dout1_5) AT=955.025n

.meas tran vdout1_6ck1900 FIND v(dout1_6) AT=955.025n

.meas tran vdout1_7ck1900 FIND v(dout1_7) AT=955.025n

.meas tran vdout1_8ck1900 FIND v(dout1_8) AT=955.025n

.meas tran vdout1_9ck1900 FIND v(dout1_9) AT=955.025n

.meas tran vdout1_10ck1900 FIND v(dout1_10) AT=955.025n

.meas tran vdout1_11ck1900 FIND v(dout1_11) AT=955.025n

.meas tran vdout1_12ck1900 FIND v(dout1_12) AT=955.025n

.meas tran vdout1_13ck1900 FIND v(dout1_13) AT=955.025n

.meas tran vdout1_14ck1900 FIND v(dout1_14) AT=955.025n

.meas tran vdout1_15ck1900 FIND v(dout1_15) AT=955.025n

.meas tran vdout1_16ck1900 FIND v(dout1_16) AT=955.025n

.meas tran vdout1_17ck1900 FIND v(dout1_17) AT=955.025n

.meas tran vdout1_18ck1900 FIND v(dout1_18) AT=955.025n

.meas tran vdout1_19ck1900 FIND v(dout1_19) AT=955.025n

.meas tran vdout1_20ck1900 FIND v(dout1_20) AT=955.025n

.meas tran vdout1_21ck1900 FIND v(dout1_21) AT=955.025n

.meas tran vdout1_22ck1900 FIND v(dout1_22) AT=955.025n

.meas tran vdout1_23ck1900 FIND v(dout1_23) AT=955.025n

.meas tran vdout1_24ck1900 FIND v(dout1_24) AT=955.025n

.meas tran vdout1_25ck1900 FIND v(dout1_25) AT=955.025n

.meas tran vdout1_26ck1900 FIND v(dout1_26) AT=955.025n

.meas tran vdout1_27ck1900 FIND v(dout1_27) AT=955.025n

.meas tran vdout1_28ck1900 FIND v(dout1_28) AT=955.025n

.meas tran vdout1_29ck1900 FIND v(dout1_29) AT=955.025n

.meas tran vdout1_30ck1900 FIND v(dout1_30) AT=955.025n

.meas tran vdout1_31ck1900 FIND v(dout1_31) AT=955.025n

.meas tran vdout1_32ck1900 FIND v(dout1_32) AT=955.025n

.meas tran vdout1_33ck1900 FIND v(dout1_33) AT=955.025n

.meas tran vdout1_34ck1900 FIND v(dout1_34) AT=955.025n

.meas tran vdout1_35ck1900 FIND v(dout1_35) AT=955.025n

.meas tran vdout1_36ck1900 FIND v(dout1_36) AT=955.025n

.meas tran vdout1_37ck1900 FIND v(dout1_37) AT=955.025n

.meas tran vdout1_38ck1900 FIND v(dout1_38) AT=955.025n

.meas tran vdout1_39ck1900 FIND v(dout1_39) AT=955.025n

.meas tran vdout1_40ck1900 FIND v(dout1_40) AT=955.025n

.meas tran vdout1_41ck1900 FIND v(dout1_41) AT=955.025n

.meas tran vdout1_42ck1900 FIND v(dout1_42) AT=955.025n

.meas tran vdout1_43ck1900 FIND v(dout1_43) AT=955.025n

.meas tran vdout1_44ck1900 FIND v(dout1_44) AT=955.025n

.meas tran vdout1_45ck1900 FIND v(dout1_45) AT=955.025n

.meas tran vdout1_46ck1900 FIND v(dout1_46) AT=955.025n

.meas tran vdout1_47ck1900 FIND v(dout1_47) AT=955.025n

.meas tran vdout1_48ck1900 FIND v(dout1_48) AT=955.025n

.meas tran vdout1_49ck1900 FIND v(dout1_49) AT=955.025n

.meas tran vdout1_50ck1900 FIND v(dout1_50) AT=955.025n

.meas tran vdout1_51ck1900 FIND v(dout1_51) AT=955.025n

.meas tran vdout1_52ck1900 FIND v(dout1_52) AT=955.025n

.meas tran vdout1_53ck1900 FIND v(dout1_53) AT=955.025n

.meas tran vdout1_54ck1900 FIND v(dout1_54) AT=955.025n

.meas tran vdout1_55ck1900 FIND v(dout1_55) AT=955.025n

.meas tran vdout1_56ck1900 FIND v(dout1_56) AT=955.025n

.meas tran vdout1_57ck1900 FIND v(dout1_57) AT=955.025n

.meas tran vdout1_58ck1900 FIND v(dout1_58) AT=955.025n

.meas tran vdout1_59ck1900 FIND v(dout1_59) AT=955.025n

.meas tran vdout1_60ck1900 FIND v(dout1_60) AT=955.025n

.meas tran vdout1_61ck1900 FIND v(dout1_61) AT=955.025n

.meas tran vdout1_62ck1900 FIND v(dout1_62) AT=955.025n

.meas tran vdout1_63ck1900 FIND v(dout1_63) AT=955.025n

.meas tran vdout1_64ck1900 FIND v(dout1_64) AT=955.025n

.meas tran vdout1_65ck1900 FIND v(dout1_65) AT=955.025n

.meas tran vdout1_66ck1900 FIND v(dout1_66) AT=955.025n

.meas tran vdout1_67ck1900 FIND v(dout1_67) AT=955.025n

.meas tran vdout1_68ck1900 FIND v(dout1_68) AT=955.025n

.meas tran vdout1_69ck1900 FIND v(dout1_69) AT=955.025n

.meas tran vdout1_70ck1900 FIND v(dout1_70) AT=955.025n

.meas tran vdout1_71ck1900 FIND v(dout1_71) AT=955.025n

.meas tran vdout1_72ck1900 FIND v(dout1_72) AT=955.025n

.meas tran vdout1_73ck1900 FIND v(dout1_73) AT=955.025n

.meas tran vdout1_74ck1900 FIND v(dout1_74) AT=955.025n

.meas tran vdout1_75ck1900 FIND v(dout1_75) AT=955.025n

.meas tran vdout1_76ck1900 FIND v(dout1_76) AT=955.025n

.meas tran vdout1_77ck1900 FIND v(dout1_77) AT=955.025n

.meas tran vdout1_78ck1900 FIND v(dout1_78) AT=955.025n

.meas tran vdout1_79ck1900 FIND v(dout1_79) AT=955.025n

.meas tran vdout1_80ck1900 FIND v(dout1_80) AT=955.025n

.meas tran vdout1_81ck1900 FIND v(dout1_81) AT=955.025n

.meas tran vdout1_82ck1900 FIND v(dout1_82) AT=955.025n

.meas tran vdout1_83ck1900 FIND v(dout1_83) AT=955.025n

.meas tran vdout1_84ck1900 FIND v(dout1_84) AT=955.025n

.meas tran vdout1_85ck1900 FIND v(dout1_85) AT=955.025n

.meas tran vdout1_86ck1900 FIND v(dout1_86) AT=955.025n

.meas tran vdout1_87ck1900 FIND v(dout1_87) AT=955.025n

.meas tran vdout1_88ck1900 FIND v(dout1_88) AT=955.025n

.meas tran vdout1_89ck1900 FIND v(dout1_89) AT=955.025n

.meas tran vdout1_90ck1900 FIND v(dout1_90) AT=955.025n

.meas tran vdout1_91ck1900 FIND v(dout1_91) AT=955.025n

.meas tran vdout1_92ck1900 FIND v(dout1_92) AT=955.025n

.meas tran vdout1_93ck1900 FIND v(dout1_93) AT=955.025n

.meas tran vdout1_94ck1900 FIND v(dout1_94) AT=955.025n

.meas tran vdout1_95ck1900 FIND v(dout1_95) AT=955.025n

.meas tran vdout1_96ck1900 FIND v(dout1_96) AT=955.025n

.meas tran vdout1_97ck1900 FIND v(dout1_97) AT=955.025n

.meas tran vdout1_98ck1900 FIND v(dout1_98) AT=955.025n

.meas tran vdout1_99ck1900 FIND v(dout1_99) AT=955.025n

.meas tran vdout1_100ck1900 FIND v(dout1_100) AT=955.025n

.meas tran vdout1_101ck1900 FIND v(dout1_101) AT=955.025n

.meas tran vdout1_102ck1900 FIND v(dout1_102) AT=955.025n

.meas tran vdout1_103ck1900 FIND v(dout1_103) AT=955.025n

.meas tran vdout1_104ck1900 FIND v(dout1_104) AT=955.025n

.meas tran vdout1_105ck1900 FIND v(dout1_105) AT=955.025n

.meas tran vdout1_106ck1900 FIND v(dout1_106) AT=955.025n

.meas tran vdout1_107ck1900 FIND v(dout1_107) AT=955.025n

.meas tran vdout1_108ck1900 FIND v(dout1_108) AT=955.025n

.meas tran vdout1_109ck1900 FIND v(dout1_109) AT=955.025n

.meas tran vdout1_110ck1900 FIND v(dout1_110) AT=955.025n

.meas tran vdout1_111ck1900 FIND v(dout1_111) AT=955.025n

.meas tran vdout1_112ck1900 FIND v(dout1_112) AT=955.025n

.meas tran vdout1_113ck1900 FIND v(dout1_113) AT=955.025n

.meas tran vdout1_114ck1900 FIND v(dout1_114) AT=955.025n

.meas tran vdout1_115ck1900 FIND v(dout1_115) AT=955.025n

.meas tran vdout1_116ck1900 FIND v(dout1_116) AT=955.025n

.meas tran vdout1_117ck1900 FIND v(dout1_117) AT=955.025n

.meas tran vdout1_118ck1900 FIND v(dout1_118) AT=955.025n

.meas tran vdout1_119ck1900 FIND v(dout1_119) AT=955.025n

.meas tran vdout1_120ck1900 FIND v(dout1_120) AT=955.025n

.meas tran vdout1_121ck1900 FIND v(dout1_121) AT=955.025n

.meas tran vdout1_122ck1900 FIND v(dout1_122) AT=955.025n

.meas tran vdout1_123ck1900 FIND v(dout1_123) AT=955.025n

.meas tran vdout1_124ck1900 FIND v(dout1_124) AT=955.025n

.meas tran vdout1_125ck1900 FIND v(dout1_125) AT=955.025n

.meas tran vdout1_126ck1900 FIND v(dout1_126) AT=955.025n

.meas tran vdout1_127ck1900 FIND v(dout1_127) AT=955.025n

.meas tran vdout1_0ck1910 FIND v(dout1_0) AT=960.025n

.meas tran vdout1_1ck1910 FIND v(dout1_1) AT=960.025n

.meas tran vdout1_2ck1910 FIND v(dout1_2) AT=960.025n

.meas tran vdout1_3ck1910 FIND v(dout1_3) AT=960.025n

.meas tran vdout1_4ck1910 FIND v(dout1_4) AT=960.025n

.meas tran vdout1_5ck1910 FIND v(dout1_5) AT=960.025n

.meas tran vdout1_6ck1910 FIND v(dout1_6) AT=960.025n

.meas tran vdout1_7ck1910 FIND v(dout1_7) AT=960.025n

.meas tran vdout1_8ck1910 FIND v(dout1_8) AT=960.025n

.meas tran vdout1_9ck1910 FIND v(dout1_9) AT=960.025n

.meas tran vdout1_10ck1910 FIND v(dout1_10) AT=960.025n

.meas tran vdout1_11ck1910 FIND v(dout1_11) AT=960.025n

.meas tran vdout1_12ck1910 FIND v(dout1_12) AT=960.025n

.meas tran vdout1_13ck1910 FIND v(dout1_13) AT=960.025n

.meas tran vdout1_14ck1910 FIND v(dout1_14) AT=960.025n

.meas tran vdout1_15ck1910 FIND v(dout1_15) AT=960.025n

.meas tran vdout1_16ck1910 FIND v(dout1_16) AT=960.025n

.meas tran vdout1_17ck1910 FIND v(dout1_17) AT=960.025n

.meas tran vdout1_18ck1910 FIND v(dout1_18) AT=960.025n

.meas tran vdout1_19ck1910 FIND v(dout1_19) AT=960.025n

.meas tran vdout1_20ck1910 FIND v(dout1_20) AT=960.025n

.meas tran vdout1_21ck1910 FIND v(dout1_21) AT=960.025n

.meas tran vdout1_22ck1910 FIND v(dout1_22) AT=960.025n

.meas tran vdout1_23ck1910 FIND v(dout1_23) AT=960.025n

.meas tran vdout1_24ck1910 FIND v(dout1_24) AT=960.025n

.meas tran vdout1_25ck1910 FIND v(dout1_25) AT=960.025n

.meas tran vdout1_26ck1910 FIND v(dout1_26) AT=960.025n

.meas tran vdout1_27ck1910 FIND v(dout1_27) AT=960.025n

.meas tran vdout1_28ck1910 FIND v(dout1_28) AT=960.025n

.meas tran vdout1_29ck1910 FIND v(dout1_29) AT=960.025n

.meas tran vdout1_30ck1910 FIND v(dout1_30) AT=960.025n

.meas tran vdout1_31ck1910 FIND v(dout1_31) AT=960.025n

.meas tran vdout1_32ck1910 FIND v(dout1_32) AT=960.025n

.meas tran vdout1_33ck1910 FIND v(dout1_33) AT=960.025n

.meas tran vdout1_34ck1910 FIND v(dout1_34) AT=960.025n

.meas tran vdout1_35ck1910 FIND v(dout1_35) AT=960.025n

.meas tran vdout1_36ck1910 FIND v(dout1_36) AT=960.025n

.meas tran vdout1_37ck1910 FIND v(dout1_37) AT=960.025n

.meas tran vdout1_38ck1910 FIND v(dout1_38) AT=960.025n

.meas tran vdout1_39ck1910 FIND v(dout1_39) AT=960.025n

.meas tran vdout1_40ck1910 FIND v(dout1_40) AT=960.025n

.meas tran vdout1_41ck1910 FIND v(dout1_41) AT=960.025n

.meas tran vdout1_42ck1910 FIND v(dout1_42) AT=960.025n

.meas tran vdout1_43ck1910 FIND v(dout1_43) AT=960.025n

.meas tran vdout1_44ck1910 FIND v(dout1_44) AT=960.025n

.meas tran vdout1_45ck1910 FIND v(dout1_45) AT=960.025n

.meas tran vdout1_46ck1910 FIND v(dout1_46) AT=960.025n

.meas tran vdout1_47ck1910 FIND v(dout1_47) AT=960.025n

.meas tran vdout1_48ck1910 FIND v(dout1_48) AT=960.025n

.meas tran vdout1_49ck1910 FIND v(dout1_49) AT=960.025n

.meas tran vdout1_50ck1910 FIND v(dout1_50) AT=960.025n

.meas tran vdout1_51ck1910 FIND v(dout1_51) AT=960.025n

.meas tran vdout1_52ck1910 FIND v(dout1_52) AT=960.025n

.meas tran vdout1_53ck1910 FIND v(dout1_53) AT=960.025n

.meas tran vdout1_54ck1910 FIND v(dout1_54) AT=960.025n

.meas tran vdout1_55ck1910 FIND v(dout1_55) AT=960.025n

.meas tran vdout1_56ck1910 FIND v(dout1_56) AT=960.025n

.meas tran vdout1_57ck1910 FIND v(dout1_57) AT=960.025n

.meas tran vdout1_58ck1910 FIND v(dout1_58) AT=960.025n

.meas tran vdout1_59ck1910 FIND v(dout1_59) AT=960.025n

.meas tran vdout1_60ck1910 FIND v(dout1_60) AT=960.025n

.meas tran vdout1_61ck1910 FIND v(dout1_61) AT=960.025n

.meas tran vdout1_62ck1910 FIND v(dout1_62) AT=960.025n

.meas tran vdout1_63ck1910 FIND v(dout1_63) AT=960.025n

.meas tran vdout1_64ck1910 FIND v(dout1_64) AT=960.025n

.meas tran vdout1_65ck1910 FIND v(dout1_65) AT=960.025n

.meas tran vdout1_66ck1910 FIND v(dout1_66) AT=960.025n

.meas tran vdout1_67ck1910 FIND v(dout1_67) AT=960.025n

.meas tran vdout1_68ck1910 FIND v(dout1_68) AT=960.025n

.meas tran vdout1_69ck1910 FIND v(dout1_69) AT=960.025n

.meas tran vdout1_70ck1910 FIND v(dout1_70) AT=960.025n

.meas tran vdout1_71ck1910 FIND v(dout1_71) AT=960.025n

.meas tran vdout1_72ck1910 FIND v(dout1_72) AT=960.025n

.meas tran vdout1_73ck1910 FIND v(dout1_73) AT=960.025n

.meas tran vdout1_74ck1910 FIND v(dout1_74) AT=960.025n

.meas tran vdout1_75ck1910 FIND v(dout1_75) AT=960.025n

.meas tran vdout1_76ck1910 FIND v(dout1_76) AT=960.025n

.meas tran vdout1_77ck1910 FIND v(dout1_77) AT=960.025n

.meas tran vdout1_78ck1910 FIND v(dout1_78) AT=960.025n

.meas tran vdout1_79ck1910 FIND v(dout1_79) AT=960.025n

.meas tran vdout1_80ck1910 FIND v(dout1_80) AT=960.025n

.meas tran vdout1_81ck1910 FIND v(dout1_81) AT=960.025n

.meas tran vdout1_82ck1910 FIND v(dout1_82) AT=960.025n

.meas tran vdout1_83ck1910 FIND v(dout1_83) AT=960.025n

.meas tran vdout1_84ck1910 FIND v(dout1_84) AT=960.025n

.meas tran vdout1_85ck1910 FIND v(dout1_85) AT=960.025n

.meas tran vdout1_86ck1910 FIND v(dout1_86) AT=960.025n

.meas tran vdout1_87ck1910 FIND v(dout1_87) AT=960.025n

.meas tran vdout1_88ck1910 FIND v(dout1_88) AT=960.025n

.meas tran vdout1_89ck1910 FIND v(dout1_89) AT=960.025n

.meas tran vdout1_90ck1910 FIND v(dout1_90) AT=960.025n

.meas tran vdout1_91ck1910 FIND v(dout1_91) AT=960.025n

.meas tran vdout1_92ck1910 FIND v(dout1_92) AT=960.025n

.meas tran vdout1_93ck1910 FIND v(dout1_93) AT=960.025n

.meas tran vdout1_94ck1910 FIND v(dout1_94) AT=960.025n

.meas tran vdout1_95ck1910 FIND v(dout1_95) AT=960.025n

.meas tran vdout1_96ck1910 FIND v(dout1_96) AT=960.025n

.meas tran vdout1_97ck1910 FIND v(dout1_97) AT=960.025n

.meas tran vdout1_98ck1910 FIND v(dout1_98) AT=960.025n

.meas tran vdout1_99ck1910 FIND v(dout1_99) AT=960.025n

.meas tran vdout1_100ck1910 FIND v(dout1_100) AT=960.025n

.meas tran vdout1_101ck1910 FIND v(dout1_101) AT=960.025n

.meas tran vdout1_102ck1910 FIND v(dout1_102) AT=960.025n

.meas tran vdout1_103ck1910 FIND v(dout1_103) AT=960.025n

.meas tran vdout1_104ck1910 FIND v(dout1_104) AT=960.025n

.meas tran vdout1_105ck1910 FIND v(dout1_105) AT=960.025n

.meas tran vdout1_106ck1910 FIND v(dout1_106) AT=960.025n

.meas tran vdout1_107ck1910 FIND v(dout1_107) AT=960.025n

.meas tran vdout1_108ck1910 FIND v(dout1_108) AT=960.025n

.meas tran vdout1_109ck1910 FIND v(dout1_109) AT=960.025n

.meas tran vdout1_110ck1910 FIND v(dout1_110) AT=960.025n

.meas tran vdout1_111ck1910 FIND v(dout1_111) AT=960.025n

.meas tran vdout1_112ck1910 FIND v(dout1_112) AT=960.025n

.meas tran vdout1_113ck1910 FIND v(dout1_113) AT=960.025n

.meas tran vdout1_114ck1910 FIND v(dout1_114) AT=960.025n

.meas tran vdout1_115ck1910 FIND v(dout1_115) AT=960.025n

.meas tran vdout1_116ck1910 FIND v(dout1_116) AT=960.025n

.meas tran vdout1_117ck1910 FIND v(dout1_117) AT=960.025n

.meas tran vdout1_118ck1910 FIND v(dout1_118) AT=960.025n

.meas tran vdout1_119ck1910 FIND v(dout1_119) AT=960.025n

.meas tran vdout1_120ck1910 FIND v(dout1_120) AT=960.025n

.meas tran vdout1_121ck1910 FIND v(dout1_121) AT=960.025n

.meas tran vdout1_122ck1910 FIND v(dout1_122) AT=960.025n

.meas tran vdout1_123ck1910 FIND v(dout1_123) AT=960.025n

.meas tran vdout1_124ck1910 FIND v(dout1_124) AT=960.025n

.meas tran vdout1_125ck1910 FIND v(dout1_125) AT=960.025n

.meas tran vdout1_126ck1910 FIND v(dout1_126) AT=960.025n

.meas tran vdout1_127ck1910 FIND v(dout1_127) AT=960.025n

.meas tran vdout1_0ck1920 FIND v(dout1_0) AT=965.025n

.meas tran vdout1_1ck1920 FIND v(dout1_1) AT=965.025n

.meas tran vdout1_2ck1920 FIND v(dout1_2) AT=965.025n

.meas tran vdout1_3ck1920 FIND v(dout1_3) AT=965.025n

.meas tran vdout1_4ck1920 FIND v(dout1_4) AT=965.025n

.meas tran vdout1_5ck1920 FIND v(dout1_5) AT=965.025n

.meas tran vdout1_6ck1920 FIND v(dout1_6) AT=965.025n

.meas tran vdout1_7ck1920 FIND v(dout1_7) AT=965.025n

.meas tran vdout1_8ck1920 FIND v(dout1_8) AT=965.025n

.meas tran vdout1_9ck1920 FIND v(dout1_9) AT=965.025n

.meas tran vdout1_10ck1920 FIND v(dout1_10) AT=965.025n

.meas tran vdout1_11ck1920 FIND v(dout1_11) AT=965.025n

.meas tran vdout1_12ck1920 FIND v(dout1_12) AT=965.025n

.meas tran vdout1_13ck1920 FIND v(dout1_13) AT=965.025n

.meas tran vdout1_14ck1920 FIND v(dout1_14) AT=965.025n

.meas tran vdout1_15ck1920 FIND v(dout1_15) AT=965.025n

.meas tran vdout1_16ck1920 FIND v(dout1_16) AT=965.025n

.meas tran vdout1_17ck1920 FIND v(dout1_17) AT=965.025n

.meas tran vdout1_18ck1920 FIND v(dout1_18) AT=965.025n

.meas tran vdout1_19ck1920 FIND v(dout1_19) AT=965.025n

.meas tran vdout1_20ck1920 FIND v(dout1_20) AT=965.025n

.meas tran vdout1_21ck1920 FIND v(dout1_21) AT=965.025n

.meas tran vdout1_22ck1920 FIND v(dout1_22) AT=965.025n

.meas tran vdout1_23ck1920 FIND v(dout1_23) AT=965.025n

.meas tran vdout1_24ck1920 FIND v(dout1_24) AT=965.025n

.meas tran vdout1_25ck1920 FIND v(dout1_25) AT=965.025n

.meas tran vdout1_26ck1920 FIND v(dout1_26) AT=965.025n

.meas tran vdout1_27ck1920 FIND v(dout1_27) AT=965.025n

.meas tran vdout1_28ck1920 FIND v(dout1_28) AT=965.025n

.meas tran vdout1_29ck1920 FIND v(dout1_29) AT=965.025n

.meas tran vdout1_30ck1920 FIND v(dout1_30) AT=965.025n

.meas tran vdout1_31ck1920 FIND v(dout1_31) AT=965.025n

.meas tran vdout1_32ck1920 FIND v(dout1_32) AT=965.025n

.meas tran vdout1_33ck1920 FIND v(dout1_33) AT=965.025n

.meas tran vdout1_34ck1920 FIND v(dout1_34) AT=965.025n

.meas tran vdout1_35ck1920 FIND v(dout1_35) AT=965.025n

.meas tran vdout1_36ck1920 FIND v(dout1_36) AT=965.025n

.meas tran vdout1_37ck1920 FIND v(dout1_37) AT=965.025n

.meas tran vdout1_38ck1920 FIND v(dout1_38) AT=965.025n

.meas tran vdout1_39ck1920 FIND v(dout1_39) AT=965.025n

.meas tran vdout1_40ck1920 FIND v(dout1_40) AT=965.025n

.meas tran vdout1_41ck1920 FIND v(dout1_41) AT=965.025n

.meas tran vdout1_42ck1920 FIND v(dout1_42) AT=965.025n

.meas tran vdout1_43ck1920 FIND v(dout1_43) AT=965.025n

.meas tran vdout1_44ck1920 FIND v(dout1_44) AT=965.025n

.meas tran vdout1_45ck1920 FIND v(dout1_45) AT=965.025n

.meas tran vdout1_46ck1920 FIND v(dout1_46) AT=965.025n

.meas tran vdout1_47ck1920 FIND v(dout1_47) AT=965.025n

.meas tran vdout1_48ck1920 FIND v(dout1_48) AT=965.025n

.meas tran vdout1_49ck1920 FIND v(dout1_49) AT=965.025n

.meas tran vdout1_50ck1920 FIND v(dout1_50) AT=965.025n

.meas tran vdout1_51ck1920 FIND v(dout1_51) AT=965.025n

.meas tran vdout1_52ck1920 FIND v(dout1_52) AT=965.025n

.meas tran vdout1_53ck1920 FIND v(dout1_53) AT=965.025n

.meas tran vdout1_54ck1920 FIND v(dout1_54) AT=965.025n

.meas tran vdout1_55ck1920 FIND v(dout1_55) AT=965.025n

.meas tran vdout1_56ck1920 FIND v(dout1_56) AT=965.025n

.meas tran vdout1_57ck1920 FIND v(dout1_57) AT=965.025n

.meas tran vdout1_58ck1920 FIND v(dout1_58) AT=965.025n

.meas tran vdout1_59ck1920 FIND v(dout1_59) AT=965.025n

.meas tran vdout1_60ck1920 FIND v(dout1_60) AT=965.025n

.meas tran vdout1_61ck1920 FIND v(dout1_61) AT=965.025n

.meas tran vdout1_62ck1920 FIND v(dout1_62) AT=965.025n

.meas tran vdout1_63ck1920 FIND v(dout1_63) AT=965.025n

.meas tran vdout1_64ck1920 FIND v(dout1_64) AT=965.025n

.meas tran vdout1_65ck1920 FIND v(dout1_65) AT=965.025n

.meas tran vdout1_66ck1920 FIND v(dout1_66) AT=965.025n

.meas tran vdout1_67ck1920 FIND v(dout1_67) AT=965.025n

.meas tran vdout1_68ck1920 FIND v(dout1_68) AT=965.025n

.meas tran vdout1_69ck1920 FIND v(dout1_69) AT=965.025n

.meas tran vdout1_70ck1920 FIND v(dout1_70) AT=965.025n

.meas tran vdout1_71ck1920 FIND v(dout1_71) AT=965.025n

.meas tran vdout1_72ck1920 FIND v(dout1_72) AT=965.025n

.meas tran vdout1_73ck1920 FIND v(dout1_73) AT=965.025n

.meas tran vdout1_74ck1920 FIND v(dout1_74) AT=965.025n

.meas tran vdout1_75ck1920 FIND v(dout1_75) AT=965.025n

.meas tran vdout1_76ck1920 FIND v(dout1_76) AT=965.025n

.meas tran vdout1_77ck1920 FIND v(dout1_77) AT=965.025n

.meas tran vdout1_78ck1920 FIND v(dout1_78) AT=965.025n

.meas tran vdout1_79ck1920 FIND v(dout1_79) AT=965.025n

.meas tran vdout1_80ck1920 FIND v(dout1_80) AT=965.025n

.meas tran vdout1_81ck1920 FIND v(dout1_81) AT=965.025n

.meas tran vdout1_82ck1920 FIND v(dout1_82) AT=965.025n

.meas tran vdout1_83ck1920 FIND v(dout1_83) AT=965.025n

.meas tran vdout1_84ck1920 FIND v(dout1_84) AT=965.025n

.meas tran vdout1_85ck1920 FIND v(dout1_85) AT=965.025n

.meas tran vdout1_86ck1920 FIND v(dout1_86) AT=965.025n

.meas tran vdout1_87ck1920 FIND v(dout1_87) AT=965.025n

.meas tran vdout1_88ck1920 FIND v(dout1_88) AT=965.025n

.meas tran vdout1_89ck1920 FIND v(dout1_89) AT=965.025n

.meas tran vdout1_90ck1920 FIND v(dout1_90) AT=965.025n

.meas tran vdout1_91ck1920 FIND v(dout1_91) AT=965.025n

.meas tran vdout1_92ck1920 FIND v(dout1_92) AT=965.025n

.meas tran vdout1_93ck1920 FIND v(dout1_93) AT=965.025n

.meas tran vdout1_94ck1920 FIND v(dout1_94) AT=965.025n

.meas tran vdout1_95ck1920 FIND v(dout1_95) AT=965.025n

.meas tran vdout1_96ck1920 FIND v(dout1_96) AT=965.025n

.meas tran vdout1_97ck1920 FIND v(dout1_97) AT=965.025n

.meas tran vdout1_98ck1920 FIND v(dout1_98) AT=965.025n

.meas tran vdout1_99ck1920 FIND v(dout1_99) AT=965.025n

.meas tran vdout1_100ck1920 FIND v(dout1_100) AT=965.025n

.meas tran vdout1_101ck1920 FIND v(dout1_101) AT=965.025n

.meas tran vdout1_102ck1920 FIND v(dout1_102) AT=965.025n

.meas tran vdout1_103ck1920 FIND v(dout1_103) AT=965.025n

.meas tran vdout1_104ck1920 FIND v(dout1_104) AT=965.025n

.meas tran vdout1_105ck1920 FIND v(dout1_105) AT=965.025n

.meas tran vdout1_106ck1920 FIND v(dout1_106) AT=965.025n

.meas tran vdout1_107ck1920 FIND v(dout1_107) AT=965.025n

.meas tran vdout1_108ck1920 FIND v(dout1_108) AT=965.025n

.meas tran vdout1_109ck1920 FIND v(dout1_109) AT=965.025n

.meas tran vdout1_110ck1920 FIND v(dout1_110) AT=965.025n

.meas tran vdout1_111ck1920 FIND v(dout1_111) AT=965.025n

.meas tran vdout1_112ck1920 FIND v(dout1_112) AT=965.025n

.meas tran vdout1_113ck1920 FIND v(dout1_113) AT=965.025n

.meas tran vdout1_114ck1920 FIND v(dout1_114) AT=965.025n

.meas tran vdout1_115ck1920 FIND v(dout1_115) AT=965.025n

.meas tran vdout1_116ck1920 FIND v(dout1_116) AT=965.025n

.meas tran vdout1_117ck1920 FIND v(dout1_117) AT=965.025n

.meas tran vdout1_118ck1920 FIND v(dout1_118) AT=965.025n

.meas tran vdout1_119ck1920 FIND v(dout1_119) AT=965.025n

.meas tran vdout1_120ck1920 FIND v(dout1_120) AT=965.025n

.meas tran vdout1_121ck1920 FIND v(dout1_121) AT=965.025n

.meas tran vdout1_122ck1920 FIND v(dout1_122) AT=965.025n

.meas tran vdout1_123ck1920 FIND v(dout1_123) AT=965.025n

.meas tran vdout1_124ck1920 FIND v(dout1_124) AT=965.025n

.meas tran vdout1_125ck1920 FIND v(dout1_125) AT=965.025n

.meas tran vdout1_126ck1920 FIND v(dout1_126) AT=965.025n

.meas tran vdout1_127ck1920 FIND v(dout1_127) AT=965.025n

.meas tran vdout1_0ck1940 FIND v(dout1_0) AT=975.025n

.meas tran vdout1_1ck1940 FIND v(dout1_1) AT=975.025n

.meas tran vdout1_2ck1940 FIND v(dout1_2) AT=975.025n

.meas tran vdout1_3ck1940 FIND v(dout1_3) AT=975.025n

.meas tran vdout1_4ck1940 FIND v(dout1_4) AT=975.025n

.meas tran vdout1_5ck1940 FIND v(dout1_5) AT=975.025n

.meas tran vdout1_6ck1940 FIND v(dout1_6) AT=975.025n

.meas tran vdout1_7ck1940 FIND v(dout1_7) AT=975.025n

.meas tran vdout1_8ck1940 FIND v(dout1_8) AT=975.025n

.meas tran vdout1_9ck1940 FIND v(dout1_9) AT=975.025n

.meas tran vdout1_10ck1940 FIND v(dout1_10) AT=975.025n

.meas tran vdout1_11ck1940 FIND v(dout1_11) AT=975.025n

.meas tran vdout1_12ck1940 FIND v(dout1_12) AT=975.025n

.meas tran vdout1_13ck1940 FIND v(dout1_13) AT=975.025n

.meas tran vdout1_14ck1940 FIND v(dout1_14) AT=975.025n

.meas tran vdout1_15ck1940 FIND v(dout1_15) AT=975.025n

.meas tran vdout1_16ck1940 FIND v(dout1_16) AT=975.025n

.meas tran vdout1_17ck1940 FIND v(dout1_17) AT=975.025n

.meas tran vdout1_18ck1940 FIND v(dout1_18) AT=975.025n

.meas tran vdout1_19ck1940 FIND v(dout1_19) AT=975.025n

.meas tran vdout1_20ck1940 FIND v(dout1_20) AT=975.025n

.meas tran vdout1_21ck1940 FIND v(dout1_21) AT=975.025n

.meas tran vdout1_22ck1940 FIND v(dout1_22) AT=975.025n

.meas tran vdout1_23ck1940 FIND v(dout1_23) AT=975.025n

.meas tran vdout1_24ck1940 FIND v(dout1_24) AT=975.025n

.meas tran vdout1_25ck1940 FIND v(dout1_25) AT=975.025n

.meas tran vdout1_26ck1940 FIND v(dout1_26) AT=975.025n

.meas tran vdout1_27ck1940 FIND v(dout1_27) AT=975.025n

.meas tran vdout1_28ck1940 FIND v(dout1_28) AT=975.025n

.meas tran vdout1_29ck1940 FIND v(dout1_29) AT=975.025n

.meas tran vdout1_30ck1940 FIND v(dout1_30) AT=975.025n

.meas tran vdout1_31ck1940 FIND v(dout1_31) AT=975.025n

.meas tran vdout1_32ck1940 FIND v(dout1_32) AT=975.025n

.meas tran vdout1_33ck1940 FIND v(dout1_33) AT=975.025n

.meas tran vdout1_34ck1940 FIND v(dout1_34) AT=975.025n

.meas tran vdout1_35ck1940 FIND v(dout1_35) AT=975.025n

.meas tran vdout1_36ck1940 FIND v(dout1_36) AT=975.025n

.meas tran vdout1_37ck1940 FIND v(dout1_37) AT=975.025n

.meas tran vdout1_38ck1940 FIND v(dout1_38) AT=975.025n

.meas tran vdout1_39ck1940 FIND v(dout1_39) AT=975.025n

.meas tran vdout1_40ck1940 FIND v(dout1_40) AT=975.025n

.meas tran vdout1_41ck1940 FIND v(dout1_41) AT=975.025n

.meas tran vdout1_42ck1940 FIND v(dout1_42) AT=975.025n

.meas tran vdout1_43ck1940 FIND v(dout1_43) AT=975.025n

.meas tran vdout1_44ck1940 FIND v(dout1_44) AT=975.025n

.meas tran vdout1_45ck1940 FIND v(dout1_45) AT=975.025n

.meas tran vdout1_46ck1940 FIND v(dout1_46) AT=975.025n

.meas tran vdout1_47ck1940 FIND v(dout1_47) AT=975.025n

.meas tran vdout1_48ck1940 FIND v(dout1_48) AT=975.025n

.meas tran vdout1_49ck1940 FIND v(dout1_49) AT=975.025n

.meas tran vdout1_50ck1940 FIND v(dout1_50) AT=975.025n

.meas tran vdout1_51ck1940 FIND v(dout1_51) AT=975.025n

.meas tran vdout1_52ck1940 FIND v(dout1_52) AT=975.025n

.meas tran vdout1_53ck1940 FIND v(dout1_53) AT=975.025n

.meas tran vdout1_54ck1940 FIND v(dout1_54) AT=975.025n

.meas tran vdout1_55ck1940 FIND v(dout1_55) AT=975.025n

.meas tran vdout1_56ck1940 FIND v(dout1_56) AT=975.025n

.meas tran vdout1_57ck1940 FIND v(dout1_57) AT=975.025n

.meas tran vdout1_58ck1940 FIND v(dout1_58) AT=975.025n

.meas tran vdout1_59ck1940 FIND v(dout1_59) AT=975.025n

.meas tran vdout1_60ck1940 FIND v(dout1_60) AT=975.025n

.meas tran vdout1_61ck1940 FIND v(dout1_61) AT=975.025n

.meas tran vdout1_62ck1940 FIND v(dout1_62) AT=975.025n

.meas tran vdout1_63ck1940 FIND v(dout1_63) AT=975.025n

.meas tran vdout1_64ck1940 FIND v(dout1_64) AT=975.025n

.meas tran vdout1_65ck1940 FIND v(dout1_65) AT=975.025n

.meas tran vdout1_66ck1940 FIND v(dout1_66) AT=975.025n

.meas tran vdout1_67ck1940 FIND v(dout1_67) AT=975.025n

.meas tran vdout1_68ck1940 FIND v(dout1_68) AT=975.025n

.meas tran vdout1_69ck1940 FIND v(dout1_69) AT=975.025n

.meas tran vdout1_70ck1940 FIND v(dout1_70) AT=975.025n

.meas tran vdout1_71ck1940 FIND v(dout1_71) AT=975.025n

.meas tran vdout1_72ck1940 FIND v(dout1_72) AT=975.025n

.meas tran vdout1_73ck1940 FIND v(dout1_73) AT=975.025n

.meas tran vdout1_74ck1940 FIND v(dout1_74) AT=975.025n

.meas tran vdout1_75ck1940 FIND v(dout1_75) AT=975.025n

.meas tran vdout1_76ck1940 FIND v(dout1_76) AT=975.025n

.meas tran vdout1_77ck1940 FIND v(dout1_77) AT=975.025n

.meas tran vdout1_78ck1940 FIND v(dout1_78) AT=975.025n

.meas tran vdout1_79ck1940 FIND v(dout1_79) AT=975.025n

.meas tran vdout1_80ck1940 FIND v(dout1_80) AT=975.025n

.meas tran vdout1_81ck1940 FIND v(dout1_81) AT=975.025n

.meas tran vdout1_82ck1940 FIND v(dout1_82) AT=975.025n

.meas tran vdout1_83ck1940 FIND v(dout1_83) AT=975.025n

.meas tran vdout1_84ck1940 FIND v(dout1_84) AT=975.025n

.meas tran vdout1_85ck1940 FIND v(dout1_85) AT=975.025n

.meas tran vdout1_86ck1940 FIND v(dout1_86) AT=975.025n

.meas tran vdout1_87ck1940 FIND v(dout1_87) AT=975.025n

.meas tran vdout1_88ck1940 FIND v(dout1_88) AT=975.025n

.meas tran vdout1_89ck1940 FIND v(dout1_89) AT=975.025n

.meas tran vdout1_90ck1940 FIND v(dout1_90) AT=975.025n

.meas tran vdout1_91ck1940 FIND v(dout1_91) AT=975.025n

.meas tran vdout1_92ck1940 FIND v(dout1_92) AT=975.025n

.meas tran vdout1_93ck1940 FIND v(dout1_93) AT=975.025n

.meas tran vdout1_94ck1940 FIND v(dout1_94) AT=975.025n

.meas tran vdout1_95ck1940 FIND v(dout1_95) AT=975.025n

.meas tran vdout1_96ck1940 FIND v(dout1_96) AT=975.025n

.meas tran vdout1_97ck1940 FIND v(dout1_97) AT=975.025n

.meas tran vdout1_98ck1940 FIND v(dout1_98) AT=975.025n

.meas tran vdout1_99ck1940 FIND v(dout1_99) AT=975.025n

.meas tran vdout1_100ck1940 FIND v(dout1_100) AT=975.025n

.meas tran vdout1_101ck1940 FIND v(dout1_101) AT=975.025n

.meas tran vdout1_102ck1940 FIND v(dout1_102) AT=975.025n

.meas tran vdout1_103ck1940 FIND v(dout1_103) AT=975.025n

.meas tran vdout1_104ck1940 FIND v(dout1_104) AT=975.025n

.meas tran vdout1_105ck1940 FIND v(dout1_105) AT=975.025n

.meas tran vdout1_106ck1940 FIND v(dout1_106) AT=975.025n

.meas tran vdout1_107ck1940 FIND v(dout1_107) AT=975.025n

.meas tran vdout1_108ck1940 FIND v(dout1_108) AT=975.025n

.meas tran vdout1_109ck1940 FIND v(dout1_109) AT=975.025n

.meas tran vdout1_110ck1940 FIND v(dout1_110) AT=975.025n

.meas tran vdout1_111ck1940 FIND v(dout1_111) AT=975.025n

.meas tran vdout1_112ck1940 FIND v(dout1_112) AT=975.025n

.meas tran vdout1_113ck1940 FIND v(dout1_113) AT=975.025n

.meas tran vdout1_114ck1940 FIND v(dout1_114) AT=975.025n

.meas tran vdout1_115ck1940 FIND v(dout1_115) AT=975.025n

.meas tran vdout1_116ck1940 FIND v(dout1_116) AT=975.025n

.meas tran vdout1_117ck1940 FIND v(dout1_117) AT=975.025n

.meas tran vdout1_118ck1940 FIND v(dout1_118) AT=975.025n

.meas tran vdout1_119ck1940 FIND v(dout1_119) AT=975.025n

.meas tran vdout1_120ck1940 FIND v(dout1_120) AT=975.025n

.meas tran vdout1_121ck1940 FIND v(dout1_121) AT=975.025n

.meas tran vdout1_122ck1940 FIND v(dout1_122) AT=975.025n

.meas tran vdout1_123ck1940 FIND v(dout1_123) AT=975.025n

.meas tran vdout1_124ck1940 FIND v(dout1_124) AT=975.025n

.meas tran vdout1_125ck1940 FIND v(dout1_125) AT=975.025n

.meas tran vdout1_126ck1940 FIND v(dout1_126) AT=975.025n

.meas tran vdout1_127ck1940 FIND v(dout1_127) AT=975.025n

.meas tran vdout1_0ck1950 FIND v(dout1_0) AT=980.025n

.meas tran vdout1_1ck1950 FIND v(dout1_1) AT=980.025n

.meas tran vdout1_2ck1950 FIND v(dout1_2) AT=980.025n

.meas tran vdout1_3ck1950 FIND v(dout1_3) AT=980.025n

.meas tran vdout1_4ck1950 FIND v(dout1_4) AT=980.025n

.meas tran vdout1_5ck1950 FIND v(dout1_5) AT=980.025n

.meas tran vdout1_6ck1950 FIND v(dout1_6) AT=980.025n

.meas tran vdout1_7ck1950 FIND v(dout1_7) AT=980.025n

.meas tran vdout1_8ck1950 FIND v(dout1_8) AT=980.025n

.meas tran vdout1_9ck1950 FIND v(dout1_9) AT=980.025n

.meas tran vdout1_10ck1950 FIND v(dout1_10) AT=980.025n

.meas tran vdout1_11ck1950 FIND v(dout1_11) AT=980.025n

.meas tran vdout1_12ck1950 FIND v(dout1_12) AT=980.025n

.meas tran vdout1_13ck1950 FIND v(dout1_13) AT=980.025n

.meas tran vdout1_14ck1950 FIND v(dout1_14) AT=980.025n

.meas tran vdout1_15ck1950 FIND v(dout1_15) AT=980.025n

.meas tran vdout1_16ck1950 FIND v(dout1_16) AT=980.025n

.meas tran vdout1_17ck1950 FIND v(dout1_17) AT=980.025n

.meas tran vdout1_18ck1950 FIND v(dout1_18) AT=980.025n

.meas tran vdout1_19ck1950 FIND v(dout1_19) AT=980.025n

.meas tran vdout1_20ck1950 FIND v(dout1_20) AT=980.025n

.meas tran vdout1_21ck1950 FIND v(dout1_21) AT=980.025n

.meas tran vdout1_22ck1950 FIND v(dout1_22) AT=980.025n

.meas tran vdout1_23ck1950 FIND v(dout1_23) AT=980.025n

.meas tran vdout1_24ck1950 FIND v(dout1_24) AT=980.025n

.meas tran vdout1_25ck1950 FIND v(dout1_25) AT=980.025n

.meas tran vdout1_26ck1950 FIND v(dout1_26) AT=980.025n

.meas tran vdout1_27ck1950 FIND v(dout1_27) AT=980.025n

.meas tran vdout1_28ck1950 FIND v(dout1_28) AT=980.025n

.meas tran vdout1_29ck1950 FIND v(dout1_29) AT=980.025n

.meas tran vdout1_30ck1950 FIND v(dout1_30) AT=980.025n

.meas tran vdout1_31ck1950 FIND v(dout1_31) AT=980.025n

.meas tran vdout1_32ck1950 FIND v(dout1_32) AT=980.025n

.meas tran vdout1_33ck1950 FIND v(dout1_33) AT=980.025n

.meas tran vdout1_34ck1950 FIND v(dout1_34) AT=980.025n

.meas tran vdout1_35ck1950 FIND v(dout1_35) AT=980.025n

.meas tran vdout1_36ck1950 FIND v(dout1_36) AT=980.025n

.meas tran vdout1_37ck1950 FIND v(dout1_37) AT=980.025n

.meas tran vdout1_38ck1950 FIND v(dout1_38) AT=980.025n

.meas tran vdout1_39ck1950 FIND v(dout1_39) AT=980.025n

.meas tran vdout1_40ck1950 FIND v(dout1_40) AT=980.025n

.meas tran vdout1_41ck1950 FIND v(dout1_41) AT=980.025n

.meas tran vdout1_42ck1950 FIND v(dout1_42) AT=980.025n

.meas tran vdout1_43ck1950 FIND v(dout1_43) AT=980.025n

.meas tran vdout1_44ck1950 FIND v(dout1_44) AT=980.025n

.meas tran vdout1_45ck1950 FIND v(dout1_45) AT=980.025n

.meas tran vdout1_46ck1950 FIND v(dout1_46) AT=980.025n

.meas tran vdout1_47ck1950 FIND v(dout1_47) AT=980.025n

.meas tran vdout1_48ck1950 FIND v(dout1_48) AT=980.025n

.meas tran vdout1_49ck1950 FIND v(dout1_49) AT=980.025n

.meas tran vdout1_50ck1950 FIND v(dout1_50) AT=980.025n

.meas tran vdout1_51ck1950 FIND v(dout1_51) AT=980.025n

.meas tran vdout1_52ck1950 FIND v(dout1_52) AT=980.025n

.meas tran vdout1_53ck1950 FIND v(dout1_53) AT=980.025n

.meas tran vdout1_54ck1950 FIND v(dout1_54) AT=980.025n

.meas tran vdout1_55ck1950 FIND v(dout1_55) AT=980.025n

.meas tran vdout1_56ck1950 FIND v(dout1_56) AT=980.025n

.meas tran vdout1_57ck1950 FIND v(dout1_57) AT=980.025n

.meas tran vdout1_58ck1950 FIND v(dout1_58) AT=980.025n

.meas tran vdout1_59ck1950 FIND v(dout1_59) AT=980.025n

.meas tran vdout1_60ck1950 FIND v(dout1_60) AT=980.025n

.meas tran vdout1_61ck1950 FIND v(dout1_61) AT=980.025n

.meas tran vdout1_62ck1950 FIND v(dout1_62) AT=980.025n

.meas tran vdout1_63ck1950 FIND v(dout1_63) AT=980.025n

.meas tran vdout1_64ck1950 FIND v(dout1_64) AT=980.025n

.meas tran vdout1_65ck1950 FIND v(dout1_65) AT=980.025n

.meas tran vdout1_66ck1950 FIND v(dout1_66) AT=980.025n

.meas tran vdout1_67ck1950 FIND v(dout1_67) AT=980.025n

.meas tran vdout1_68ck1950 FIND v(dout1_68) AT=980.025n

.meas tran vdout1_69ck1950 FIND v(dout1_69) AT=980.025n

.meas tran vdout1_70ck1950 FIND v(dout1_70) AT=980.025n

.meas tran vdout1_71ck1950 FIND v(dout1_71) AT=980.025n

.meas tran vdout1_72ck1950 FIND v(dout1_72) AT=980.025n

.meas tran vdout1_73ck1950 FIND v(dout1_73) AT=980.025n

.meas tran vdout1_74ck1950 FIND v(dout1_74) AT=980.025n

.meas tran vdout1_75ck1950 FIND v(dout1_75) AT=980.025n

.meas tran vdout1_76ck1950 FIND v(dout1_76) AT=980.025n

.meas tran vdout1_77ck1950 FIND v(dout1_77) AT=980.025n

.meas tran vdout1_78ck1950 FIND v(dout1_78) AT=980.025n

.meas tran vdout1_79ck1950 FIND v(dout1_79) AT=980.025n

.meas tran vdout1_80ck1950 FIND v(dout1_80) AT=980.025n

.meas tran vdout1_81ck1950 FIND v(dout1_81) AT=980.025n

.meas tran vdout1_82ck1950 FIND v(dout1_82) AT=980.025n

.meas tran vdout1_83ck1950 FIND v(dout1_83) AT=980.025n

.meas tran vdout1_84ck1950 FIND v(dout1_84) AT=980.025n

.meas tran vdout1_85ck1950 FIND v(dout1_85) AT=980.025n

.meas tran vdout1_86ck1950 FIND v(dout1_86) AT=980.025n

.meas tran vdout1_87ck1950 FIND v(dout1_87) AT=980.025n

.meas tran vdout1_88ck1950 FIND v(dout1_88) AT=980.025n

.meas tran vdout1_89ck1950 FIND v(dout1_89) AT=980.025n

.meas tran vdout1_90ck1950 FIND v(dout1_90) AT=980.025n

.meas tran vdout1_91ck1950 FIND v(dout1_91) AT=980.025n

.meas tran vdout1_92ck1950 FIND v(dout1_92) AT=980.025n

.meas tran vdout1_93ck1950 FIND v(dout1_93) AT=980.025n

.meas tran vdout1_94ck1950 FIND v(dout1_94) AT=980.025n

.meas tran vdout1_95ck1950 FIND v(dout1_95) AT=980.025n

.meas tran vdout1_96ck1950 FIND v(dout1_96) AT=980.025n

.meas tran vdout1_97ck1950 FIND v(dout1_97) AT=980.025n

.meas tran vdout1_98ck1950 FIND v(dout1_98) AT=980.025n

.meas tran vdout1_99ck1950 FIND v(dout1_99) AT=980.025n

.meas tran vdout1_100ck1950 FIND v(dout1_100) AT=980.025n

.meas tran vdout1_101ck1950 FIND v(dout1_101) AT=980.025n

.meas tran vdout1_102ck1950 FIND v(dout1_102) AT=980.025n

.meas tran vdout1_103ck1950 FIND v(dout1_103) AT=980.025n

.meas tran vdout1_104ck1950 FIND v(dout1_104) AT=980.025n

.meas tran vdout1_105ck1950 FIND v(dout1_105) AT=980.025n

.meas tran vdout1_106ck1950 FIND v(dout1_106) AT=980.025n

.meas tran vdout1_107ck1950 FIND v(dout1_107) AT=980.025n

.meas tran vdout1_108ck1950 FIND v(dout1_108) AT=980.025n

.meas tran vdout1_109ck1950 FIND v(dout1_109) AT=980.025n

.meas tran vdout1_110ck1950 FIND v(dout1_110) AT=980.025n

.meas tran vdout1_111ck1950 FIND v(dout1_111) AT=980.025n

.meas tran vdout1_112ck1950 FIND v(dout1_112) AT=980.025n

.meas tran vdout1_113ck1950 FIND v(dout1_113) AT=980.025n

.meas tran vdout1_114ck1950 FIND v(dout1_114) AT=980.025n

.meas tran vdout1_115ck1950 FIND v(dout1_115) AT=980.025n

.meas tran vdout1_116ck1950 FIND v(dout1_116) AT=980.025n

.meas tran vdout1_117ck1950 FIND v(dout1_117) AT=980.025n

.meas tran vdout1_118ck1950 FIND v(dout1_118) AT=980.025n

.meas tran vdout1_119ck1950 FIND v(dout1_119) AT=980.025n

.meas tran vdout1_120ck1950 FIND v(dout1_120) AT=980.025n

.meas tran vdout1_121ck1950 FIND v(dout1_121) AT=980.025n

.meas tran vdout1_122ck1950 FIND v(dout1_122) AT=980.025n

.meas tran vdout1_123ck1950 FIND v(dout1_123) AT=980.025n

.meas tran vdout1_124ck1950 FIND v(dout1_124) AT=980.025n

.meas tran vdout1_125ck1950 FIND v(dout1_125) AT=980.025n

.meas tran vdout1_126ck1950 FIND v(dout1_126) AT=980.025n

.meas tran vdout1_127ck1950 FIND v(dout1_127) AT=980.025n
