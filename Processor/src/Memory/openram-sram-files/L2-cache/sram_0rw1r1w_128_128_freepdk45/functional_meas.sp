.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_17ck40 FIND v(dout1_17) AT=25.025n

.meas tran vdout1_18ck40 FIND v(dout1_18) AT=25.025n

.meas tran vdout1_19ck40 FIND v(dout1_19) AT=25.025n

.meas tran vdout1_20ck40 FIND v(dout1_20) AT=25.025n

.meas tran vdout1_21ck40 FIND v(dout1_21) AT=25.025n

.meas tran vdout1_22ck40 FIND v(dout1_22) AT=25.025n

.meas tran vdout1_23ck40 FIND v(dout1_23) AT=25.025n

.meas tran vdout1_24ck40 FIND v(dout1_24) AT=25.025n

.meas tran vdout1_25ck40 FIND v(dout1_25) AT=25.025n

.meas tran vdout1_26ck40 FIND v(dout1_26) AT=25.025n

.meas tran vdout1_27ck40 FIND v(dout1_27) AT=25.025n

.meas tran vdout1_28ck40 FIND v(dout1_28) AT=25.025n

.meas tran vdout1_29ck40 FIND v(dout1_29) AT=25.025n

.meas tran vdout1_30ck40 FIND v(dout1_30) AT=25.025n

.meas tran vdout1_31ck40 FIND v(dout1_31) AT=25.025n

.meas tran vdout1_32ck40 FIND v(dout1_32) AT=25.025n

.meas tran vdout1_33ck40 FIND v(dout1_33) AT=25.025n

.meas tran vdout1_34ck40 FIND v(dout1_34) AT=25.025n

.meas tran vdout1_35ck40 FIND v(dout1_35) AT=25.025n

.meas tran vdout1_36ck40 FIND v(dout1_36) AT=25.025n

.meas tran vdout1_37ck40 FIND v(dout1_37) AT=25.025n

.meas tran vdout1_38ck40 FIND v(dout1_38) AT=25.025n

.meas tran vdout1_39ck40 FIND v(dout1_39) AT=25.025n

.meas tran vdout1_40ck40 FIND v(dout1_40) AT=25.025n

.meas tran vdout1_41ck40 FIND v(dout1_41) AT=25.025n

.meas tran vdout1_42ck40 FIND v(dout1_42) AT=25.025n

.meas tran vdout1_43ck40 FIND v(dout1_43) AT=25.025n

.meas tran vdout1_44ck40 FIND v(dout1_44) AT=25.025n

.meas tran vdout1_45ck40 FIND v(dout1_45) AT=25.025n

.meas tran vdout1_46ck40 FIND v(dout1_46) AT=25.025n

.meas tran vdout1_47ck40 FIND v(dout1_47) AT=25.025n

.meas tran vdout1_48ck40 FIND v(dout1_48) AT=25.025n

.meas tran vdout1_49ck40 FIND v(dout1_49) AT=25.025n

.meas tran vdout1_50ck40 FIND v(dout1_50) AT=25.025n

.meas tran vdout1_51ck40 FIND v(dout1_51) AT=25.025n

.meas tran vdout1_52ck40 FIND v(dout1_52) AT=25.025n

.meas tran vdout1_53ck40 FIND v(dout1_53) AT=25.025n

.meas tran vdout1_54ck40 FIND v(dout1_54) AT=25.025n

.meas tran vdout1_55ck40 FIND v(dout1_55) AT=25.025n

.meas tran vdout1_56ck40 FIND v(dout1_56) AT=25.025n

.meas tran vdout1_57ck40 FIND v(dout1_57) AT=25.025n

.meas tran vdout1_58ck40 FIND v(dout1_58) AT=25.025n

.meas tran vdout1_59ck40 FIND v(dout1_59) AT=25.025n

.meas tran vdout1_60ck40 FIND v(dout1_60) AT=25.025n

.meas tran vdout1_61ck40 FIND v(dout1_61) AT=25.025n

.meas tran vdout1_62ck40 FIND v(dout1_62) AT=25.025n

.meas tran vdout1_63ck40 FIND v(dout1_63) AT=25.025n

.meas tran vdout1_64ck40 FIND v(dout1_64) AT=25.025n

.meas tran vdout1_65ck40 FIND v(dout1_65) AT=25.025n

.meas tran vdout1_66ck40 FIND v(dout1_66) AT=25.025n

.meas tran vdout1_67ck40 FIND v(dout1_67) AT=25.025n

.meas tran vdout1_68ck40 FIND v(dout1_68) AT=25.025n

.meas tran vdout1_69ck40 FIND v(dout1_69) AT=25.025n

.meas tran vdout1_70ck40 FIND v(dout1_70) AT=25.025n

.meas tran vdout1_71ck40 FIND v(dout1_71) AT=25.025n

.meas tran vdout1_72ck40 FIND v(dout1_72) AT=25.025n

.meas tran vdout1_73ck40 FIND v(dout1_73) AT=25.025n

.meas tran vdout1_74ck40 FIND v(dout1_74) AT=25.025n

.meas tran vdout1_75ck40 FIND v(dout1_75) AT=25.025n

.meas tran vdout1_76ck40 FIND v(dout1_76) AT=25.025n

.meas tran vdout1_77ck40 FIND v(dout1_77) AT=25.025n

.meas tran vdout1_78ck40 FIND v(dout1_78) AT=25.025n

.meas tran vdout1_79ck40 FIND v(dout1_79) AT=25.025n

.meas tran vdout1_80ck40 FIND v(dout1_80) AT=25.025n

.meas tran vdout1_81ck40 FIND v(dout1_81) AT=25.025n

.meas tran vdout1_82ck40 FIND v(dout1_82) AT=25.025n

.meas tran vdout1_83ck40 FIND v(dout1_83) AT=25.025n

.meas tran vdout1_84ck40 FIND v(dout1_84) AT=25.025n

.meas tran vdout1_85ck40 FIND v(dout1_85) AT=25.025n

.meas tran vdout1_86ck40 FIND v(dout1_86) AT=25.025n

.meas tran vdout1_87ck40 FIND v(dout1_87) AT=25.025n

.meas tran vdout1_88ck40 FIND v(dout1_88) AT=25.025n

.meas tran vdout1_89ck40 FIND v(dout1_89) AT=25.025n

.meas tran vdout1_90ck40 FIND v(dout1_90) AT=25.025n

.meas tran vdout1_91ck40 FIND v(dout1_91) AT=25.025n

.meas tran vdout1_92ck40 FIND v(dout1_92) AT=25.025n

.meas tran vdout1_93ck40 FIND v(dout1_93) AT=25.025n

.meas tran vdout1_94ck40 FIND v(dout1_94) AT=25.025n

.meas tran vdout1_95ck40 FIND v(dout1_95) AT=25.025n

.meas tran vdout1_96ck40 FIND v(dout1_96) AT=25.025n

.meas tran vdout1_97ck40 FIND v(dout1_97) AT=25.025n

.meas tran vdout1_98ck40 FIND v(dout1_98) AT=25.025n

.meas tran vdout1_99ck40 FIND v(dout1_99) AT=25.025n

.meas tran vdout1_100ck40 FIND v(dout1_100) AT=25.025n

.meas tran vdout1_101ck40 FIND v(dout1_101) AT=25.025n

.meas tran vdout1_102ck40 FIND v(dout1_102) AT=25.025n

.meas tran vdout1_103ck40 FIND v(dout1_103) AT=25.025n

.meas tran vdout1_104ck40 FIND v(dout1_104) AT=25.025n

.meas tran vdout1_105ck40 FIND v(dout1_105) AT=25.025n

.meas tran vdout1_106ck40 FIND v(dout1_106) AT=25.025n

.meas tran vdout1_107ck40 FIND v(dout1_107) AT=25.025n

.meas tran vdout1_108ck40 FIND v(dout1_108) AT=25.025n

.meas tran vdout1_109ck40 FIND v(dout1_109) AT=25.025n

.meas tran vdout1_110ck40 FIND v(dout1_110) AT=25.025n

.meas tran vdout1_111ck40 FIND v(dout1_111) AT=25.025n

.meas tran vdout1_112ck40 FIND v(dout1_112) AT=25.025n

.meas tran vdout1_113ck40 FIND v(dout1_113) AT=25.025n

.meas tran vdout1_114ck40 FIND v(dout1_114) AT=25.025n

.meas tran vdout1_115ck40 FIND v(dout1_115) AT=25.025n

.meas tran vdout1_116ck40 FIND v(dout1_116) AT=25.025n

.meas tran vdout1_117ck40 FIND v(dout1_117) AT=25.025n

.meas tran vdout1_118ck40 FIND v(dout1_118) AT=25.025n

.meas tran vdout1_119ck40 FIND v(dout1_119) AT=25.025n

.meas tran vdout1_120ck40 FIND v(dout1_120) AT=25.025n

.meas tran vdout1_121ck40 FIND v(dout1_121) AT=25.025n

.meas tran vdout1_122ck40 FIND v(dout1_122) AT=25.025n

.meas tran vdout1_123ck40 FIND v(dout1_123) AT=25.025n

.meas tran vdout1_124ck40 FIND v(dout1_124) AT=25.025n

.meas tran vdout1_125ck40 FIND v(dout1_125) AT=25.025n

.meas tran vdout1_126ck40 FIND v(dout1_126) AT=25.025n

.meas tran vdout1_127ck40 FIND v(dout1_127) AT=25.025n

.meas tran vdout1_0ck90 FIND v(dout1_0) AT=50.025n

.meas tran vdout1_1ck90 FIND v(dout1_1) AT=50.025n

.meas tran vdout1_2ck90 FIND v(dout1_2) AT=50.025n

.meas tran vdout1_3ck90 FIND v(dout1_3) AT=50.025n

.meas tran vdout1_4ck90 FIND v(dout1_4) AT=50.025n

.meas tran vdout1_5ck90 FIND v(dout1_5) AT=50.025n

.meas tran vdout1_6ck90 FIND v(dout1_6) AT=50.025n

.meas tran vdout1_7ck90 FIND v(dout1_7) AT=50.025n

.meas tran vdout1_8ck90 FIND v(dout1_8) AT=50.025n

.meas tran vdout1_9ck90 FIND v(dout1_9) AT=50.025n

.meas tran vdout1_10ck90 FIND v(dout1_10) AT=50.025n

.meas tran vdout1_11ck90 FIND v(dout1_11) AT=50.025n

.meas tran vdout1_12ck90 FIND v(dout1_12) AT=50.025n

.meas tran vdout1_13ck90 FIND v(dout1_13) AT=50.025n

.meas tran vdout1_14ck90 FIND v(dout1_14) AT=50.025n

.meas tran vdout1_15ck90 FIND v(dout1_15) AT=50.025n

.meas tran vdout1_16ck90 FIND v(dout1_16) AT=50.025n

.meas tran vdout1_17ck90 FIND v(dout1_17) AT=50.025n

.meas tran vdout1_18ck90 FIND v(dout1_18) AT=50.025n

.meas tran vdout1_19ck90 FIND v(dout1_19) AT=50.025n

.meas tran vdout1_20ck90 FIND v(dout1_20) AT=50.025n

.meas tran vdout1_21ck90 FIND v(dout1_21) AT=50.025n

.meas tran vdout1_22ck90 FIND v(dout1_22) AT=50.025n

.meas tran vdout1_23ck90 FIND v(dout1_23) AT=50.025n

.meas tran vdout1_24ck90 FIND v(dout1_24) AT=50.025n

.meas tran vdout1_25ck90 FIND v(dout1_25) AT=50.025n

.meas tran vdout1_26ck90 FIND v(dout1_26) AT=50.025n

.meas tran vdout1_27ck90 FIND v(dout1_27) AT=50.025n

.meas tran vdout1_28ck90 FIND v(dout1_28) AT=50.025n

.meas tran vdout1_29ck90 FIND v(dout1_29) AT=50.025n

.meas tran vdout1_30ck90 FIND v(dout1_30) AT=50.025n

.meas tran vdout1_31ck90 FIND v(dout1_31) AT=50.025n

.meas tran vdout1_32ck90 FIND v(dout1_32) AT=50.025n

.meas tran vdout1_33ck90 FIND v(dout1_33) AT=50.025n

.meas tran vdout1_34ck90 FIND v(dout1_34) AT=50.025n

.meas tran vdout1_35ck90 FIND v(dout1_35) AT=50.025n

.meas tran vdout1_36ck90 FIND v(dout1_36) AT=50.025n

.meas tran vdout1_37ck90 FIND v(dout1_37) AT=50.025n

.meas tran vdout1_38ck90 FIND v(dout1_38) AT=50.025n

.meas tran vdout1_39ck90 FIND v(dout1_39) AT=50.025n

.meas tran vdout1_40ck90 FIND v(dout1_40) AT=50.025n

.meas tran vdout1_41ck90 FIND v(dout1_41) AT=50.025n

.meas tran vdout1_42ck90 FIND v(dout1_42) AT=50.025n

.meas tran vdout1_43ck90 FIND v(dout1_43) AT=50.025n

.meas tran vdout1_44ck90 FIND v(dout1_44) AT=50.025n

.meas tran vdout1_45ck90 FIND v(dout1_45) AT=50.025n

.meas tran vdout1_46ck90 FIND v(dout1_46) AT=50.025n

.meas tran vdout1_47ck90 FIND v(dout1_47) AT=50.025n

.meas tran vdout1_48ck90 FIND v(dout1_48) AT=50.025n

.meas tran vdout1_49ck90 FIND v(dout1_49) AT=50.025n

.meas tran vdout1_50ck90 FIND v(dout1_50) AT=50.025n

.meas tran vdout1_51ck90 FIND v(dout1_51) AT=50.025n

.meas tran vdout1_52ck90 FIND v(dout1_52) AT=50.025n

.meas tran vdout1_53ck90 FIND v(dout1_53) AT=50.025n

.meas tran vdout1_54ck90 FIND v(dout1_54) AT=50.025n

.meas tran vdout1_55ck90 FIND v(dout1_55) AT=50.025n

.meas tran vdout1_56ck90 FIND v(dout1_56) AT=50.025n

.meas tran vdout1_57ck90 FIND v(dout1_57) AT=50.025n

.meas tran vdout1_58ck90 FIND v(dout1_58) AT=50.025n

.meas tran vdout1_59ck90 FIND v(dout1_59) AT=50.025n

.meas tran vdout1_60ck90 FIND v(dout1_60) AT=50.025n

.meas tran vdout1_61ck90 FIND v(dout1_61) AT=50.025n

.meas tran vdout1_62ck90 FIND v(dout1_62) AT=50.025n

.meas tran vdout1_63ck90 FIND v(dout1_63) AT=50.025n

.meas tran vdout1_64ck90 FIND v(dout1_64) AT=50.025n

.meas tran vdout1_65ck90 FIND v(dout1_65) AT=50.025n

.meas tran vdout1_66ck90 FIND v(dout1_66) AT=50.025n

.meas tran vdout1_67ck90 FIND v(dout1_67) AT=50.025n

.meas tran vdout1_68ck90 FIND v(dout1_68) AT=50.025n

.meas tran vdout1_69ck90 FIND v(dout1_69) AT=50.025n

.meas tran vdout1_70ck90 FIND v(dout1_70) AT=50.025n

.meas tran vdout1_71ck90 FIND v(dout1_71) AT=50.025n

.meas tran vdout1_72ck90 FIND v(dout1_72) AT=50.025n

.meas tran vdout1_73ck90 FIND v(dout1_73) AT=50.025n

.meas tran vdout1_74ck90 FIND v(dout1_74) AT=50.025n

.meas tran vdout1_75ck90 FIND v(dout1_75) AT=50.025n

.meas tran vdout1_76ck90 FIND v(dout1_76) AT=50.025n

.meas tran vdout1_77ck90 FIND v(dout1_77) AT=50.025n

.meas tran vdout1_78ck90 FIND v(dout1_78) AT=50.025n

.meas tran vdout1_79ck90 FIND v(dout1_79) AT=50.025n

.meas tran vdout1_80ck90 FIND v(dout1_80) AT=50.025n

.meas tran vdout1_81ck90 FIND v(dout1_81) AT=50.025n

.meas tran vdout1_82ck90 FIND v(dout1_82) AT=50.025n

.meas tran vdout1_83ck90 FIND v(dout1_83) AT=50.025n

.meas tran vdout1_84ck90 FIND v(dout1_84) AT=50.025n

.meas tran vdout1_85ck90 FIND v(dout1_85) AT=50.025n

.meas tran vdout1_86ck90 FIND v(dout1_86) AT=50.025n

.meas tran vdout1_87ck90 FIND v(dout1_87) AT=50.025n

.meas tran vdout1_88ck90 FIND v(dout1_88) AT=50.025n

.meas tran vdout1_89ck90 FIND v(dout1_89) AT=50.025n

.meas tran vdout1_90ck90 FIND v(dout1_90) AT=50.025n

.meas tran vdout1_91ck90 FIND v(dout1_91) AT=50.025n

.meas tran vdout1_92ck90 FIND v(dout1_92) AT=50.025n

.meas tran vdout1_93ck90 FIND v(dout1_93) AT=50.025n

.meas tran vdout1_94ck90 FIND v(dout1_94) AT=50.025n

.meas tran vdout1_95ck90 FIND v(dout1_95) AT=50.025n

.meas tran vdout1_96ck90 FIND v(dout1_96) AT=50.025n

.meas tran vdout1_97ck90 FIND v(dout1_97) AT=50.025n

.meas tran vdout1_98ck90 FIND v(dout1_98) AT=50.025n

.meas tran vdout1_99ck90 FIND v(dout1_99) AT=50.025n

.meas tran vdout1_100ck90 FIND v(dout1_100) AT=50.025n

.meas tran vdout1_101ck90 FIND v(dout1_101) AT=50.025n

.meas tran vdout1_102ck90 FIND v(dout1_102) AT=50.025n

.meas tran vdout1_103ck90 FIND v(dout1_103) AT=50.025n

.meas tran vdout1_104ck90 FIND v(dout1_104) AT=50.025n

.meas tran vdout1_105ck90 FIND v(dout1_105) AT=50.025n

.meas tran vdout1_106ck90 FIND v(dout1_106) AT=50.025n

.meas tran vdout1_107ck90 FIND v(dout1_107) AT=50.025n

.meas tran vdout1_108ck90 FIND v(dout1_108) AT=50.025n

.meas tran vdout1_109ck90 FIND v(dout1_109) AT=50.025n

.meas tran vdout1_110ck90 FIND v(dout1_110) AT=50.025n

.meas tran vdout1_111ck90 FIND v(dout1_111) AT=50.025n

.meas tran vdout1_112ck90 FIND v(dout1_112) AT=50.025n

.meas tran vdout1_113ck90 FIND v(dout1_113) AT=50.025n

.meas tran vdout1_114ck90 FIND v(dout1_114) AT=50.025n

.meas tran vdout1_115ck90 FIND v(dout1_115) AT=50.025n

.meas tran vdout1_116ck90 FIND v(dout1_116) AT=50.025n

.meas tran vdout1_117ck90 FIND v(dout1_117) AT=50.025n

.meas tran vdout1_118ck90 FIND v(dout1_118) AT=50.025n

.meas tran vdout1_119ck90 FIND v(dout1_119) AT=50.025n

.meas tran vdout1_120ck90 FIND v(dout1_120) AT=50.025n

.meas tran vdout1_121ck90 FIND v(dout1_121) AT=50.025n

.meas tran vdout1_122ck90 FIND v(dout1_122) AT=50.025n

.meas tran vdout1_123ck90 FIND v(dout1_123) AT=50.025n

.meas tran vdout1_124ck90 FIND v(dout1_124) AT=50.025n

.meas tran vdout1_125ck90 FIND v(dout1_125) AT=50.025n

.meas tran vdout1_126ck90 FIND v(dout1_126) AT=50.025n

.meas tran vdout1_127ck90 FIND v(dout1_127) AT=50.025n

.meas tran vdout1_0ck110 FIND v(dout1_0) AT=60.025n

.meas tran vdout1_1ck110 FIND v(dout1_1) AT=60.025n

.meas tran vdout1_2ck110 FIND v(dout1_2) AT=60.025n

.meas tran vdout1_3ck110 FIND v(dout1_3) AT=60.025n

.meas tran vdout1_4ck110 FIND v(dout1_4) AT=60.025n

.meas tran vdout1_5ck110 FIND v(dout1_5) AT=60.025n

.meas tran vdout1_6ck110 FIND v(dout1_6) AT=60.025n

.meas tran vdout1_7ck110 FIND v(dout1_7) AT=60.025n

.meas tran vdout1_8ck110 FIND v(dout1_8) AT=60.025n

.meas tran vdout1_9ck110 FIND v(dout1_9) AT=60.025n

.meas tran vdout1_10ck110 FIND v(dout1_10) AT=60.025n

.meas tran vdout1_11ck110 FIND v(dout1_11) AT=60.025n

.meas tran vdout1_12ck110 FIND v(dout1_12) AT=60.025n

.meas tran vdout1_13ck110 FIND v(dout1_13) AT=60.025n

.meas tran vdout1_14ck110 FIND v(dout1_14) AT=60.025n

.meas tran vdout1_15ck110 FIND v(dout1_15) AT=60.025n

.meas tran vdout1_16ck110 FIND v(dout1_16) AT=60.025n

.meas tran vdout1_17ck110 FIND v(dout1_17) AT=60.025n

.meas tran vdout1_18ck110 FIND v(dout1_18) AT=60.025n

.meas tran vdout1_19ck110 FIND v(dout1_19) AT=60.025n

.meas tran vdout1_20ck110 FIND v(dout1_20) AT=60.025n

.meas tran vdout1_21ck110 FIND v(dout1_21) AT=60.025n

.meas tran vdout1_22ck110 FIND v(dout1_22) AT=60.025n

.meas tran vdout1_23ck110 FIND v(dout1_23) AT=60.025n

.meas tran vdout1_24ck110 FIND v(dout1_24) AT=60.025n

.meas tran vdout1_25ck110 FIND v(dout1_25) AT=60.025n

.meas tran vdout1_26ck110 FIND v(dout1_26) AT=60.025n

.meas tran vdout1_27ck110 FIND v(dout1_27) AT=60.025n

.meas tran vdout1_28ck110 FIND v(dout1_28) AT=60.025n

.meas tran vdout1_29ck110 FIND v(dout1_29) AT=60.025n

.meas tran vdout1_30ck110 FIND v(dout1_30) AT=60.025n

.meas tran vdout1_31ck110 FIND v(dout1_31) AT=60.025n

.meas tran vdout1_32ck110 FIND v(dout1_32) AT=60.025n

.meas tran vdout1_33ck110 FIND v(dout1_33) AT=60.025n

.meas tran vdout1_34ck110 FIND v(dout1_34) AT=60.025n

.meas tran vdout1_35ck110 FIND v(dout1_35) AT=60.025n

.meas tran vdout1_36ck110 FIND v(dout1_36) AT=60.025n

.meas tran vdout1_37ck110 FIND v(dout1_37) AT=60.025n

.meas tran vdout1_38ck110 FIND v(dout1_38) AT=60.025n

.meas tran vdout1_39ck110 FIND v(dout1_39) AT=60.025n

.meas tran vdout1_40ck110 FIND v(dout1_40) AT=60.025n

.meas tran vdout1_41ck110 FIND v(dout1_41) AT=60.025n

.meas tran vdout1_42ck110 FIND v(dout1_42) AT=60.025n

.meas tran vdout1_43ck110 FIND v(dout1_43) AT=60.025n

.meas tran vdout1_44ck110 FIND v(dout1_44) AT=60.025n

.meas tran vdout1_45ck110 FIND v(dout1_45) AT=60.025n

.meas tran vdout1_46ck110 FIND v(dout1_46) AT=60.025n

.meas tran vdout1_47ck110 FIND v(dout1_47) AT=60.025n

.meas tran vdout1_48ck110 FIND v(dout1_48) AT=60.025n

.meas tran vdout1_49ck110 FIND v(dout1_49) AT=60.025n

.meas tran vdout1_50ck110 FIND v(dout1_50) AT=60.025n

.meas tran vdout1_51ck110 FIND v(dout1_51) AT=60.025n

.meas tran vdout1_52ck110 FIND v(dout1_52) AT=60.025n

.meas tran vdout1_53ck110 FIND v(dout1_53) AT=60.025n

.meas tran vdout1_54ck110 FIND v(dout1_54) AT=60.025n

.meas tran vdout1_55ck110 FIND v(dout1_55) AT=60.025n

.meas tran vdout1_56ck110 FIND v(dout1_56) AT=60.025n

.meas tran vdout1_57ck110 FIND v(dout1_57) AT=60.025n

.meas tran vdout1_58ck110 FIND v(dout1_58) AT=60.025n

.meas tran vdout1_59ck110 FIND v(dout1_59) AT=60.025n

.meas tran vdout1_60ck110 FIND v(dout1_60) AT=60.025n

.meas tran vdout1_61ck110 FIND v(dout1_61) AT=60.025n

.meas tran vdout1_62ck110 FIND v(dout1_62) AT=60.025n

.meas tran vdout1_63ck110 FIND v(dout1_63) AT=60.025n

.meas tran vdout1_64ck110 FIND v(dout1_64) AT=60.025n

.meas tran vdout1_65ck110 FIND v(dout1_65) AT=60.025n

.meas tran vdout1_66ck110 FIND v(dout1_66) AT=60.025n

.meas tran vdout1_67ck110 FIND v(dout1_67) AT=60.025n

.meas tran vdout1_68ck110 FIND v(dout1_68) AT=60.025n

.meas tran vdout1_69ck110 FIND v(dout1_69) AT=60.025n

.meas tran vdout1_70ck110 FIND v(dout1_70) AT=60.025n

.meas tran vdout1_71ck110 FIND v(dout1_71) AT=60.025n

.meas tran vdout1_72ck110 FIND v(dout1_72) AT=60.025n

.meas tran vdout1_73ck110 FIND v(dout1_73) AT=60.025n

.meas tran vdout1_74ck110 FIND v(dout1_74) AT=60.025n

.meas tran vdout1_75ck110 FIND v(dout1_75) AT=60.025n

.meas tran vdout1_76ck110 FIND v(dout1_76) AT=60.025n

.meas tran vdout1_77ck110 FIND v(dout1_77) AT=60.025n

.meas tran vdout1_78ck110 FIND v(dout1_78) AT=60.025n

.meas tran vdout1_79ck110 FIND v(dout1_79) AT=60.025n

.meas tran vdout1_80ck110 FIND v(dout1_80) AT=60.025n

.meas tran vdout1_81ck110 FIND v(dout1_81) AT=60.025n

.meas tran vdout1_82ck110 FIND v(dout1_82) AT=60.025n

.meas tran vdout1_83ck110 FIND v(dout1_83) AT=60.025n

.meas tran vdout1_84ck110 FIND v(dout1_84) AT=60.025n

.meas tran vdout1_85ck110 FIND v(dout1_85) AT=60.025n

.meas tran vdout1_86ck110 FIND v(dout1_86) AT=60.025n

.meas tran vdout1_87ck110 FIND v(dout1_87) AT=60.025n

.meas tran vdout1_88ck110 FIND v(dout1_88) AT=60.025n

.meas tran vdout1_89ck110 FIND v(dout1_89) AT=60.025n

.meas tran vdout1_90ck110 FIND v(dout1_90) AT=60.025n

.meas tran vdout1_91ck110 FIND v(dout1_91) AT=60.025n

.meas tran vdout1_92ck110 FIND v(dout1_92) AT=60.025n

.meas tran vdout1_93ck110 FIND v(dout1_93) AT=60.025n

.meas tran vdout1_94ck110 FIND v(dout1_94) AT=60.025n

.meas tran vdout1_95ck110 FIND v(dout1_95) AT=60.025n

.meas tran vdout1_96ck110 FIND v(dout1_96) AT=60.025n

.meas tran vdout1_97ck110 FIND v(dout1_97) AT=60.025n

.meas tran vdout1_98ck110 FIND v(dout1_98) AT=60.025n

.meas tran vdout1_99ck110 FIND v(dout1_99) AT=60.025n

.meas tran vdout1_100ck110 FIND v(dout1_100) AT=60.025n

.meas tran vdout1_101ck110 FIND v(dout1_101) AT=60.025n

.meas tran vdout1_102ck110 FIND v(dout1_102) AT=60.025n

.meas tran vdout1_103ck110 FIND v(dout1_103) AT=60.025n

.meas tran vdout1_104ck110 FIND v(dout1_104) AT=60.025n

.meas tran vdout1_105ck110 FIND v(dout1_105) AT=60.025n

.meas tran vdout1_106ck110 FIND v(dout1_106) AT=60.025n

.meas tran vdout1_107ck110 FIND v(dout1_107) AT=60.025n

.meas tran vdout1_108ck110 FIND v(dout1_108) AT=60.025n

.meas tran vdout1_109ck110 FIND v(dout1_109) AT=60.025n

.meas tran vdout1_110ck110 FIND v(dout1_110) AT=60.025n

.meas tran vdout1_111ck110 FIND v(dout1_111) AT=60.025n

.meas tran vdout1_112ck110 FIND v(dout1_112) AT=60.025n

.meas tran vdout1_113ck110 FIND v(dout1_113) AT=60.025n

.meas tran vdout1_114ck110 FIND v(dout1_114) AT=60.025n

.meas tran vdout1_115ck110 FIND v(dout1_115) AT=60.025n

.meas tran vdout1_116ck110 FIND v(dout1_116) AT=60.025n

.meas tran vdout1_117ck110 FIND v(dout1_117) AT=60.025n

.meas tran vdout1_118ck110 FIND v(dout1_118) AT=60.025n

.meas tran vdout1_119ck110 FIND v(dout1_119) AT=60.025n

.meas tran vdout1_120ck110 FIND v(dout1_120) AT=60.025n

.meas tran vdout1_121ck110 FIND v(dout1_121) AT=60.025n

.meas tran vdout1_122ck110 FIND v(dout1_122) AT=60.025n

.meas tran vdout1_123ck110 FIND v(dout1_123) AT=60.025n

.meas tran vdout1_124ck110 FIND v(dout1_124) AT=60.025n

.meas tran vdout1_125ck110 FIND v(dout1_125) AT=60.025n

.meas tran vdout1_126ck110 FIND v(dout1_126) AT=60.025n

.meas tran vdout1_127ck110 FIND v(dout1_127) AT=60.025n

.meas tran vdout1_0ck190 FIND v(dout1_0) AT=100.025n

.meas tran vdout1_1ck190 FIND v(dout1_1) AT=100.025n

.meas tran vdout1_2ck190 FIND v(dout1_2) AT=100.025n

.meas tran vdout1_3ck190 FIND v(dout1_3) AT=100.025n

.meas tran vdout1_4ck190 FIND v(dout1_4) AT=100.025n

.meas tran vdout1_5ck190 FIND v(dout1_5) AT=100.025n

.meas tran vdout1_6ck190 FIND v(dout1_6) AT=100.025n

.meas tran vdout1_7ck190 FIND v(dout1_7) AT=100.025n

.meas tran vdout1_8ck190 FIND v(dout1_8) AT=100.025n

.meas tran vdout1_9ck190 FIND v(dout1_9) AT=100.025n

.meas tran vdout1_10ck190 FIND v(dout1_10) AT=100.025n

.meas tran vdout1_11ck190 FIND v(dout1_11) AT=100.025n

.meas tran vdout1_12ck190 FIND v(dout1_12) AT=100.025n

.meas tran vdout1_13ck190 FIND v(dout1_13) AT=100.025n

.meas tran vdout1_14ck190 FIND v(dout1_14) AT=100.025n

.meas tran vdout1_15ck190 FIND v(dout1_15) AT=100.025n

.meas tran vdout1_16ck190 FIND v(dout1_16) AT=100.025n

.meas tran vdout1_17ck190 FIND v(dout1_17) AT=100.025n

.meas tran vdout1_18ck190 FIND v(dout1_18) AT=100.025n

.meas tran vdout1_19ck190 FIND v(dout1_19) AT=100.025n

.meas tran vdout1_20ck190 FIND v(dout1_20) AT=100.025n

.meas tran vdout1_21ck190 FIND v(dout1_21) AT=100.025n

.meas tran vdout1_22ck190 FIND v(dout1_22) AT=100.025n

.meas tran vdout1_23ck190 FIND v(dout1_23) AT=100.025n

.meas tran vdout1_24ck190 FIND v(dout1_24) AT=100.025n

.meas tran vdout1_25ck190 FIND v(dout1_25) AT=100.025n

.meas tran vdout1_26ck190 FIND v(dout1_26) AT=100.025n

.meas tran vdout1_27ck190 FIND v(dout1_27) AT=100.025n

.meas tran vdout1_28ck190 FIND v(dout1_28) AT=100.025n

.meas tran vdout1_29ck190 FIND v(dout1_29) AT=100.025n

.meas tran vdout1_30ck190 FIND v(dout1_30) AT=100.025n

.meas tran vdout1_31ck190 FIND v(dout1_31) AT=100.025n

.meas tran vdout1_32ck190 FIND v(dout1_32) AT=100.025n

.meas tran vdout1_33ck190 FIND v(dout1_33) AT=100.025n

.meas tran vdout1_34ck190 FIND v(dout1_34) AT=100.025n

.meas tran vdout1_35ck190 FIND v(dout1_35) AT=100.025n

.meas tran vdout1_36ck190 FIND v(dout1_36) AT=100.025n

.meas tran vdout1_37ck190 FIND v(dout1_37) AT=100.025n

.meas tran vdout1_38ck190 FIND v(dout1_38) AT=100.025n

.meas tran vdout1_39ck190 FIND v(dout1_39) AT=100.025n

.meas tran vdout1_40ck190 FIND v(dout1_40) AT=100.025n

.meas tran vdout1_41ck190 FIND v(dout1_41) AT=100.025n

.meas tran vdout1_42ck190 FIND v(dout1_42) AT=100.025n

.meas tran vdout1_43ck190 FIND v(dout1_43) AT=100.025n

.meas tran vdout1_44ck190 FIND v(dout1_44) AT=100.025n

.meas tran vdout1_45ck190 FIND v(dout1_45) AT=100.025n

.meas tran vdout1_46ck190 FIND v(dout1_46) AT=100.025n

.meas tran vdout1_47ck190 FIND v(dout1_47) AT=100.025n

.meas tran vdout1_48ck190 FIND v(dout1_48) AT=100.025n

.meas tran vdout1_49ck190 FIND v(dout1_49) AT=100.025n

.meas tran vdout1_50ck190 FIND v(dout1_50) AT=100.025n

.meas tran vdout1_51ck190 FIND v(dout1_51) AT=100.025n

.meas tran vdout1_52ck190 FIND v(dout1_52) AT=100.025n

.meas tran vdout1_53ck190 FIND v(dout1_53) AT=100.025n

.meas tran vdout1_54ck190 FIND v(dout1_54) AT=100.025n

.meas tran vdout1_55ck190 FIND v(dout1_55) AT=100.025n

.meas tran vdout1_56ck190 FIND v(dout1_56) AT=100.025n

.meas tran vdout1_57ck190 FIND v(dout1_57) AT=100.025n

.meas tran vdout1_58ck190 FIND v(dout1_58) AT=100.025n

.meas tran vdout1_59ck190 FIND v(dout1_59) AT=100.025n

.meas tran vdout1_60ck190 FIND v(dout1_60) AT=100.025n

.meas tran vdout1_61ck190 FIND v(dout1_61) AT=100.025n

.meas tran vdout1_62ck190 FIND v(dout1_62) AT=100.025n

.meas tran vdout1_63ck190 FIND v(dout1_63) AT=100.025n

.meas tran vdout1_64ck190 FIND v(dout1_64) AT=100.025n

.meas tran vdout1_65ck190 FIND v(dout1_65) AT=100.025n

.meas tran vdout1_66ck190 FIND v(dout1_66) AT=100.025n

.meas tran vdout1_67ck190 FIND v(dout1_67) AT=100.025n

.meas tran vdout1_68ck190 FIND v(dout1_68) AT=100.025n

.meas tran vdout1_69ck190 FIND v(dout1_69) AT=100.025n

.meas tran vdout1_70ck190 FIND v(dout1_70) AT=100.025n

.meas tran vdout1_71ck190 FIND v(dout1_71) AT=100.025n

.meas tran vdout1_72ck190 FIND v(dout1_72) AT=100.025n

.meas tran vdout1_73ck190 FIND v(dout1_73) AT=100.025n

.meas tran vdout1_74ck190 FIND v(dout1_74) AT=100.025n

.meas tran vdout1_75ck190 FIND v(dout1_75) AT=100.025n

.meas tran vdout1_76ck190 FIND v(dout1_76) AT=100.025n

.meas tran vdout1_77ck190 FIND v(dout1_77) AT=100.025n

.meas tran vdout1_78ck190 FIND v(dout1_78) AT=100.025n

.meas tran vdout1_79ck190 FIND v(dout1_79) AT=100.025n

.meas tran vdout1_80ck190 FIND v(dout1_80) AT=100.025n

.meas tran vdout1_81ck190 FIND v(dout1_81) AT=100.025n

.meas tran vdout1_82ck190 FIND v(dout1_82) AT=100.025n

.meas tran vdout1_83ck190 FIND v(dout1_83) AT=100.025n

.meas tran vdout1_84ck190 FIND v(dout1_84) AT=100.025n

.meas tran vdout1_85ck190 FIND v(dout1_85) AT=100.025n

.meas tran vdout1_86ck190 FIND v(dout1_86) AT=100.025n

.meas tran vdout1_87ck190 FIND v(dout1_87) AT=100.025n

.meas tran vdout1_88ck190 FIND v(dout1_88) AT=100.025n

.meas tran vdout1_89ck190 FIND v(dout1_89) AT=100.025n

.meas tran vdout1_90ck190 FIND v(dout1_90) AT=100.025n

.meas tran vdout1_91ck190 FIND v(dout1_91) AT=100.025n

.meas tran vdout1_92ck190 FIND v(dout1_92) AT=100.025n

.meas tran vdout1_93ck190 FIND v(dout1_93) AT=100.025n

.meas tran vdout1_94ck190 FIND v(dout1_94) AT=100.025n

.meas tran vdout1_95ck190 FIND v(dout1_95) AT=100.025n

.meas tran vdout1_96ck190 FIND v(dout1_96) AT=100.025n

.meas tran vdout1_97ck190 FIND v(dout1_97) AT=100.025n

.meas tran vdout1_98ck190 FIND v(dout1_98) AT=100.025n

.meas tran vdout1_99ck190 FIND v(dout1_99) AT=100.025n

.meas tran vdout1_100ck190 FIND v(dout1_100) AT=100.025n

.meas tran vdout1_101ck190 FIND v(dout1_101) AT=100.025n

.meas tran vdout1_102ck190 FIND v(dout1_102) AT=100.025n

.meas tran vdout1_103ck190 FIND v(dout1_103) AT=100.025n

.meas tran vdout1_104ck190 FIND v(dout1_104) AT=100.025n

.meas tran vdout1_105ck190 FIND v(dout1_105) AT=100.025n

.meas tran vdout1_106ck190 FIND v(dout1_106) AT=100.025n

.meas tran vdout1_107ck190 FIND v(dout1_107) AT=100.025n

.meas tran vdout1_108ck190 FIND v(dout1_108) AT=100.025n

.meas tran vdout1_109ck190 FIND v(dout1_109) AT=100.025n

.meas tran vdout1_110ck190 FIND v(dout1_110) AT=100.025n

.meas tran vdout1_111ck190 FIND v(dout1_111) AT=100.025n

.meas tran vdout1_112ck190 FIND v(dout1_112) AT=100.025n

.meas tran vdout1_113ck190 FIND v(dout1_113) AT=100.025n

.meas tran vdout1_114ck190 FIND v(dout1_114) AT=100.025n

.meas tran vdout1_115ck190 FIND v(dout1_115) AT=100.025n

.meas tran vdout1_116ck190 FIND v(dout1_116) AT=100.025n

.meas tran vdout1_117ck190 FIND v(dout1_117) AT=100.025n

.meas tran vdout1_118ck190 FIND v(dout1_118) AT=100.025n

.meas tran vdout1_119ck190 FIND v(dout1_119) AT=100.025n

.meas tran vdout1_120ck190 FIND v(dout1_120) AT=100.025n

.meas tran vdout1_121ck190 FIND v(dout1_121) AT=100.025n

.meas tran vdout1_122ck190 FIND v(dout1_122) AT=100.025n

.meas tran vdout1_123ck190 FIND v(dout1_123) AT=100.025n

.meas tran vdout1_124ck190 FIND v(dout1_124) AT=100.025n

.meas tran vdout1_125ck190 FIND v(dout1_125) AT=100.025n

.meas tran vdout1_126ck190 FIND v(dout1_126) AT=100.025n

.meas tran vdout1_127ck190 FIND v(dout1_127) AT=100.025n

.meas tran vdout1_0ck230 FIND v(dout1_0) AT=120.025n

.meas tran vdout1_1ck230 FIND v(dout1_1) AT=120.025n

.meas tran vdout1_2ck230 FIND v(dout1_2) AT=120.025n

.meas tran vdout1_3ck230 FIND v(dout1_3) AT=120.025n

.meas tran vdout1_4ck230 FIND v(dout1_4) AT=120.025n

.meas tran vdout1_5ck230 FIND v(dout1_5) AT=120.025n

.meas tran vdout1_6ck230 FIND v(dout1_6) AT=120.025n

.meas tran vdout1_7ck230 FIND v(dout1_7) AT=120.025n

.meas tran vdout1_8ck230 FIND v(dout1_8) AT=120.025n

.meas tran vdout1_9ck230 FIND v(dout1_9) AT=120.025n

.meas tran vdout1_10ck230 FIND v(dout1_10) AT=120.025n

.meas tran vdout1_11ck230 FIND v(dout1_11) AT=120.025n

.meas tran vdout1_12ck230 FIND v(dout1_12) AT=120.025n

.meas tran vdout1_13ck230 FIND v(dout1_13) AT=120.025n

.meas tran vdout1_14ck230 FIND v(dout1_14) AT=120.025n

.meas tran vdout1_15ck230 FIND v(dout1_15) AT=120.025n

.meas tran vdout1_16ck230 FIND v(dout1_16) AT=120.025n

.meas tran vdout1_17ck230 FIND v(dout1_17) AT=120.025n

.meas tran vdout1_18ck230 FIND v(dout1_18) AT=120.025n

.meas tran vdout1_19ck230 FIND v(dout1_19) AT=120.025n

.meas tran vdout1_20ck230 FIND v(dout1_20) AT=120.025n

.meas tran vdout1_21ck230 FIND v(dout1_21) AT=120.025n

.meas tran vdout1_22ck230 FIND v(dout1_22) AT=120.025n

.meas tran vdout1_23ck230 FIND v(dout1_23) AT=120.025n

.meas tran vdout1_24ck230 FIND v(dout1_24) AT=120.025n

.meas tran vdout1_25ck230 FIND v(dout1_25) AT=120.025n

.meas tran vdout1_26ck230 FIND v(dout1_26) AT=120.025n

.meas tran vdout1_27ck230 FIND v(dout1_27) AT=120.025n

.meas tran vdout1_28ck230 FIND v(dout1_28) AT=120.025n

.meas tran vdout1_29ck230 FIND v(dout1_29) AT=120.025n

.meas tran vdout1_30ck230 FIND v(dout1_30) AT=120.025n

.meas tran vdout1_31ck230 FIND v(dout1_31) AT=120.025n

.meas tran vdout1_32ck230 FIND v(dout1_32) AT=120.025n

.meas tran vdout1_33ck230 FIND v(dout1_33) AT=120.025n

.meas tran vdout1_34ck230 FIND v(dout1_34) AT=120.025n

.meas tran vdout1_35ck230 FIND v(dout1_35) AT=120.025n

.meas tran vdout1_36ck230 FIND v(dout1_36) AT=120.025n

.meas tran vdout1_37ck230 FIND v(dout1_37) AT=120.025n

.meas tran vdout1_38ck230 FIND v(dout1_38) AT=120.025n

.meas tran vdout1_39ck230 FIND v(dout1_39) AT=120.025n

.meas tran vdout1_40ck230 FIND v(dout1_40) AT=120.025n

.meas tran vdout1_41ck230 FIND v(dout1_41) AT=120.025n

.meas tran vdout1_42ck230 FIND v(dout1_42) AT=120.025n

.meas tran vdout1_43ck230 FIND v(dout1_43) AT=120.025n

.meas tran vdout1_44ck230 FIND v(dout1_44) AT=120.025n

.meas tran vdout1_45ck230 FIND v(dout1_45) AT=120.025n

.meas tran vdout1_46ck230 FIND v(dout1_46) AT=120.025n

.meas tran vdout1_47ck230 FIND v(dout1_47) AT=120.025n

.meas tran vdout1_48ck230 FIND v(dout1_48) AT=120.025n

.meas tran vdout1_49ck230 FIND v(dout1_49) AT=120.025n

.meas tran vdout1_50ck230 FIND v(dout1_50) AT=120.025n

.meas tran vdout1_51ck230 FIND v(dout1_51) AT=120.025n

.meas tran vdout1_52ck230 FIND v(dout1_52) AT=120.025n

.meas tran vdout1_53ck230 FIND v(dout1_53) AT=120.025n

.meas tran vdout1_54ck230 FIND v(dout1_54) AT=120.025n

.meas tran vdout1_55ck230 FIND v(dout1_55) AT=120.025n

.meas tran vdout1_56ck230 FIND v(dout1_56) AT=120.025n

.meas tran vdout1_57ck230 FIND v(dout1_57) AT=120.025n

.meas tran vdout1_58ck230 FIND v(dout1_58) AT=120.025n

.meas tran vdout1_59ck230 FIND v(dout1_59) AT=120.025n

.meas tran vdout1_60ck230 FIND v(dout1_60) AT=120.025n

.meas tran vdout1_61ck230 FIND v(dout1_61) AT=120.025n

.meas tran vdout1_62ck230 FIND v(dout1_62) AT=120.025n

.meas tran vdout1_63ck230 FIND v(dout1_63) AT=120.025n

.meas tran vdout1_64ck230 FIND v(dout1_64) AT=120.025n

.meas tran vdout1_65ck230 FIND v(dout1_65) AT=120.025n

.meas tran vdout1_66ck230 FIND v(dout1_66) AT=120.025n

.meas tran vdout1_67ck230 FIND v(dout1_67) AT=120.025n

.meas tran vdout1_68ck230 FIND v(dout1_68) AT=120.025n

.meas tran vdout1_69ck230 FIND v(dout1_69) AT=120.025n

.meas tran vdout1_70ck230 FIND v(dout1_70) AT=120.025n

.meas tran vdout1_71ck230 FIND v(dout1_71) AT=120.025n

.meas tran vdout1_72ck230 FIND v(dout1_72) AT=120.025n

.meas tran vdout1_73ck230 FIND v(dout1_73) AT=120.025n

.meas tran vdout1_74ck230 FIND v(dout1_74) AT=120.025n

.meas tran vdout1_75ck230 FIND v(dout1_75) AT=120.025n

.meas tran vdout1_76ck230 FIND v(dout1_76) AT=120.025n

.meas tran vdout1_77ck230 FIND v(dout1_77) AT=120.025n

.meas tran vdout1_78ck230 FIND v(dout1_78) AT=120.025n

.meas tran vdout1_79ck230 FIND v(dout1_79) AT=120.025n

.meas tran vdout1_80ck230 FIND v(dout1_80) AT=120.025n

.meas tran vdout1_81ck230 FIND v(dout1_81) AT=120.025n

.meas tran vdout1_82ck230 FIND v(dout1_82) AT=120.025n

.meas tran vdout1_83ck230 FIND v(dout1_83) AT=120.025n

.meas tran vdout1_84ck230 FIND v(dout1_84) AT=120.025n

.meas tran vdout1_85ck230 FIND v(dout1_85) AT=120.025n

.meas tran vdout1_86ck230 FIND v(dout1_86) AT=120.025n

.meas tran vdout1_87ck230 FIND v(dout1_87) AT=120.025n

.meas tran vdout1_88ck230 FIND v(dout1_88) AT=120.025n

.meas tran vdout1_89ck230 FIND v(dout1_89) AT=120.025n

.meas tran vdout1_90ck230 FIND v(dout1_90) AT=120.025n

.meas tran vdout1_91ck230 FIND v(dout1_91) AT=120.025n

.meas tran vdout1_92ck230 FIND v(dout1_92) AT=120.025n

.meas tran vdout1_93ck230 FIND v(dout1_93) AT=120.025n

.meas tran vdout1_94ck230 FIND v(dout1_94) AT=120.025n

.meas tran vdout1_95ck230 FIND v(dout1_95) AT=120.025n

.meas tran vdout1_96ck230 FIND v(dout1_96) AT=120.025n

.meas tran vdout1_97ck230 FIND v(dout1_97) AT=120.025n

.meas tran vdout1_98ck230 FIND v(dout1_98) AT=120.025n

.meas tran vdout1_99ck230 FIND v(dout1_99) AT=120.025n

.meas tran vdout1_100ck230 FIND v(dout1_100) AT=120.025n

.meas tran vdout1_101ck230 FIND v(dout1_101) AT=120.025n

.meas tran vdout1_102ck230 FIND v(dout1_102) AT=120.025n

.meas tran vdout1_103ck230 FIND v(dout1_103) AT=120.025n

.meas tran vdout1_104ck230 FIND v(dout1_104) AT=120.025n

.meas tran vdout1_105ck230 FIND v(dout1_105) AT=120.025n

.meas tran vdout1_106ck230 FIND v(dout1_106) AT=120.025n

.meas tran vdout1_107ck230 FIND v(dout1_107) AT=120.025n

.meas tran vdout1_108ck230 FIND v(dout1_108) AT=120.025n

.meas tran vdout1_109ck230 FIND v(dout1_109) AT=120.025n

.meas tran vdout1_110ck230 FIND v(dout1_110) AT=120.025n

.meas tran vdout1_111ck230 FIND v(dout1_111) AT=120.025n

.meas tran vdout1_112ck230 FIND v(dout1_112) AT=120.025n

.meas tran vdout1_113ck230 FIND v(dout1_113) AT=120.025n

.meas tran vdout1_114ck230 FIND v(dout1_114) AT=120.025n

.meas tran vdout1_115ck230 FIND v(dout1_115) AT=120.025n

.meas tran vdout1_116ck230 FIND v(dout1_116) AT=120.025n

.meas tran vdout1_117ck230 FIND v(dout1_117) AT=120.025n

.meas tran vdout1_118ck230 FIND v(dout1_118) AT=120.025n

.meas tran vdout1_119ck230 FIND v(dout1_119) AT=120.025n

.meas tran vdout1_120ck230 FIND v(dout1_120) AT=120.025n

.meas tran vdout1_121ck230 FIND v(dout1_121) AT=120.025n

.meas tran vdout1_122ck230 FIND v(dout1_122) AT=120.025n

.meas tran vdout1_123ck230 FIND v(dout1_123) AT=120.025n

.meas tran vdout1_124ck230 FIND v(dout1_124) AT=120.025n

.meas tran vdout1_125ck230 FIND v(dout1_125) AT=120.025n

.meas tran vdout1_126ck230 FIND v(dout1_126) AT=120.025n

.meas tran vdout1_127ck230 FIND v(dout1_127) AT=120.025n

.meas tran vdout1_0ck300 FIND v(dout1_0) AT=155.025n

.meas tran vdout1_1ck300 FIND v(dout1_1) AT=155.025n

.meas tran vdout1_2ck300 FIND v(dout1_2) AT=155.025n

.meas tran vdout1_3ck300 FIND v(dout1_3) AT=155.025n

.meas tran vdout1_4ck300 FIND v(dout1_4) AT=155.025n

.meas tran vdout1_5ck300 FIND v(dout1_5) AT=155.025n

.meas tran vdout1_6ck300 FIND v(dout1_6) AT=155.025n

.meas tran vdout1_7ck300 FIND v(dout1_7) AT=155.025n

.meas tran vdout1_8ck300 FIND v(dout1_8) AT=155.025n

.meas tran vdout1_9ck300 FIND v(dout1_9) AT=155.025n

.meas tran vdout1_10ck300 FIND v(dout1_10) AT=155.025n

.meas tran vdout1_11ck300 FIND v(dout1_11) AT=155.025n

.meas tran vdout1_12ck300 FIND v(dout1_12) AT=155.025n

.meas tran vdout1_13ck300 FIND v(dout1_13) AT=155.025n

.meas tran vdout1_14ck300 FIND v(dout1_14) AT=155.025n

.meas tran vdout1_15ck300 FIND v(dout1_15) AT=155.025n

.meas tran vdout1_16ck300 FIND v(dout1_16) AT=155.025n

.meas tran vdout1_17ck300 FIND v(dout1_17) AT=155.025n

.meas tran vdout1_18ck300 FIND v(dout1_18) AT=155.025n

.meas tran vdout1_19ck300 FIND v(dout1_19) AT=155.025n

.meas tran vdout1_20ck300 FIND v(dout1_20) AT=155.025n

.meas tran vdout1_21ck300 FIND v(dout1_21) AT=155.025n

.meas tran vdout1_22ck300 FIND v(dout1_22) AT=155.025n

.meas tran vdout1_23ck300 FIND v(dout1_23) AT=155.025n

.meas tran vdout1_24ck300 FIND v(dout1_24) AT=155.025n

.meas tran vdout1_25ck300 FIND v(dout1_25) AT=155.025n

.meas tran vdout1_26ck300 FIND v(dout1_26) AT=155.025n

.meas tran vdout1_27ck300 FIND v(dout1_27) AT=155.025n

.meas tran vdout1_28ck300 FIND v(dout1_28) AT=155.025n

.meas tran vdout1_29ck300 FIND v(dout1_29) AT=155.025n

.meas tran vdout1_30ck300 FIND v(dout1_30) AT=155.025n

.meas tran vdout1_31ck300 FIND v(dout1_31) AT=155.025n

.meas tran vdout1_32ck300 FIND v(dout1_32) AT=155.025n

.meas tran vdout1_33ck300 FIND v(dout1_33) AT=155.025n

.meas tran vdout1_34ck300 FIND v(dout1_34) AT=155.025n

.meas tran vdout1_35ck300 FIND v(dout1_35) AT=155.025n

.meas tran vdout1_36ck300 FIND v(dout1_36) AT=155.025n

.meas tran vdout1_37ck300 FIND v(dout1_37) AT=155.025n

.meas tran vdout1_38ck300 FIND v(dout1_38) AT=155.025n

.meas tran vdout1_39ck300 FIND v(dout1_39) AT=155.025n

.meas tran vdout1_40ck300 FIND v(dout1_40) AT=155.025n

.meas tran vdout1_41ck300 FIND v(dout1_41) AT=155.025n

.meas tran vdout1_42ck300 FIND v(dout1_42) AT=155.025n

.meas tran vdout1_43ck300 FIND v(dout1_43) AT=155.025n

.meas tran vdout1_44ck300 FIND v(dout1_44) AT=155.025n

.meas tran vdout1_45ck300 FIND v(dout1_45) AT=155.025n

.meas tran vdout1_46ck300 FIND v(dout1_46) AT=155.025n

.meas tran vdout1_47ck300 FIND v(dout1_47) AT=155.025n

.meas tran vdout1_48ck300 FIND v(dout1_48) AT=155.025n

.meas tran vdout1_49ck300 FIND v(dout1_49) AT=155.025n

.meas tran vdout1_50ck300 FIND v(dout1_50) AT=155.025n

.meas tran vdout1_51ck300 FIND v(dout1_51) AT=155.025n

.meas tran vdout1_52ck300 FIND v(dout1_52) AT=155.025n

.meas tran vdout1_53ck300 FIND v(dout1_53) AT=155.025n

.meas tran vdout1_54ck300 FIND v(dout1_54) AT=155.025n

.meas tran vdout1_55ck300 FIND v(dout1_55) AT=155.025n

.meas tran vdout1_56ck300 FIND v(dout1_56) AT=155.025n

.meas tran vdout1_57ck300 FIND v(dout1_57) AT=155.025n

.meas tran vdout1_58ck300 FIND v(dout1_58) AT=155.025n

.meas tran vdout1_59ck300 FIND v(dout1_59) AT=155.025n

.meas tran vdout1_60ck300 FIND v(dout1_60) AT=155.025n

.meas tran vdout1_61ck300 FIND v(dout1_61) AT=155.025n

.meas tran vdout1_62ck300 FIND v(dout1_62) AT=155.025n

.meas tran vdout1_63ck300 FIND v(dout1_63) AT=155.025n

.meas tran vdout1_64ck300 FIND v(dout1_64) AT=155.025n

.meas tran vdout1_65ck300 FIND v(dout1_65) AT=155.025n

.meas tran vdout1_66ck300 FIND v(dout1_66) AT=155.025n

.meas tran vdout1_67ck300 FIND v(dout1_67) AT=155.025n

.meas tran vdout1_68ck300 FIND v(dout1_68) AT=155.025n

.meas tran vdout1_69ck300 FIND v(dout1_69) AT=155.025n

.meas tran vdout1_70ck300 FIND v(dout1_70) AT=155.025n

.meas tran vdout1_71ck300 FIND v(dout1_71) AT=155.025n

.meas tran vdout1_72ck300 FIND v(dout1_72) AT=155.025n

.meas tran vdout1_73ck300 FIND v(dout1_73) AT=155.025n

.meas tran vdout1_74ck300 FIND v(dout1_74) AT=155.025n

.meas tran vdout1_75ck300 FIND v(dout1_75) AT=155.025n

.meas tran vdout1_76ck300 FIND v(dout1_76) AT=155.025n

.meas tran vdout1_77ck300 FIND v(dout1_77) AT=155.025n

.meas tran vdout1_78ck300 FIND v(dout1_78) AT=155.025n

.meas tran vdout1_79ck300 FIND v(dout1_79) AT=155.025n

.meas tran vdout1_80ck300 FIND v(dout1_80) AT=155.025n

.meas tran vdout1_81ck300 FIND v(dout1_81) AT=155.025n

.meas tran vdout1_82ck300 FIND v(dout1_82) AT=155.025n

.meas tran vdout1_83ck300 FIND v(dout1_83) AT=155.025n

.meas tran vdout1_84ck300 FIND v(dout1_84) AT=155.025n

.meas tran vdout1_85ck300 FIND v(dout1_85) AT=155.025n

.meas tran vdout1_86ck300 FIND v(dout1_86) AT=155.025n

.meas tran vdout1_87ck300 FIND v(dout1_87) AT=155.025n

.meas tran vdout1_88ck300 FIND v(dout1_88) AT=155.025n

.meas tran vdout1_89ck300 FIND v(dout1_89) AT=155.025n

.meas tran vdout1_90ck300 FIND v(dout1_90) AT=155.025n

.meas tran vdout1_91ck300 FIND v(dout1_91) AT=155.025n

.meas tran vdout1_92ck300 FIND v(dout1_92) AT=155.025n

.meas tran vdout1_93ck300 FIND v(dout1_93) AT=155.025n

.meas tran vdout1_94ck300 FIND v(dout1_94) AT=155.025n

.meas tran vdout1_95ck300 FIND v(dout1_95) AT=155.025n

.meas tran vdout1_96ck300 FIND v(dout1_96) AT=155.025n

.meas tran vdout1_97ck300 FIND v(dout1_97) AT=155.025n

.meas tran vdout1_98ck300 FIND v(dout1_98) AT=155.025n

.meas tran vdout1_99ck300 FIND v(dout1_99) AT=155.025n

.meas tran vdout1_100ck300 FIND v(dout1_100) AT=155.025n

.meas tran vdout1_101ck300 FIND v(dout1_101) AT=155.025n

.meas tran vdout1_102ck300 FIND v(dout1_102) AT=155.025n

.meas tran vdout1_103ck300 FIND v(dout1_103) AT=155.025n

.meas tran vdout1_104ck300 FIND v(dout1_104) AT=155.025n

.meas tran vdout1_105ck300 FIND v(dout1_105) AT=155.025n

.meas tran vdout1_106ck300 FIND v(dout1_106) AT=155.025n

.meas tran vdout1_107ck300 FIND v(dout1_107) AT=155.025n

.meas tran vdout1_108ck300 FIND v(dout1_108) AT=155.025n

.meas tran vdout1_109ck300 FIND v(dout1_109) AT=155.025n

.meas tran vdout1_110ck300 FIND v(dout1_110) AT=155.025n

.meas tran vdout1_111ck300 FIND v(dout1_111) AT=155.025n

.meas tran vdout1_112ck300 FIND v(dout1_112) AT=155.025n

.meas tran vdout1_113ck300 FIND v(dout1_113) AT=155.025n

.meas tran vdout1_114ck300 FIND v(dout1_114) AT=155.025n

.meas tran vdout1_115ck300 FIND v(dout1_115) AT=155.025n

.meas tran vdout1_116ck300 FIND v(dout1_116) AT=155.025n

.meas tran vdout1_117ck300 FIND v(dout1_117) AT=155.025n

.meas tran vdout1_118ck300 FIND v(dout1_118) AT=155.025n

.meas tran vdout1_119ck300 FIND v(dout1_119) AT=155.025n

.meas tran vdout1_120ck300 FIND v(dout1_120) AT=155.025n

.meas tran vdout1_121ck300 FIND v(dout1_121) AT=155.025n

.meas tran vdout1_122ck300 FIND v(dout1_122) AT=155.025n

.meas tran vdout1_123ck300 FIND v(dout1_123) AT=155.025n

.meas tran vdout1_124ck300 FIND v(dout1_124) AT=155.025n

.meas tran vdout1_125ck300 FIND v(dout1_125) AT=155.025n

.meas tran vdout1_126ck300 FIND v(dout1_126) AT=155.025n

.meas tran vdout1_127ck300 FIND v(dout1_127) AT=155.025n

.meas tran vdout1_0ck310 FIND v(dout1_0) AT=160.025n

.meas tran vdout1_1ck310 FIND v(dout1_1) AT=160.025n

.meas tran vdout1_2ck310 FIND v(dout1_2) AT=160.025n

.meas tran vdout1_3ck310 FIND v(dout1_3) AT=160.025n

.meas tran vdout1_4ck310 FIND v(dout1_4) AT=160.025n

.meas tran vdout1_5ck310 FIND v(dout1_5) AT=160.025n

.meas tran vdout1_6ck310 FIND v(dout1_6) AT=160.025n

.meas tran vdout1_7ck310 FIND v(dout1_7) AT=160.025n

.meas tran vdout1_8ck310 FIND v(dout1_8) AT=160.025n

.meas tran vdout1_9ck310 FIND v(dout1_9) AT=160.025n

.meas tran vdout1_10ck310 FIND v(dout1_10) AT=160.025n

.meas tran vdout1_11ck310 FIND v(dout1_11) AT=160.025n

.meas tran vdout1_12ck310 FIND v(dout1_12) AT=160.025n

.meas tran vdout1_13ck310 FIND v(dout1_13) AT=160.025n

.meas tran vdout1_14ck310 FIND v(dout1_14) AT=160.025n

.meas tran vdout1_15ck310 FIND v(dout1_15) AT=160.025n

.meas tran vdout1_16ck310 FIND v(dout1_16) AT=160.025n

.meas tran vdout1_17ck310 FIND v(dout1_17) AT=160.025n

.meas tran vdout1_18ck310 FIND v(dout1_18) AT=160.025n

.meas tran vdout1_19ck310 FIND v(dout1_19) AT=160.025n

.meas tran vdout1_20ck310 FIND v(dout1_20) AT=160.025n

.meas tran vdout1_21ck310 FIND v(dout1_21) AT=160.025n

.meas tran vdout1_22ck310 FIND v(dout1_22) AT=160.025n

.meas tran vdout1_23ck310 FIND v(dout1_23) AT=160.025n

.meas tran vdout1_24ck310 FIND v(dout1_24) AT=160.025n

.meas tran vdout1_25ck310 FIND v(dout1_25) AT=160.025n

.meas tran vdout1_26ck310 FIND v(dout1_26) AT=160.025n

.meas tran vdout1_27ck310 FIND v(dout1_27) AT=160.025n

.meas tran vdout1_28ck310 FIND v(dout1_28) AT=160.025n

.meas tran vdout1_29ck310 FIND v(dout1_29) AT=160.025n

.meas tran vdout1_30ck310 FIND v(dout1_30) AT=160.025n

.meas tran vdout1_31ck310 FIND v(dout1_31) AT=160.025n

.meas tran vdout1_32ck310 FIND v(dout1_32) AT=160.025n

.meas tran vdout1_33ck310 FIND v(dout1_33) AT=160.025n

.meas tran vdout1_34ck310 FIND v(dout1_34) AT=160.025n

.meas tran vdout1_35ck310 FIND v(dout1_35) AT=160.025n

.meas tran vdout1_36ck310 FIND v(dout1_36) AT=160.025n

.meas tran vdout1_37ck310 FIND v(dout1_37) AT=160.025n

.meas tran vdout1_38ck310 FIND v(dout1_38) AT=160.025n

.meas tran vdout1_39ck310 FIND v(dout1_39) AT=160.025n

.meas tran vdout1_40ck310 FIND v(dout1_40) AT=160.025n

.meas tran vdout1_41ck310 FIND v(dout1_41) AT=160.025n

.meas tran vdout1_42ck310 FIND v(dout1_42) AT=160.025n

.meas tran vdout1_43ck310 FIND v(dout1_43) AT=160.025n

.meas tran vdout1_44ck310 FIND v(dout1_44) AT=160.025n

.meas tran vdout1_45ck310 FIND v(dout1_45) AT=160.025n

.meas tran vdout1_46ck310 FIND v(dout1_46) AT=160.025n

.meas tran vdout1_47ck310 FIND v(dout1_47) AT=160.025n

.meas tran vdout1_48ck310 FIND v(dout1_48) AT=160.025n

.meas tran vdout1_49ck310 FIND v(dout1_49) AT=160.025n

.meas tran vdout1_50ck310 FIND v(dout1_50) AT=160.025n

.meas tran vdout1_51ck310 FIND v(dout1_51) AT=160.025n

.meas tran vdout1_52ck310 FIND v(dout1_52) AT=160.025n

.meas tran vdout1_53ck310 FIND v(dout1_53) AT=160.025n

.meas tran vdout1_54ck310 FIND v(dout1_54) AT=160.025n

.meas tran vdout1_55ck310 FIND v(dout1_55) AT=160.025n

.meas tran vdout1_56ck310 FIND v(dout1_56) AT=160.025n

.meas tran vdout1_57ck310 FIND v(dout1_57) AT=160.025n

.meas tran vdout1_58ck310 FIND v(dout1_58) AT=160.025n

.meas tran vdout1_59ck310 FIND v(dout1_59) AT=160.025n

.meas tran vdout1_60ck310 FIND v(dout1_60) AT=160.025n

.meas tran vdout1_61ck310 FIND v(dout1_61) AT=160.025n

.meas tran vdout1_62ck310 FIND v(dout1_62) AT=160.025n

.meas tran vdout1_63ck310 FIND v(dout1_63) AT=160.025n

.meas tran vdout1_64ck310 FIND v(dout1_64) AT=160.025n

.meas tran vdout1_65ck310 FIND v(dout1_65) AT=160.025n

.meas tran vdout1_66ck310 FIND v(dout1_66) AT=160.025n

.meas tran vdout1_67ck310 FIND v(dout1_67) AT=160.025n

.meas tran vdout1_68ck310 FIND v(dout1_68) AT=160.025n

.meas tran vdout1_69ck310 FIND v(dout1_69) AT=160.025n

.meas tran vdout1_70ck310 FIND v(dout1_70) AT=160.025n

.meas tran vdout1_71ck310 FIND v(dout1_71) AT=160.025n

.meas tran vdout1_72ck310 FIND v(dout1_72) AT=160.025n

.meas tran vdout1_73ck310 FIND v(dout1_73) AT=160.025n

.meas tran vdout1_74ck310 FIND v(dout1_74) AT=160.025n

.meas tran vdout1_75ck310 FIND v(dout1_75) AT=160.025n

.meas tran vdout1_76ck310 FIND v(dout1_76) AT=160.025n

.meas tran vdout1_77ck310 FIND v(dout1_77) AT=160.025n

.meas tran vdout1_78ck310 FIND v(dout1_78) AT=160.025n

.meas tran vdout1_79ck310 FIND v(dout1_79) AT=160.025n

.meas tran vdout1_80ck310 FIND v(dout1_80) AT=160.025n

.meas tran vdout1_81ck310 FIND v(dout1_81) AT=160.025n

.meas tran vdout1_82ck310 FIND v(dout1_82) AT=160.025n

.meas tran vdout1_83ck310 FIND v(dout1_83) AT=160.025n

.meas tran vdout1_84ck310 FIND v(dout1_84) AT=160.025n

.meas tran vdout1_85ck310 FIND v(dout1_85) AT=160.025n

.meas tran vdout1_86ck310 FIND v(dout1_86) AT=160.025n

.meas tran vdout1_87ck310 FIND v(dout1_87) AT=160.025n

.meas tran vdout1_88ck310 FIND v(dout1_88) AT=160.025n

.meas tran vdout1_89ck310 FIND v(dout1_89) AT=160.025n

.meas tran vdout1_90ck310 FIND v(dout1_90) AT=160.025n

.meas tran vdout1_91ck310 FIND v(dout1_91) AT=160.025n

.meas tran vdout1_92ck310 FIND v(dout1_92) AT=160.025n

.meas tran vdout1_93ck310 FIND v(dout1_93) AT=160.025n

.meas tran vdout1_94ck310 FIND v(dout1_94) AT=160.025n

.meas tran vdout1_95ck310 FIND v(dout1_95) AT=160.025n

.meas tran vdout1_96ck310 FIND v(dout1_96) AT=160.025n

.meas tran vdout1_97ck310 FIND v(dout1_97) AT=160.025n

.meas tran vdout1_98ck310 FIND v(dout1_98) AT=160.025n

.meas tran vdout1_99ck310 FIND v(dout1_99) AT=160.025n

.meas tran vdout1_100ck310 FIND v(dout1_100) AT=160.025n

.meas tran vdout1_101ck310 FIND v(dout1_101) AT=160.025n

.meas tran vdout1_102ck310 FIND v(dout1_102) AT=160.025n

.meas tran vdout1_103ck310 FIND v(dout1_103) AT=160.025n

.meas tran vdout1_104ck310 FIND v(dout1_104) AT=160.025n

.meas tran vdout1_105ck310 FIND v(dout1_105) AT=160.025n

.meas tran vdout1_106ck310 FIND v(dout1_106) AT=160.025n

.meas tran vdout1_107ck310 FIND v(dout1_107) AT=160.025n

.meas tran vdout1_108ck310 FIND v(dout1_108) AT=160.025n

.meas tran vdout1_109ck310 FIND v(dout1_109) AT=160.025n

.meas tran vdout1_110ck310 FIND v(dout1_110) AT=160.025n

.meas tran vdout1_111ck310 FIND v(dout1_111) AT=160.025n

.meas tran vdout1_112ck310 FIND v(dout1_112) AT=160.025n

.meas tran vdout1_113ck310 FIND v(dout1_113) AT=160.025n

.meas tran vdout1_114ck310 FIND v(dout1_114) AT=160.025n

.meas tran vdout1_115ck310 FIND v(dout1_115) AT=160.025n

.meas tran vdout1_116ck310 FIND v(dout1_116) AT=160.025n

.meas tran vdout1_117ck310 FIND v(dout1_117) AT=160.025n

.meas tran vdout1_118ck310 FIND v(dout1_118) AT=160.025n

.meas tran vdout1_119ck310 FIND v(dout1_119) AT=160.025n

.meas tran vdout1_120ck310 FIND v(dout1_120) AT=160.025n

.meas tran vdout1_121ck310 FIND v(dout1_121) AT=160.025n

.meas tran vdout1_122ck310 FIND v(dout1_122) AT=160.025n

.meas tran vdout1_123ck310 FIND v(dout1_123) AT=160.025n

.meas tran vdout1_124ck310 FIND v(dout1_124) AT=160.025n

.meas tran vdout1_125ck310 FIND v(dout1_125) AT=160.025n

.meas tran vdout1_126ck310 FIND v(dout1_126) AT=160.025n

.meas tran vdout1_127ck310 FIND v(dout1_127) AT=160.025n

.meas tran vdout1_0ck350 FIND v(dout1_0) AT=180.025n

.meas tran vdout1_1ck350 FIND v(dout1_1) AT=180.025n

.meas tran vdout1_2ck350 FIND v(dout1_2) AT=180.025n

.meas tran vdout1_3ck350 FIND v(dout1_3) AT=180.025n

.meas tran vdout1_4ck350 FIND v(dout1_4) AT=180.025n

.meas tran vdout1_5ck350 FIND v(dout1_5) AT=180.025n

.meas tran vdout1_6ck350 FIND v(dout1_6) AT=180.025n

.meas tran vdout1_7ck350 FIND v(dout1_7) AT=180.025n

.meas tran vdout1_8ck350 FIND v(dout1_8) AT=180.025n

.meas tran vdout1_9ck350 FIND v(dout1_9) AT=180.025n

.meas tran vdout1_10ck350 FIND v(dout1_10) AT=180.025n

.meas tran vdout1_11ck350 FIND v(dout1_11) AT=180.025n

.meas tran vdout1_12ck350 FIND v(dout1_12) AT=180.025n

.meas tran vdout1_13ck350 FIND v(dout1_13) AT=180.025n

.meas tran vdout1_14ck350 FIND v(dout1_14) AT=180.025n

.meas tran vdout1_15ck350 FIND v(dout1_15) AT=180.025n

.meas tran vdout1_16ck350 FIND v(dout1_16) AT=180.025n

.meas tran vdout1_17ck350 FIND v(dout1_17) AT=180.025n

.meas tran vdout1_18ck350 FIND v(dout1_18) AT=180.025n

.meas tran vdout1_19ck350 FIND v(dout1_19) AT=180.025n

.meas tran vdout1_20ck350 FIND v(dout1_20) AT=180.025n

.meas tran vdout1_21ck350 FIND v(dout1_21) AT=180.025n

.meas tran vdout1_22ck350 FIND v(dout1_22) AT=180.025n

.meas tran vdout1_23ck350 FIND v(dout1_23) AT=180.025n

.meas tran vdout1_24ck350 FIND v(dout1_24) AT=180.025n

.meas tran vdout1_25ck350 FIND v(dout1_25) AT=180.025n

.meas tran vdout1_26ck350 FIND v(dout1_26) AT=180.025n

.meas tran vdout1_27ck350 FIND v(dout1_27) AT=180.025n

.meas tran vdout1_28ck350 FIND v(dout1_28) AT=180.025n

.meas tran vdout1_29ck350 FIND v(dout1_29) AT=180.025n

.meas tran vdout1_30ck350 FIND v(dout1_30) AT=180.025n

.meas tran vdout1_31ck350 FIND v(dout1_31) AT=180.025n

.meas tran vdout1_32ck350 FIND v(dout1_32) AT=180.025n

.meas tran vdout1_33ck350 FIND v(dout1_33) AT=180.025n

.meas tran vdout1_34ck350 FIND v(dout1_34) AT=180.025n

.meas tran vdout1_35ck350 FIND v(dout1_35) AT=180.025n

.meas tran vdout1_36ck350 FIND v(dout1_36) AT=180.025n

.meas tran vdout1_37ck350 FIND v(dout1_37) AT=180.025n

.meas tran vdout1_38ck350 FIND v(dout1_38) AT=180.025n

.meas tran vdout1_39ck350 FIND v(dout1_39) AT=180.025n

.meas tran vdout1_40ck350 FIND v(dout1_40) AT=180.025n

.meas tran vdout1_41ck350 FIND v(dout1_41) AT=180.025n

.meas tran vdout1_42ck350 FIND v(dout1_42) AT=180.025n

.meas tran vdout1_43ck350 FIND v(dout1_43) AT=180.025n

.meas tran vdout1_44ck350 FIND v(dout1_44) AT=180.025n

.meas tran vdout1_45ck350 FIND v(dout1_45) AT=180.025n

.meas tran vdout1_46ck350 FIND v(dout1_46) AT=180.025n

.meas tran vdout1_47ck350 FIND v(dout1_47) AT=180.025n

.meas tran vdout1_48ck350 FIND v(dout1_48) AT=180.025n

.meas tran vdout1_49ck350 FIND v(dout1_49) AT=180.025n

.meas tran vdout1_50ck350 FIND v(dout1_50) AT=180.025n

.meas tran vdout1_51ck350 FIND v(dout1_51) AT=180.025n

.meas tran vdout1_52ck350 FIND v(dout1_52) AT=180.025n

.meas tran vdout1_53ck350 FIND v(dout1_53) AT=180.025n

.meas tran vdout1_54ck350 FIND v(dout1_54) AT=180.025n

.meas tran vdout1_55ck350 FIND v(dout1_55) AT=180.025n

.meas tran vdout1_56ck350 FIND v(dout1_56) AT=180.025n

.meas tran vdout1_57ck350 FIND v(dout1_57) AT=180.025n

.meas tran vdout1_58ck350 FIND v(dout1_58) AT=180.025n

.meas tran vdout1_59ck350 FIND v(dout1_59) AT=180.025n

.meas tran vdout1_60ck350 FIND v(dout1_60) AT=180.025n

.meas tran vdout1_61ck350 FIND v(dout1_61) AT=180.025n

.meas tran vdout1_62ck350 FIND v(dout1_62) AT=180.025n

.meas tran vdout1_63ck350 FIND v(dout1_63) AT=180.025n

.meas tran vdout1_64ck350 FIND v(dout1_64) AT=180.025n

.meas tran vdout1_65ck350 FIND v(dout1_65) AT=180.025n

.meas tran vdout1_66ck350 FIND v(dout1_66) AT=180.025n

.meas tran vdout1_67ck350 FIND v(dout1_67) AT=180.025n

.meas tran vdout1_68ck350 FIND v(dout1_68) AT=180.025n

.meas tran vdout1_69ck350 FIND v(dout1_69) AT=180.025n

.meas tran vdout1_70ck350 FIND v(dout1_70) AT=180.025n

.meas tran vdout1_71ck350 FIND v(dout1_71) AT=180.025n

.meas tran vdout1_72ck350 FIND v(dout1_72) AT=180.025n

.meas tran vdout1_73ck350 FIND v(dout1_73) AT=180.025n

.meas tran vdout1_74ck350 FIND v(dout1_74) AT=180.025n

.meas tran vdout1_75ck350 FIND v(dout1_75) AT=180.025n

.meas tran vdout1_76ck350 FIND v(dout1_76) AT=180.025n

.meas tran vdout1_77ck350 FIND v(dout1_77) AT=180.025n

.meas tran vdout1_78ck350 FIND v(dout1_78) AT=180.025n

.meas tran vdout1_79ck350 FIND v(dout1_79) AT=180.025n

.meas tran vdout1_80ck350 FIND v(dout1_80) AT=180.025n

.meas tran vdout1_81ck350 FIND v(dout1_81) AT=180.025n

.meas tran vdout1_82ck350 FIND v(dout1_82) AT=180.025n

.meas tran vdout1_83ck350 FIND v(dout1_83) AT=180.025n

.meas tran vdout1_84ck350 FIND v(dout1_84) AT=180.025n

.meas tran vdout1_85ck350 FIND v(dout1_85) AT=180.025n

.meas tran vdout1_86ck350 FIND v(dout1_86) AT=180.025n

.meas tran vdout1_87ck350 FIND v(dout1_87) AT=180.025n

.meas tran vdout1_88ck350 FIND v(dout1_88) AT=180.025n

.meas tran vdout1_89ck350 FIND v(dout1_89) AT=180.025n

.meas tran vdout1_90ck350 FIND v(dout1_90) AT=180.025n

.meas tran vdout1_91ck350 FIND v(dout1_91) AT=180.025n

.meas tran vdout1_92ck350 FIND v(dout1_92) AT=180.025n

.meas tran vdout1_93ck350 FIND v(dout1_93) AT=180.025n

.meas tran vdout1_94ck350 FIND v(dout1_94) AT=180.025n

.meas tran vdout1_95ck350 FIND v(dout1_95) AT=180.025n

.meas tran vdout1_96ck350 FIND v(dout1_96) AT=180.025n

.meas tran vdout1_97ck350 FIND v(dout1_97) AT=180.025n

.meas tran vdout1_98ck350 FIND v(dout1_98) AT=180.025n

.meas tran vdout1_99ck350 FIND v(dout1_99) AT=180.025n

.meas tran vdout1_100ck350 FIND v(dout1_100) AT=180.025n

.meas tran vdout1_101ck350 FIND v(dout1_101) AT=180.025n

.meas tran vdout1_102ck350 FIND v(dout1_102) AT=180.025n

.meas tran vdout1_103ck350 FIND v(dout1_103) AT=180.025n

.meas tran vdout1_104ck350 FIND v(dout1_104) AT=180.025n

.meas tran vdout1_105ck350 FIND v(dout1_105) AT=180.025n

.meas tran vdout1_106ck350 FIND v(dout1_106) AT=180.025n

.meas tran vdout1_107ck350 FIND v(dout1_107) AT=180.025n

.meas tran vdout1_108ck350 FIND v(dout1_108) AT=180.025n

.meas tran vdout1_109ck350 FIND v(dout1_109) AT=180.025n

.meas tran vdout1_110ck350 FIND v(dout1_110) AT=180.025n

.meas tran vdout1_111ck350 FIND v(dout1_111) AT=180.025n

.meas tran vdout1_112ck350 FIND v(dout1_112) AT=180.025n

.meas tran vdout1_113ck350 FIND v(dout1_113) AT=180.025n

.meas tran vdout1_114ck350 FIND v(dout1_114) AT=180.025n

.meas tran vdout1_115ck350 FIND v(dout1_115) AT=180.025n

.meas tran vdout1_116ck350 FIND v(dout1_116) AT=180.025n

.meas tran vdout1_117ck350 FIND v(dout1_117) AT=180.025n

.meas tran vdout1_118ck350 FIND v(dout1_118) AT=180.025n

.meas tran vdout1_119ck350 FIND v(dout1_119) AT=180.025n

.meas tran vdout1_120ck350 FIND v(dout1_120) AT=180.025n

.meas tran vdout1_121ck350 FIND v(dout1_121) AT=180.025n

.meas tran vdout1_122ck350 FIND v(dout1_122) AT=180.025n

.meas tran vdout1_123ck350 FIND v(dout1_123) AT=180.025n

.meas tran vdout1_124ck350 FIND v(dout1_124) AT=180.025n

.meas tran vdout1_125ck350 FIND v(dout1_125) AT=180.025n

.meas tran vdout1_126ck350 FIND v(dout1_126) AT=180.025n

.meas tran vdout1_127ck350 FIND v(dout1_127) AT=180.025n

.meas tran vdout1_0ck360 FIND v(dout1_0) AT=185.025n

.meas tran vdout1_1ck360 FIND v(dout1_1) AT=185.025n

.meas tran vdout1_2ck360 FIND v(dout1_2) AT=185.025n

.meas tran vdout1_3ck360 FIND v(dout1_3) AT=185.025n

.meas tran vdout1_4ck360 FIND v(dout1_4) AT=185.025n

.meas tran vdout1_5ck360 FIND v(dout1_5) AT=185.025n

.meas tran vdout1_6ck360 FIND v(dout1_6) AT=185.025n

.meas tran vdout1_7ck360 FIND v(dout1_7) AT=185.025n

.meas tran vdout1_8ck360 FIND v(dout1_8) AT=185.025n

.meas tran vdout1_9ck360 FIND v(dout1_9) AT=185.025n

.meas tran vdout1_10ck360 FIND v(dout1_10) AT=185.025n

.meas tran vdout1_11ck360 FIND v(dout1_11) AT=185.025n

.meas tran vdout1_12ck360 FIND v(dout1_12) AT=185.025n

.meas tran vdout1_13ck360 FIND v(dout1_13) AT=185.025n

.meas tran vdout1_14ck360 FIND v(dout1_14) AT=185.025n

.meas tran vdout1_15ck360 FIND v(dout1_15) AT=185.025n

.meas tran vdout1_16ck360 FIND v(dout1_16) AT=185.025n

.meas tran vdout1_17ck360 FIND v(dout1_17) AT=185.025n

.meas tran vdout1_18ck360 FIND v(dout1_18) AT=185.025n

.meas tran vdout1_19ck360 FIND v(dout1_19) AT=185.025n

.meas tran vdout1_20ck360 FIND v(dout1_20) AT=185.025n

.meas tran vdout1_21ck360 FIND v(dout1_21) AT=185.025n

.meas tran vdout1_22ck360 FIND v(dout1_22) AT=185.025n

.meas tran vdout1_23ck360 FIND v(dout1_23) AT=185.025n

.meas tran vdout1_24ck360 FIND v(dout1_24) AT=185.025n

.meas tran vdout1_25ck360 FIND v(dout1_25) AT=185.025n

.meas tran vdout1_26ck360 FIND v(dout1_26) AT=185.025n

.meas tran vdout1_27ck360 FIND v(dout1_27) AT=185.025n

.meas tran vdout1_28ck360 FIND v(dout1_28) AT=185.025n

.meas tran vdout1_29ck360 FIND v(dout1_29) AT=185.025n

.meas tran vdout1_30ck360 FIND v(dout1_30) AT=185.025n

.meas tran vdout1_31ck360 FIND v(dout1_31) AT=185.025n

.meas tran vdout1_32ck360 FIND v(dout1_32) AT=185.025n

.meas tran vdout1_33ck360 FIND v(dout1_33) AT=185.025n

.meas tran vdout1_34ck360 FIND v(dout1_34) AT=185.025n

.meas tran vdout1_35ck360 FIND v(dout1_35) AT=185.025n

.meas tran vdout1_36ck360 FIND v(dout1_36) AT=185.025n

.meas tran vdout1_37ck360 FIND v(dout1_37) AT=185.025n

.meas tran vdout1_38ck360 FIND v(dout1_38) AT=185.025n

.meas tran vdout1_39ck360 FIND v(dout1_39) AT=185.025n

.meas tran vdout1_40ck360 FIND v(dout1_40) AT=185.025n

.meas tran vdout1_41ck360 FIND v(dout1_41) AT=185.025n

.meas tran vdout1_42ck360 FIND v(dout1_42) AT=185.025n

.meas tran vdout1_43ck360 FIND v(dout1_43) AT=185.025n

.meas tran vdout1_44ck360 FIND v(dout1_44) AT=185.025n

.meas tran vdout1_45ck360 FIND v(dout1_45) AT=185.025n

.meas tran vdout1_46ck360 FIND v(dout1_46) AT=185.025n

.meas tran vdout1_47ck360 FIND v(dout1_47) AT=185.025n

.meas tran vdout1_48ck360 FIND v(dout1_48) AT=185.025n

.meas tran vdout1_49ck360 FIND v(dout1_49) AT=185.025n

.meas tran vdout1_50ck360 FIND v(dout1_50) AT=185.025n

.meas tran vdout1_51ck360 FIND v(dout1_51) AT=185.025n

.meas tran vdout1_52ck360 FIND v(dout1_52) AT=185.025n

.meas tran vdout1_53ck360 FIND v(dout1_53) AT=185.025n

.meas tran vdout1_54ck360 FIND v(dout1_54) AT=185.025n

.meas tran vdout1_55ck360 FIND v(dout1_55) AT=185.025n

.meas tran vdout1_56ck360 FIND v(dout1_56) AT=185.025n

.meas tran vdout1_57ck360 FIND v(dout1_57) AT=185.025n

.meas tran vdout1_58ck360 FIND v(dout1_58) AT=185.025n

.meas tran vdout1_59ck360 FIND v(dout1_59) AT=185.025n

.meas tran vdout1_60ck360 FIND v(dout1_60) AT=185.025n

.meas tran vdout1_61ck360 FIND v(dout1_61) AT=185.025n

.meas tran vdout1_62ck360 FIND v(dout1_62) AT=185.025n

.meas tran vdout1_63ck360 FIND v(dout1_63) AT=185.025n

.meas tran vdout1_64ck360 FIND v(dout1_64) AT=185.025n

.meas tran vdout1_65ck360 FIND v(dout1_65) AT=185.025n

.meas tran vdout1_66ck360 FIND v(dout1_66) AT=185.025n

.meas tran vdout1_67ck360 FIND v(dout1_67) AT=185.025n

.meas tran vdout1_68ck360 FIND v(dout1_68) AT=185.025n

.meas tran vdout1_69ck360 FIND v(dout1_69) AT=185.025n

.meas tran vdout1_70ck360 FIND v(dout1_70) AT=185.025n

.meas tran vdout1_71ck360 FIND v(dout1_71) AT=185.025n

.meas tran vdout1_72ck360 FIND v(dout1_72) AT=185.025n

.meas tran vdout1_73ck360 FIND v(dout1_73) AT=185.025n

.meas tran vdout1_74ck360 FIND v(dout1_74) AT=185.025n

.meas tran vdout1_75ck360 FIND v(dout1_75) AT=185.025n

.meas tran vdout1_76ck360 FIND v(dout1_76) AT=185.025n

.meas tran vdout1_77ck360 FIND v(dout1_77) AT=185.025n

.meas tran vdout1_78ck360 FIND v(dout1_78) AT=185.025n

.meas tran vdout1_79ck360 FIND v(dout1_79) AT=185.025n

.meas tran vdout1_80ck360 FIND v(dout1_80) AT=185.025n

.meas tran vdout1_81ck360 FIND v(dout1_81) AT=185.025n

.meas tran vdout1_82ck360 FIND v(dout1_82) AT=185.025n

.meas tran vdout1_83ck360 FIND v(dout1_83) AT=185.025n

.meas tran vdout1_84ck360 FIND v(dout1_84) AT=185.025n

.meas tran vdout1_85ck360 FIND v(dout1_85) AT=185.025n

.meas tran vdout1_86ck360 FIND v(dout1_86) AT=185.025n

.meas tran vdout1_87ck360 FIND v(dout1_87) AT=185.025n

.meas tran vdout1_88ck360 FIND v(dout1_88) AT=185.025n

.meas tran vdout1_89ck360 FIND v(dout1_89) AT=185.025n

.meas tran vdout1_90ck360 FIND v(dout1_90) AT=185.025n

.meas tran vdout1_91ck360 FIND v(dout1_91) AT=185.025n

.meas tran vdout1_92ck360 FIND v(dout1_92) AT=185.025n

.meas tran vdout1_93ck360 FIND v(dout1_93) AT=185.025n

.meas tran vdout1_94ck360 FIND v(dout1_94) AT=185.025n

.meas tran vdout1_95ck360 FIND v(dout1_95) AT=185.025n

.meas tran vdout1_96ck360 FIND v(dout1_96) AT=185.025n

.meas tran vdout1_97ck360 FIND v(dout1_97) AT=185.025n

.meas tran vdout1_98ck360 FIND v(dout1_98) AT=185.025n

.meas tran vdout1_99ck360 FIND v(dout1_99) AT=185.025n

.meas tran vdout1_100ck360 FIND v(dout1_100) AT=185.025n

.meas tran vdout1_101ck360 FIND v(dout1_101) AT=185.025n

.meas tran vdout1_102ck360 FIND v(dout1_102) AT=185.025n

.meas tran vdout1_103ck360 FIND v(dout1_103) AT=185.025n

.meas tran vdout1_104ck360 FIND v(dout1_104) AT=185.025n

.meas tran vdout1_105ck360 FIND v(dout1_105) AT=185.025n

.meas tran vdout1_106ck360 FIND v(dout1_106) AT=185.025n

.meas tran vdout1_107ck360 FIND v(dout1_107) AT=185.025n

.meas tran vdout1_108ck360 FIND v(dout1_108) AT=185.025n

.meas tran vdout1_109ck360 FIND v(dout1_109) AT=185.025n

.meas tran vdout1_110ck360 FIND v(dout1_110) AT=185.025n

.meas tran vdout1_111ck360 FIND v(dout1_111) AT=185.025n

.meas tran vdout1_112ck360 FIND v(dout1_112) AT=185.025n

.meas tran vdout1_113ck360 FIND v(dout1_113) AT=185.025n

.meas tran vdout1_114ck360 FIND v(dout1_114) AT=185.025n

.meas tran vdout1_115ck360 FIND v(dout1_115) AT=185.025n

.meas tran vdout1_116ck360 FIND v(dout1_116) AT=185.025n

.meas tran vdout1_117ck360 FIND v(dout1_117) AT=185.025n

.meas tran vdout1_118ck360 FIND v(dout1_118) AT=185.025n

.meas tran vdout1_119ck360 FIND v(dout1_119) AT=185.025n

.meas tran vdout1_120ck360 FIND v(dout1_120) AT=185.025n

.meas tran vdout1_121ck360 FIND v(dout1_121) AT=185.025n

.meas tran vdout1_122ck360 FIND v(dout1_122) AT=185.025n

.meas tran vdout1_123ck360 FIND v(dout1_123) AT=185.025n

.meas tran vdout1_124ck360 FIND v(dout1_124) AT=185.025n

.meas tran vdout1_125ck360 FIND v(dout1_125) AT=185.025n

.meas tran vdout1_126ck360 FIND v(dout1_126) AT=185.025n

.meas tran vdout1_127ck360 FIND v(dout1_127) AT=185.025n

.meas tran vdout1_0ck370 FIND v(dout1_0) AT=190.025n

.meas tran vdout1_1ck370 FIND v(dout1_1) AT=190.025n

.meas tran vdout1_2ck370 FIND v(dout1_2) AT=190.025n

.meas tran vdout1_3ck370 FIND v(dout1_3) AT=190.025n

.meas tran vdout1_4ck370 FIND v(dout1_4) AT=190.025n

.meas tran vdout1_5ck370 FIND v(dout1_5) AT=190.025n

.meas tran vdout1_6ck370 FIND v(dout1_6) AT=190.025n

.meas tran vdout1_7ck370 FIND v(dout1_7) AT=190.025n

.meas tran vdout1_8ck370 FIND v(dout1_8) AT=190.025n

.meas tran vdout1_9ck370 FIND v(dout1_9) AT=190.025n

.meas tran vdout1_10ck370 FIND v(dout1_10) AT=190.025n

.meas tran vdout1_11ck370 FIND v(dout1_11) AT=190.025n

.meas tran vdout1_12ck370 FIND v(dout1_12) AT=190.025n

.meas tran vdout1_13ck370 FIND v(dout1_13) AT=190.025n

.meas tran vdout1_14ck370 FIND v(dout1_14) AT=190.025n

.meas tran vdout1_15ck370 FIND v(dout1_15) AT=190.025n

.meas tran vdout1_16ck370 FIND v(dout1_16) AT=190.025n

.meas tran vdout1_17ck370 FIND v(dout1_17) AT=190.025n

.meas tran vdout1_18ck370 FIND v(dout1_18) AT=190.025n

.meas tran vdout1_19ck370 FIND v(dout1_19) AT=190.025n

.meas tran vdout1_20ck370 FIND v(dout1_20) AT=190.025n

.meas tran vdout1_21ck370 FIND v(dout1_21) AT=190.025n

.meas tran vdout1_22ck370 FIND v(dout1_22) AT=190.025n

.meas tran vdout1_23ck370 FIND v(dout1_23) AT=190.025n

.meas tran vdout1_24ck370 FIND v(dout1_24) AT=190.025n

.meas tran vdout1_25ck370 FIND v(dout1_25) AT=190.025n

.meas tran vdout1_26ck370 FIND v(dout1_26) AT=190.025n

.meas tran vdout1_27ck370 FIND v(dout1_27) AT=190.025n

.meas tran vdout1_28ck370 FIND v(dout1_28) AT=190.025n

.meas tran vdout1_29ck370 FIND v(dout1_29) AT=190.025n

.meas tran vdout1_30ck370 FIND v(dout1_30) AT=190.025n

.meas tran vdout1_31ck370 FIND v(dout1_31) AT=190.025n

.meas tran vdout1_32ck370 FIND v(dout1_32) AT=190.025n

.meas tran vdout1_33ck370 FIND v(dout1_33) AT=190.025n

.meas tran vdout1_34ck370 FIND v(dout1_34) AT=190.025n

.meas tran vdout1_35ck370 FIND v(dout1_35) AT=190.025n

.meas tran vdout1_36ck370 FIND v(dout1_36) AT=190.025n

.meas tran vdout1_37ck370 FIND v(dout1_37) AT=190.025n

.meas tran vdout1_38ck370 FIND v(dout1_38) AT=190.025n

.meas tran vdout1_39ck370 FIND v(dout1_39) AT=190.025n

.meas tran vdout1_40ck370 FIND v(dout1_40) AT=190.025n

.meas tran vdout1_41ck370 FIND v(dout1_41) AT=190.025n

.meas tran vdout1_42ck370 FIND v(dout1_42) AT=190.025n

.meas tran vdout1_43ck370 FIND v(dout1_43) AT=190.025n

.meas tran vdout1_44ck370 FIND v(dout1_44) AT=190.025n

.meas tran vdout1_45ck370 FIND v(dout1_45) AT=190.025n

.meas tran vdout1_46ck370 FIND v(dout1_46) AT=190.025n

.meas tran vdout1_47ck370 FIND v(dout1_47) AT=190.025n

.meas tran vdout1_48ck370 FIND v(dout1_48) AT=190.025n

.meas tran vdout1_49ck370 FIND v(dout1_49) AT=190.025n

.meas tran vdout1_50ck370 FIND v(dout1_50) AT=190.025n

.meas tran vdout1_51ck370 FIND v(dout1_51) AT=190.025n

.meas tran vdout1_52ck370 FIND v(dout1_52) AT=190.025n

.meas tran vdout1_53ck370 FIND v(dout1_53) AT=190.025n

.meas tran vdout1_54ck370 FIND v(dout1_54) AT=190.025n

.meas tran vdout1_55ck370 FIND v(dout1_55) AT=190.025n

.meas tran vdout1_56ck370 FIND v(dout1_56) AT=190.025n

.meas tran vdout1_57ck370 FIND v(dout1_57) AT=190.025n

.meas tran vdout1_58ck370 FIND v(dout1_58) AT=190.025n

.meas tran vdout1_59ck370 FIND v(dout1_59) AT=190.025n

.meas tran vdout1_60ck370 FIND v(dout1_60) AT=190.025n

.meas tran vdout1_61ck370 FIND v(dout1_61) AT=190.025n

.meas tran vdout1_62ck370 FIND v(dout1_62) AT=190.025n

.meas tran vdout1_63ck370 FIND v(dout1_63) AT=190.025n

.meas tran vdout1_64ck370 FIND v(dout1_64) AT=190.025n

.meas tran vdout1_65ck370 FIND v(dout1_65) AT=190.025n

.meas tran vdout1_66ck370 FIND v(dout1_66) AT=190.025n

.meas tran vdout1_67ck370 FIND v(dout1_67) AT=190.025n

.meas tran vdout1_68ck370 FIND v(dout1_68) AT=190.025n

.meas tran vdout1_69ck370 FIND v(dout1_69) AT=190.025n

.meas tran vdout1_70ck370 FIND v(dout1_70) AT=190.025n

.meas tran vdout1_71ck370 FIND v(dout1_71) AT=190.025n

.meas tran vdout1_72ck370 FIND v(dout1_72) AT=190.025n

.meas tran vdout1_73ck370 FIND v(dout1_73) AT=190.025n

.meas tran vdout1_74ck370 FIND v(dout1_74) AT=190.025n

.meas tran vdout1_75ck370 FIND v(dout1_75) AT=190.025n

.meas tran vdout1_76ck370 FIND v(dout1_76) AT=190.025n

.meas tran vdout1_77ck370 FIND v(dout1_77) AT=190.025n

.meas tran vdout1_78ck370 FIND v(dout1_78) AT=190.025n

.meas tran vdout1_79ck370 FIND v(dout1_79) AT=190.025n

.meas tran vdout1_80ck370 FIND v(dout1_80) AT=190.025n

.meas tran vdout1_81ck370 FIND v(dout1_81) AT=190.025n

.meas tran vdout1_82ck370 FIND v(dout1_82) AT=190.025n

.meas tran vdout1_83ck370 FIND v(dout1_83) AT=190.025n

.meas tran vdout1_84ck370 FIND v(dout1_84) AT=190.025n

.meas tran vdout1_85ck370 FIND v(dout1_85) AT=190.025n

.meas tran vdout1_86ck370 FIND v(dout1_86) AT=190.025n

.meas tran vdout1_87ck370 FIND v(dout1_87) AT=190.025n

.meas tran vdout1_88ck370 FIND v(dout1_88) AT=190.025n

.meas tran vdout1_89ck370 FIND v(dout1_89) AT=190.025n

.meas tran vdout1_90ck370 FIND v(dout1_90) AT=190.025n

.meas tran vdout1_91ck370 FIND v(dout1_91) AT=190.025n

.meas tran vdout1_92ck370 FIND v(dout1_92) AT=190.025n

.meas tran vdout1_93ck370 FIND v(dout1_93) AT=190.025n

.meas tran vdout1_94ck370 FIND v(dout1_94) AT=190.025n

.meas tran vdout1_95ck370 FIND v(dout1_95) AT=190.025n

.meas tran vdout1_96ck370 FIND v(dout1_96) AT=190.025n

.meas tran vdout1_97ck370 FIND v(dout1_97) AT=190.025n

.meas tran vdout1_98ck370 FIND v(dout1_98) AT=190.025n

.meas tran vdout1_99ck370 FIND v(dout1_99) AT=190.025n

.meas tran vdout1_100ck370 FIND v(dout1_100) AT=190.025n

.meas tran vdout1_101ck370 FIND v(dout1_101) AT=190.025n

.meas tran vdout1_102ck370 FIND v(dout1_102) AT=190.025n

.meas tran vdout1_103ck370 FIND v(dout1_103) AT=190.025n

.meas tran vdout1_104ck370 FIND v(dout1_104) AT=190.025n

.meas tran vdout1_105ck370 FIND v(dout1_105) AT=190.025n

.meas tran vdout1_106ck370 FIND v(dout1_106) AT=190.025n

.meas tran vdout1_107ck370 FIND v(dout1_107) AT=190.025n

.meas tran vdout1_108ck370 FIND v(dout1_108) AT=190.025n

.meas tran vdout1_109ck370 FIND v(dout1_109) AT=190.025n

.meas tran vdout1_110ck370 FIND v(dout1_110) AT=190.025n

.meas tran vdout1_111ck370 FIND v(dout1_111) AT=190.025n

.meas tran vdout1_112ck370 FIND v(dout1_112) AT=190.025n

.meas tran vdout1_113ck370 FIND v(dout1_113) AT=190.025n

.meas tran vdout1_114ck370 FIND v(dout1_114) AT=190.025n

.meas tran vdout1_115ck370 FIND v(dout1_115) AT=190.025n

.meas tran vdout1_116ck370 FIND v(dout1_116) AT=190.025n

.meas tran vdout1_117ck370 FIND v(dout1_117) AT=190.025n

.meas tran vdout1_118ck370 FIND v(dout1_118) AT=190.025n

.meas tran vdout1_119ck370 FIND v(dout1_119) AT=190.025n

.meas tran vdout1_120ck370 FIND v(dout1_120) AT=190.025n

.meas tran vdout1_121ck370 FIND v(dout1_121) AT=190.025n

.meas tran vdout1_122ck370 FIND v(dout1_122) AT=190.025n

.meas tran vdout1_123ck370 FIND v(dout1_123) AT=190.025n

.meas tran vdout1_124ck370 FIND v(dout1_124) AT=190.025n

.meas tran vdout1_125ck370 FIND v(dout1_125) AT=190.025n

.meas tran vdout1_126ck370 FIND v(dout1_126) AT=190.025n

.meas tran vdout1_127ck370 FIND v(dout1_127) AT=190.025n

.meas tran vdout1_0ck390 FIND v(dout1_0) AT=200.025n

.meas tran vdout1_1ck390 FIND v(dout1_1) AT=200.025n

.meas tran vdout1_2ck390 FIND v(dout1_2) AT=200.025n

.meas tran vdout1_3ck390 FIND v(dout1_3) AT=200.025n

.meas tran vdout1_4ck390 FIND v(dout1_4) AT=200.025n

.meas tran vdout1_5ck390 FIND v(dout1_5) AT=200.025n

.meas tran vdout1_6ck390 FIND v(dout1_6) AT=200.025n

.meas tran vdout1_7ck390 FIND v(dout1_7) AT=200.025n

.meas tran vdout1_8ck390 FIND v(dout1_8) AT=200.025n

.meas tran vdout1_9ck390 FIND v(dout1_9) AT=200.025n

.meas tran vdout1_10ck390 FIND v(dout1_10) AT=200.025n

.meas tran vdout1_11ck390 FIND v(dout1_11) AT=200.025n

.meas tran vdout1_12ck390 FIND v(dout1_12) AT=200.025n

.meas tran vdout1_13ck390 FIND v(dout1_13) AT=200.025n

.meas tran vdout1_14ck390 FIND v(dout1_14) AT=200.025n

.meas tran vdout1_15ck390 FIND v(dout1_15) AT=200.025n

.meas tran vdout1_16ck390 FIND v(dout1_16) AT=200.025n

.meas tran vdout1_17ck390 FIND v(dout1_17) AT=200.025n

.meas tran vdout1_18ck390 FIND v(dout1_18) AT=200.025n

.meas tran vdout1_19ck390 FIND v(dout1_19) AT=200.025n

.meas tran vdout1_20ck390 FIND v(dout1_20) AT=200.025n

.meas tran vdout1_21ck390 FIND v(dout1_21) AT=200.025n

.meas tran vdout1_22ck390 FIND v(dout1_22) AT=200.025n

.meas tran vdout1_23ck390 FIND v(dout1_23) AT=200.025n

.meas tran vdout1_24ck390 FIND v(dout1_24) AT=200.025n

.meas tran vdout1_25ck390 FIND v(dout1_25) AT=200.025n

.meas tran vdout1_26ck390 FIND v(dout1_26) AT=200.025n

.meas tran vdout1_27ck390 FIND v(dout1_27) AT=200.025n

.meas tran vdout1_28ck390 FIND v(dout1_28) AT=200.025n

.meas tran vdout1_29ck390 FIND v(dout1_29) AT=200.025n

.meas tran vdout1_30ck390 FIND v(dout1_30) AT=200.025n

.meas tran vdout1_31ck390 FIND v(dout1_31) AT=200.025n

.meas tran vdout1_32ck390 FIND v(dout1_32) AT=200.025n

.meas tran vdout1_33ck390 FIND v(dout1_33) AT=200.025n

.meas tran vdout1_34ck390 FIND v(dout1_34) AT=200.025n

.meas tran vdout1_35ck390 FIND v(dout1_35) AT=200.025n

.meas tran vdout1_36ck390 FIND v(dout1_36) AT=200.025n

.meas tran vdout1_37ck390 FIND v(dout1_37) AT=200.025n

.meas tran vdout1_38ck390 FIND v(dout1_38) AT=200.025n

.meas tran vdout1_39ck390 FIND v(dout1_39) AT=200.025n

.meas tran vdout1_40ck390 FIND v(dout1_40) AT=200.025n

.meas tran vdout1_41ck390 FIND v(dout1_41) AT=200.025n

.meas tran vdout1_42ck390 FIND v(dout1_42) AT=200.025n

.meas tran vdout1_43ck390 FIND v(dout1_43) AT=200.025n

.meas tran vdout1_44ck390 FIND v(dout1_44) AT=200.025n

.meas tran vdout1_45ck390 FIND v(dout1_45) AT=200.025n

.meas tran vdout1_46ck390 FIND v(dout1_46) AT=200.025n

.meas tran vdout1_47ck390 FIND v(dout1_47) AT=200.025n

.meas tran vdout1_48ck390 FIND v(dout1_48) AT=200.025n

.meas tran vdout1_49ck390 FIND v(dout1_49) AT=200.025n

.meas tran vdout1_50ck390 FIND v(dout1_50) AT=200.025n

.meas tran vdout1_51ck390 FIND v(dout1_51) AT=200.025n

.meas tran vdout1_52ck390 FIND v(dout1_52) AT=200.025n

.meas tran vdout1_53ck390 FIND v(dout1_53) AT=200.025n

.meas tran vdout1_54ck390 FIND v(dout1_54) AT=200.025n

.meas tran vdout1_55ck390 FIND v(dout1_55) AT=200.025n

.meas tran vdout1_56ck390 FIND v(dout1_56) AT=200.025n

.meas tran vdout1_57ck390 FIND v(dout1_57) AT=200.025n

.meas tran vdout1_58ck390 FIND v(dout1_58) AT=200.025n

.meas tran vdout1_59ck390 FIND v(dout1_59) AT=200.025n

.meas tran vdout1_60ck390 FIND v(dout1_60) AT=200.025n

.meas tran vdout1_61ck390 FIND v(dout1_61) AT=200.025n

.meas tran vdout1_62ck390 FIND v(dout1_62) AT=200.025n

.meas tran vdout1_63ck390 FIND v(dout1_63) AT=200.025n

.meas tran vdout1_64ck390 FIND v(dout1_64) AT=200.025n

.meas tran vdout1_65ck390 FIND v(dout1_65) AT=200.025n

.meas tran vdout1_66ck390 FIND v(dout1_66) AT=200.025n

.meas tran vdout1_67ck390 FIND v(dout1_67) AT=200.025n

.meas tran vdout1_68ck390 FIND v(dout1_68) AT=200.025n

.meas tran vdout1_69ck390 FIND v(dout1_69) AT=200.025n

.meas tran vdout1_70ck390 FIND v(dout1_70) AT=200.025n

.meas tran vdout1_71ck390 FIND v(dout1_71) AT=200.025n

.meas tran vdout1_72ck390 FIND v(dout1_72) AT=200.025n

.meas tran vdout1_73ck390 FIND v(dout1_73) AT=200.025n

.meas tran vdout1_74ck390 FIND v(dout1_74) AT=200.025n

.meas tran vdout1_75ck390 FIND v(dout1_75) AT=200.025n

.meas tran vdout1_76ck390 FIND v(dout1_76) AT=200.025n

.meas tran vdout1_77ck390 FIND v(dout1_77) AT=200.025n

.meas tran vdout1_78ck390 FIND v(dout1_78) AT=200.025n

.meas tran vdout1_79ck390 FIND v(dout1_79) AT=200.025n

.meas tran vdout1_80ck390 FIND v(dout1_80) AT=200.025n

.meas tran vdout1_81ck390 FIND v(dout1_81) AT=200.025n

.meas tran vdout1_82ck390 FIND v(dout1_82) AT=200.025n

.meas tran vdout1_83ck390 FIND v(dout1_83) AT=200.025n

.meas tran vdout1_84ck390 FIND v(dout1_84) AT=200.025n

.meas tran vdout1_85ck390 FIND v(dout1_85) AT=200.025n

.meas tran vdout1_86ck390 FIND v(dout1_86) AT=200.025n

.meas tran vdout1_87ck390 FIND v(dout1_87) AT=200.025n

.meas tran vdout1_88ck390 FIND v(dout1_88) AT=200.025n

.meas tran vdout1_89ck390 FIND v(dout1_89) AT=200.025n

.meas tran vdout1_90ck390 FIND v(dout1_90) AT=200.025n

.meas tran vdout1_91ck390 FIND v(dout1_91) AT=200.025n

.meas tran vdout1_92ck390 FIND v(dout1_92) AT=200.025n

.meas tran vdout1_93ck390 FIND v(dout1_93) AT=200.025n

.meas tran vdout1_94ck390 FIND v(dout1_94) AT=200.025n

.meas tran vdout1_95ck390 FIND v(dout1_95) AT=200.025n

.meas tran vdout1_96ck390 FIND v(dout1_96) AT=200.025n

.meas tran vdout1_97ck390 FIND v(dout1_97) AT=200.025n

.meas tran vdout1_98ck390 FIND v(dout1_98) AT=200.025n

.meas tran vdout1_99ck390 FIND v(dout1_99) AT=200.025n

.meas tran vdout1_100ck390 FIND v(dout1_100) AT=200.025n

.meas tran vdout1_101ck390 FIND v(dout1_101) AT=200.025n

.meas tran vdout1_102ck390 FIND v(dout1_102) AT=200.025n

.meas tran vdout1_103ck390 FIND v(dout1_103) AT=200.025n

.meas tran vdout1_104ck390 FIND v(dout1_104) AT=200.025n

.meas tran vdout1_105ck390 FIND v(dout1_105) AT=200.025n

.meas tran vdout1_106ck390 FIND v(dout1_106) AT=200.025n

.meas tran vdout1_107ck390 FIND v(dout1_107) AT=200.025n

.meas tran vdout1_108ck390 FIND v(dout1_108) AT=200.025n

.meas tran vdout1_109ck390 FIND v(dout1_109) AT=200.025n

.meas tran vdout1_110ck390 FIND v(dout1_110) AT=200.025n

.meas tran vdout1_111ck390 FIND v(dout1_111) AT=200.025n

.meas tran vdout1_112ck390 FIND v(dout1_112) AT=200.025n

.meas tran vdout1_113ck390 FIND v(dout1_113) AT=200.025n

.meas tran vdout1_114ck390 FIND v(dout1_114) AT=200.025n

.meas tran vdout1_115ck390 FIND v(dout1_115) AT=200.025n

.meas tran vdout1_116ck390 FIND v(dout1_116) AT=200.025n

.meas tran vdout1_117ck390 FIND v(dout1_117) AT=200.025n

.meas tran vdout1_118ck390 FIND v(dout1_118) AT=200.025n

.meas tran vdout1_119ck390 FIND v(dout1_119) AT=200.025n

.meas tran vdout1_120ck390 FIND v(dout1_120) AT=200.025n

.meas tran vdout1_121ck390 FIND v(dout1_121) AT=200.025n

.meas tran vdout1_122ck390 FIND v(dout1_122) AT=200.025n

.meas tran vdout1_123ck390 FIND v(dout1_123) AT=200.025n

.meas tran vdout1_124ck390 FIND v(dout1_124) AT=200.025n

.meas tran vdout1_125ck390 FIND v(dout1_125) AT=200.025n

.meas tran vdout1_126ck390 FIND v(dout1_126) AT=200.025n

.meas tran vdout1_127ck390 FIND v(dout1_127) AT=200.025n

.meas tran vdout1_0ck430 FIND v(dout1_0) AT=220.025n

.meas tran vdout1_1ck430 FIND v(dout1_1) AT=220.025n

.meas tran vdout1_2ck430 FIND v(dout1_2) AT=220.025n

.meas tran vdout1_3ck430 FIND v(dout1_3) AT=220.025n

.meas tran vdout1_4ck430 FIND v(dout1_4) AT=220.025n

.meas tran vdout1_5ck430 FIND v(dout1_5) AT=220.025n

.meas tran vdout1_6ck430 FIND v(dout1_6) AT=220.025n

.meas tran vdout1_7ck430 FIND v(dout1_7) AT=220.025n

.meas tran vdout1_8ck430 FIND v(dout1_8) AT=220.025n

.meas tran vdout1_9ck430 FIND v(dout1_9) AT=220.025n

.meas tran vdout1_10ck430 FIND v(dout1_10) AT=220.025n

.meas tran vdout1_11ck430 FIND v(dout1_11) AT=220.025n

.meas tran vdout1_12ck430 FIND v(dout1_12) AT=220.025n

.meas tran vdout1_13ck430 FIND v(dout1_13) AT=220.025n

.meas tran vdout1_14ck430 FIND v(dout1_14) AT=220.025n

.meas tran vdout1_15ck430 FIND v(dout1_15) AT=220.025n

.meas tran vdout1_16ck430 FIND v(dout1_16) AT=220.025n

.meas tran vdout1_17ck430 FIND v(dout1_17) AT=220.025n

.meas tran vdout1_18ck430 FIND v(dout1_18) AT=220.025n

.meas tran vdout1_19ck430 FIND v(dout1_19) AT=220.025n

.meas tran vdout1_20ck430 FIND v(dout1_20) AT=220.025n

.meas tran vdout1_21ck430 FIND v(dout1_21) AT=220.025n

.meas tran vdout1_22ck430 FIND v(dout1_22) AT=220.025n

.meas tran vdout1_23ck430 FIND v(dout1_23) AT=220.025n

.meas tran vdout1_24ck430 FIND v(dout1_24) AT=220.025n

.meas tran vdout1_25ck430 FIND v(dout1_25) AT=220.025n

.meas tran vdout1_26ck430 FIND v(dout1_26) AT=220.025n

.meas tran vdout1_27ck430 FIND v(dout1_27) AT=220.025n

.meas tran vdout1_28ck430 FIND v(dout1_28) AT=220.025n

.meas tran vdout1_29ck430 FIND v(dout1_29) AT=220.025n

.meas tran vdout1_30ck430 FIND v(dout1_30) AT=220.025n

.meas tran vdout1_31ck430 FIND v(dout1_31) AT=220.025n

.meas tran vdout1_32ck430 FIND v(dout1_32) AT=220.025n

.meas tran vdout1_33ck430 FIND v(dout1_33) AT=220.025n

.meas tran vdout1_34ck430 FIND v(dout1_34) AT=220.025n

.meas tran vdout1_35ck430 FIND v(dout1_35) AT=220.025n

.meas tran vdout1_36ck430 FIND v(dout1_36) AT=220.025n

.meas tran vdout1_37ck430 FIND v(dout1_37) AT=220.025n

.meas tran vdout1_38ck430 FIND v(dout1_38) AT=220.025n

.meas tran vdout1_39ck430 FIND v(dout1_39) AT=220.025n

.meas tran vdout1_40ck430 FIND v(dout1_40) AT=220.025n

.meas tran vdout1_41ck430 FIND v(dout1_41) AT=220.025n

.meas tran vdout1_42ck430 FIND v(dout1_42) AT=220.025n

.meas tran vdout1_43ck430 FIND v(dout1_43) AT=220.025n

.meas tran vdout1_44ck430 FIND v(dout1_44) AT=220.025n

.meas tran vdout1_45ck430 FIND v(dout1_45) AT=220.025n

.meas tran vdout1_46ck430 FIND v(dout1_46) AT=220.025n

.meas tran vdout1_47ck430 FIND v(dout1_47) AT=220.025n

.meas tran vdout1_48ck430 FIND v(dout1_48) AT=220.025n

.meas tran vdout1_49ck430 FIND v(dout1_49) AT=220.025n

.meas tran vdout1_50ck430 FIND v(dout1_50) AT=220.025n

.meas tran vdout1_51ck430 FIND v(dout1_51) AT=220.025n

.meas tran vdout1_52ck430 FIND v(dout1_52) AT=220.025n

.meas tran vdout1_53ck430 FIND v(dout1_53) AT=220.025n

.meas tran vdout1_54ck430 FIND v(dout1_54) AT=220.025n

.meas tran vdout1_55ck430 FIND v(dout1_55) AT=220.025n

.meas tran vdout1_56ck430 FIND v(dout1_56) AT=220.025n

.meas tran vdout1_57ck430 FIND v(dout1_57) AT=220.025n

.meas tran vdout1_58ck430 FIND v(dout1_58) AT=220.025n

.meas tran vdout1_59ck430 FIND v(dout1_59) AT=220.025n

.meas tran vdout1_60ck430 FIND v(dout1_60) AT=220.025n

.meas tran vdout1_61ck430 FIND v(dout1_61) AT=220.025n

.meas tran vdout1_62ck430 FIND v(dout1_62) AT=220.025n

.meas tran vdout1_63ck430 FIND v(dout1_63) AT=220.025n

.meas tran vdout1_64ck430 FIND v(dout1_64) AT=220.025n

.meas tran vdout1_65ck430 FIND v(dout1_65) AT=220.025n

.meas tran vdout1_66ck430 FIND v(dout1_66) AT=220.025n

.meas tran vdout1_67ck430 FIND v(dout1_67) AT=220.025n

.meas tran vdout1_68ck430 FIND v(dout1_68) AT=220.025n

.meas tran vdout1_69ck430 FIND v(dout1_69) AT=220.025n

.meas tran vdout1_70ck430 FIND v(dout1_70) AT=220.025n

.meas tran vdout1_71ck430 FIND v(dout1_71) AT=220.025n

.meas tran vdout1_72ck430 FIND v(dout1_72) AT=220.025n

.meas tran vdout1_73ck430 FIND v(dout1_73) AT=220.025n

.meas tran vdout1_74ck430 FIND v(dout1_74) AT=220.025n

.meas tran vdout1_75ck430 FIND v(dout1_75) AT=220.025n

.meas tran vdout1_76ck430 FIND v(dout1_76) AT=220.025n

.meas tran vdout1_77ck430 FIND v(dout1_77) AT=220.025n

.meas tran vdout1_78ck430 FIND v(dout1_78) AT=220.025n

.meas tran vdout1_79ck430 FIND v(dout1_79) AT=220.025n

.meas tran vdout1_80ck430 FIND v(dout1_80) AT=220.025n

.meas tran vdout1_81ck430 FIND v(dout1_81) AT=220.025n

.meas tran vdout1_82ck430 FIND v(dout1_82) AT=220.025n

.meas tran vdout1_83ck430 FIND v(dout1_83) AT=220.025n

.meas tran vdout1_84ck430 FIND v(dout1_84) AT=220.025n

.meas tran vdout1_85ck430 FIND v(dout1_85) AT=220.025n

.meas tran vdout1_86ck430 FIND v(dout1_86) AT=220.025n

.meas tran vdout1_87ck430 FIND v(dout1_87) AT=220.025n

.meas tran vdout1_88ck430 FIND v(dout1_88) AT=220.025n

.meas tran vdout1_89ck430 FIND v(dout1_89) AT=220.025n

.meas tran vdout1_90ck430 FIND v(dout1_90) AT=220.025n

.meas tran vdout1_91ck430 FIND v(dout1_91) AT=220.025n

.meas tran vdout1_92ck430 FIND v(dout1_92) AT=220.025n

.meas tran vdout1_93ck430 FIND v(dout1_93) AT=220.025n

.meas tran vdout1_94ck430 FIND v(dout1_94) AT=220.025n

.meas tran vdout1_95ck430 FIND v(dout1_95) AT=220.025n

.meas tran vdout1_96ck430 FIND v(dout1_96) AT=220.025n

.meas tran vdout1_97ck430 FIND v(dout1_97) AT=220.025n

.meas tran vdout1_98ck430 FIND v(dout1_98) AT=220.025n

.meas tran vdout1_99ck430 FIND v(dout1_99) AT=220.025n

.meas tran vdout1_100ck430 FIND v(dout1_100) AT=220.025n

.meas tran vdout1_101ck430 FIND v(dout1_101) AT=220.025n

.meas tran vdout1_102ck430 FIND v(dout1_102) AT=220.025n

.meas tran vdout1_103ck430 FIND v(dout1_103) AT=220.025n

.meas tran vdout1_104ck430 FIND v(dout1_104) AT=220.025n

.meas tran vdout1_105ck430 FIND v(dout1_105) AT=220.025n

.meas tran vdout1_106ck430 FIND v(dout1_106) AT=220.025n

.meas tran vdout1_107ck430 FIND v(dout1_107) AT=220.025n

.meas tran vdout1_108ck430 FIND v(dout1_108) AT=220.025n

.meas tran vdout1_109ck430 FIND v(dout1_109) AT=220.025n

.meas tran vdout1_110ck430 FIND v(dout1_110) AT=220.025n

.meas tran vdout1_111ck430 FIND v(dout1_111) AT=220.025n

.meas tran vdout1_112ck430 FIND v(dout1_112) AT=220.025n

.meas tran vdout1_113ck430 FIND v(dout1_113) AT=220.025n

.meas tran vdout1_114ck430 FIND v(dout1_114) AT=220.025n

.meas tran vdout1_115ck430 FIND v(dout1_115) AT=220.025n

.meas tran vdout1_116ck430 FIND v(dout1_116) AT=220.025n

.meas tran vdout1_117ck430 FIND v(dout1_117) AT=220.025n

.meas tran vdout1_118ck430 FIND v(dout1_118) AT=220.025n

.meas tran vdout1_119ck430 FIND v(dout1_119) AT=220.025n

.meas tran vdout1_120ck430 FIND v(dout1_120) AT=220.025n

.meas tran vdout1_121ck430 FIND v(dout1_121) AT=220.025n

.meas tran vdout1_122ck430 FIND v(dout1_122) AT=220.025n

.meas tran vdout1_123ck430 FIND v(dout1_123) AT=220.025n

.meas tran vdout1_124ck430 FIND v(dout1_124) AT=220.025n

.meas tran vdout1_125ck430 FIND v(dout1_125) AT=220.025n

.meas tran vdout1_126ck430 FIND v(dout1_126) AT=220.025n

.meas tran vdout1_127ck430 FIND v(dout1_127) AT=220.025n

.meas tran vdout1_0ck440 FIND v(dout1_0) AT=225.025n

.meas tran vdout1_1ck440 FIND v(dout1_1) AT=225.025n

.meas tran vdout1_2ck440 FIND v(dout1_2) AT=225.025n

.meas tran vdout1_3ck440 FIND v(dout1_3) AT=225.025n

.meas tran vdout1_4ck440 FIND v(dout1_4) AT=225.025n

.meas tran vdout1_5ck440 FIND v(dout1_5) AT=225.025n

.meas tran vdout1_6ck440 FIND v(dout1_6) AT=225.025n

.meas tran vdout1_7ck440 FIND v(dout1_7) AT=225.025n

.meas tran vdout1_8ck440 FIND v(dout1_8) AT=225.025n

.meas tran vdout1_9ck440 FIND v(dout1_9) AT=225.025n

.meas tran vdout1_10ck440 FIND v(dout1_10) AT=225.025n

.meas tran vdout1_11ck440 FIND v(dout1_11) AT=225.025n

.meas tran vdout1_12ck440 FIND v(dout1_12) AT=225.025n

.meas tran vdout1_13ck440 FIND v(dout1_13) AT=225.025n

.meas tran vdout1_14ck440 FIND v(dout1_14) AT=225.025n

.meas tran vdout1_15ck440 FIND v(dout1_15) AT=225.025n

.meas tran vdout1_16ck440 FIND v(dout1_16) AT=225.025n

.meas tran vdout1_17ck440 FIND v(dout1_17) AT=225.025n

.meas tran vdout1_18ck440 FIND v(dout1_18) AT=225.025n

.meas tran vdout1_19ck440 FIND v(dout1_19) AT=225.025n

.meas tran vdout1_20ck440 FIND v(dout1_20) AT=225.025n

.meas tran vdout1_21ck440 FIND v(dout1_21) AT=225.025n

.meas tran vdout1_22ck440 FIND v(dout1_22) AT=225.025n

.meas tran vdout1_23ck440 FIND v(dout1_23) AT=225.025n

.meas tran vdout1_24ck440 FIND v(dout1_24) AT=225.025n

.meas tran vdout1_25ck440 FIND v(dout1_25) AT=225.025n

.meas tran vdout1_26ck440 FIND v(dout1_26) AT=225.025n

.meas tran vdout1_27ck440 FIND v(dout1_27) AT=225.025n

.meas tran vdout1_28ck440 FIND v(dout1_28) AT=225.025n

.meas tran vdout1_29ck440 FIND v(dout1_29) AT=225.025n

.meas tran vdout1_30ck440 FIND v(dout1_30) AT=225.025n

.meas tran vdout1_31ck440 FIND v(dout1_31) AT=225.025n

.meas tran vdout1_32ck440 FIND v(dout1_32) AT=225.025n

.meas tran vdout1_33ck440 FIND v(dout1_33) AT=225.025n

.meas tran vdout1_34ck440 FIND v(dout1_34) AT=225.025n

.meas tran vdout1_35ck440 FIND v(dout1_35) AT=225.025n

.meas tran vdout1_36ck440 FIND v(dout1_36) AT=225.025n

.meas tran vdout1_37ck440 FIND v(dout1_37) AT=225.025n

.meas tran vdout1_38ck440 FIND v(dout1_38) AT=225.025n

.meas tran vdout1_39ck440 FIND v(dout1_39) AT=225.025n

.meas tran vdout1_40ck440 FIND v(dout1_40) AT=225.025n

.meas tran vdout1_41ck440 FIND v(dout1_41) AT=225.025n

.meas tran vdout1_42ck440 FIND v(dout1_42) AT=225.025n

.meas tran vdout1_43ck440 FIND v(dout1_43) AT=225.025n

.meas tran vdout1_44ck440 FIND v(dout1_44) AT=225.025n

.meas tran vdout1_45ck440 FIND v(dout1_45) AT=225.025n

.meas tran vdout1_46ck440 FIND v(dout1_46) AT=225.025n

.meas tran vdout1_47ck440 FIND v(dout1_47) AT=225.025n

.meas tran vdout1_48ck440 FIND v(dout1_48) AT=225.025n

.meas tran vdout1_49ck440 FIND v(dout1_49) AT=225.025n

.meas tran vdout1_50ck440 FIND v(dout1_50) AT=225.025n

.meas tran vdout1_51ck440 FIND v(dout1_51) AT=225.025n

.meas tran vdout1_52ck440 FIND v(dout1_52) AT=225.025n

.meas tran vdout1_53ck440 FIND v(dout1_53) AT=225.025n

.meas tran vdout1_54ck440 FIND v(dout1_54) AT=225.025n

.meas tran vdout1_55ck440 FIND v(dout1_55) AT=225.025n

.meas tran vdout1_56ck440 FIND v(dout1_56) AT=225.025n

.meas tran vdout1_57ck440 FIND v(dout1_57) AT=225.025n

.meas tran vdout1_58ck440 FIND v(dout1_58) AT=225.025n

.meas tran vdout1_59ck440 FIND v(dout1_59) AT=225.025n

.meas tran vdout1_60ck440 FIND v(dout1_60) AT=225.025n

.meas tran vdout1_61ck440 FIND v(dout1_61) AT=225.025n

.meas tran vdout1_62ck440 FIND v(dout1_62) AT=225.025n

.meas tran vdout1_63ck440 FIND v(dout1_63) AT=225.025n

.meas tran vdout1_64ck440 FIND v(dout1_64) AT=225.025n

.meas tran vdout1_65ck440 FIND v(dout1_65) AT=225.025n

.meas tran vdout1_66ck440 FIND v(dout1_66) AT=225.025n

.meas tran vdout1_67ck440 FIND v(dout1_67) AT=225.025n

.meas tran vdout1_68ck440 FIND v(dout1_68) AT=225.025n

.meas tran vdout1_69ck440 FIND v(dout1_69) AT=225.025n

.meas tran vdout1_70ck440 FIND v(dout1_70) AT=225.025n

.meas tran vdout1_71ck440 FIND v(dout1_71) AT=225.025n

.meas tran vdout1_72ck440 FIND v(dout1_72) AT=225.025n

.meas tran vdout1_73ck440 FIND v(dout1_73) AT=225.025n

.meas tran vdout1_74ck440 FIND v(dout1_74) AT=225.025n

.meas tran vdout1_75ck440 FIND v(dout1_75) AT=225.025n

.meas tran vdout1_76ck440 FIND v(dout1_76) AT=225.025n

.meas tran vdout1_77ck440 FIND v(dout1_77) AT=225.025n

.meas tran vdout1_78ck440 FIND v(dout1_78) AT=225.025n

.meas tran vdout1_79ck440 FIND v(dout1_79) AT=225.025n

.meas tran vdout1_80ck440 FIND v(dout1_80) AT=225.025n

.meas tran vdout1_81ck440 FIND v(dout1_81) AT=225.025n

.meas tran vdout1_82ck440 FIND v(dout1_82) AT=225.025n

.meas tran vdout1_83ck440 FIND v(dout1_83) AT=225.025n

.meas tran vdout1_84ck440 FIND v(dout1_84) AT=225.025n

.meas tran vdout1_85ck440 FIND v(dout1_85) AT=225.025n

.meas tran vdout1_86ck440 FIND v(dout1_86) AT=225.025n

.meas tran vdout1_87ck440 FIND v(dout1_87) AT=225.025n

.meas tran vdout1_88ck440 FIND v(dout1_88) AT=225.025n

.meas tran vdout1_89ck440 FIND v(dout1_89) AT=225.025n

.meas tran vdout1_90ck440 FIND v(dout1_90) AT=225.025n

.meas tran vdout1_91ck440 FIND v(dout1_91) AT=225.025n

.meas tran vdout1_92ck440 FIND v(dout1_92) AT=225.025n

.meas tran vdout1_93ck440 FIND v(dout1_93) AT=225.025n

.meas tran vdout1_94ck440 FIND v(dout1_94) AT=225.025n

.meas tran vdout1_95ck440 FIND v(dout1_95) AT=225.025n

.meas tran vdout1_96ck440 FIND v(dout1_96) AT=225.025n

.meas tran vdout1_97ck440 FIND v(dout1_97) AT=225.025n

.meas tran vdout1_98ck440 FIND v(dout1_98) AT=225.025n

.meas tran vdout1_99ck440 FIND v(dout1_99) AT=225.025n

.meas tran vdout1_100ck440 FIND v(dout1_100) AT=225.025n

.meas tran vdout1_101ck440 FIND v(dout1_101) AT=225.025n

.meas tran vdout1_102ck440 FIND v(dout1_102) AT=225.025n

.meas tran vdout1_103ck440 FIND v(dout1_103) AT=225.025n

.meas tran vdout1_104ck440 FIND v(dout1_104) AT=225.025n

.meas tran vdout1_105ck440 FIND v(dout1_105) AT=225.025n

.meas tran vdout1_106ck440 FIND v(dout1_106) AT=225.025n

.meas tran vdout1_107ck440 FIND v(dout1_107) AT=225.025n

.meas tran vdout1_108ck440 FIND v(dout1_108) AT=225.025n

.meas tran vdout1_109ck440 FIND v(dout1_109) AT=225.025n

.meas tran vdout1_110ck440 FIND v(dout1_110) AT=225.025n

.meas tran vdout1_111ck440 FIND v(dout1_111) AT=225.025n

.meas tran vdout1_112ck440 FIND v(dout1_112) AT=225.025n

.meas tran vdout1_113ck440 FIND v(dout1_113) AT=225.025n

.meas tran vdout1_114ck440 FIND v(dout1_114) AT=225.025n

.meas tran vdout1_115ck440 FIND v(dout1_115) AT=225.025n

.meas tran vdout1_116ck440 FIND v(dout1_116) AT=225.025n

.meas tran vdout1_117ck440 FIND v(dout1_117) AT=225.025n

.meas tran vdout1_118ck440 FIND v(dout1_118) AT=225.025n

.meas tran vdout1_119ck440 FIND v(dout1_119) AT=225.025n

.meas tran vdout1_120ck440 FIND v(dout1_120) AT=225.025n

.meas tran vdout1_121ck440 FIND v(dout1_121) AT=225.025n

.meas tran vdout1_122ck440 FIND v(dout1_122) AT=225.025n

.meas tran vdout1_123ck440 FIND v(dout1_123) AT=225.025n

.meas tran vdout1_124ck440 FIND v(dout1_124) AT=225.025n

.meas tran vdout1_125ck440 FIND v(dout1_125) AT=225.025n

.meas tran vdout1_126ck440 FIND v(dout1_126) AT=225.025n

.meas tran vdout1_127ck440 FIND v(dout1_127) AT=225.025n

.meas tran vdout1_0ck460 FIND v(dout1_0) AT=235.025n

.meas tran vdout1_1ck460 FIND v(dout1_1) AT=235.025n

.meas tran vdout1_2ck460 FIND v(dout1_2) AT=235.025n

.meas tran vdout1_3ck460 FIND v(dout1_3) AT=235.025n

.meas tran vdout1_4ck460 FIND v(dout1_4) AT=235.025n

.meas tran vdout1_5ck460 FIND v(dout1_5) AT=235.025n

.meas tran vdout1_6ck460 FIND v(dout1_6) AT=235.025n

.meas tran vdout1_7ck460 FIND v(dout1_7) AT=235.025n

.meas tran vdout1_8ck460 FIND v(dout1_8) AT=235.025n

.meas tran vdout1_9ck460 FIND v(dout1_9) AT=235.025n

.meas tran vdout1_10ck460 FIND v(dout1_10) AT=235.025n

.meas tran vdout1_11ck460 FIND v(dout1_11) AT=235.025n

.meas tran vdout1_12ck460 FIND v(dout1_12) AT=235.025n

.meas tran vdout1_13ck460 FIND v(dout1_13) AT=235.025n

.meas tran vdout1_14ck460 FIND v(dout1_14) AT=235.025n

.meas tran vdout1_15ck460 FIND v(dout1_15) AT=235.025n

.meas tran vdout1_16ck460 FIND v(dout1_16) AT=235.025n

.meas tran vdout1_17ck460 FIND v(dout1_17) AT=235.025n

.meas tran vdout1_18ck460 FIND v(dout1_18) AT=235.025n

.meas tran vdout1_19ck460 FIND v(dout1_19) AT=235.025n

.meas tran vdout1_20ck460 FIND v(dout1_20) AT=235.025n

.meas tran vdout1_21ck460 FIND v(dout1_21) AT=235.025n

.meas tran vdout1_22ck460 FIND v(dout1_22) AT=235.025n

.meas tran vdout1_23ck460 FIND v(dout1_23) AT=235.025n

.meas tran vdout1_24ck460 FIND v(dout1_24) AT=235.025n

.meas tran vdout1_25ck460 FIND v(dout1_25) AT=235.025n

.meas tran vdout1_26ck460 FIND v(dout1_26) AT=235.025n

.meas tran vdout1_27ck460 FIND v(dout1_27) AT=235.025n

.meas tran vdout1_28ck460 FIND v(dout1_28) AT=235.025n

.meas tran vdout1_29ck460 FIND v(dout1_29) AT=235.025n

.meas tran vdout1_30ck460 FIND v(dout1_30) AT=235.025n

.meas tran vdout1_31ck460 FIND v(dout1_31) AT=235.025n

.meas tran vdout1_32ck460 FIND v(dout1_32) AT=235.025n

.meas tran vdout1_33ck460 FIND v(dout1_33) AT=235.025n

.meas tran vdout1_34ck460 FIND v(dout1_34) AT=235.025n

.meas tran vdout1_35ck460 FIND v(dout1_35) AT=235.025n

.meas tran vdout1_36ck460 FIND v(dout1_36) AT=235.025n

.meas tran vdout1_37ck460 FIND v(dout1_37) AT=235.025n

.meas tran vdout1_38ck460 FIND v(dout1_38) AT=235.025n

.meas tran vdout1_39ck460 FIND v(dout1_39) AT=235.025n

.meas tran vdout1_40ck460 FIND v(dout1_40) AT=235.025n

.meas tran vdout1_41ck460 FIND v(dout1_41) AT=235.025n

.meas tran vdout1_42ck460 FIND v(dout1_42) AT=235.025n

.meas tran vdout1_43ck460 FIND v(dout1_43) AT=235.025n

.meas tran vdout1_44ck460 FIND v(dout1_44) AT=235.025n

.meas tran vdout1_45ck460 FIND v(dout1_45) AT=235.025n

.meas tran vdout1_46ck460 FIND v(dout1_46) AT=235.025n

.meas tran vdout1_47ck460 FIND v(dout1_47) AT=235.025n

.meas tran vdout1_48ck460 FIND v(dout1_48) AT=235.025n

.meas tran vdout1_49ck460 FIND v(dout1_49) AT=235.025n

.meas tran vdout1_50ck460 FIND v(dout1_50) AT=235.025n

.meas tran vdout1_51ck460 FIND v(dout1_51) AT=235.025n

.meas tran vdout1_52ck460 FIND v(dout1_52) AT=235.025n

.meas tran vdout1_53ck460 FIND v(dout1_53) AT=235.025n

.meas tran vdout1_54ck460 FIND v(dout1_54) AT=235.025n

.meas tran vdout1_55ck460 FIND v(dout1_55) AT=235.025n

.meas tran vdout1_56ck460 FIND v(dout1_56) AT=235.025n

.meas tran vdout1_57ck460 FIND v(dout1_57) AT=235.025n

.meas tran vdout1_58ck460 FIND v(dout1_58) AT=235.025n

.meas tran vdout1_59ck460 FIND v(dout1_59) AT=235.025n

.meas tran vdout1_60ck460 FIND v(dout1_60) AT=235.025n

.meas tran vdout1_61ck460 FIND v(dout1_61) AT=235.025n

.meas tran vdout1_62ck460 FIND v(dout1_62) AT=235.025n

.meas tran vdout1_63ck460 FIND v(dout1_63) AT=235.025n

.meas tran vdout1_64ck460 FIND v(dout1_64) AT=235.025n

.meas tran vdout1_65ck460 FIND v(dout1_65) AT=235.025n

.meas tran vdout1_66ck460 FIND v(dout1_66) AT=235.025n

.meas tran vdout1_67ck460 FIND v(dout1_67) AT=235.025n

.meas tran vdout1_68ck460 FIND v(dout1_68) AT=235.025n

.meas tran vdout1_69ck460 FIND v(dout1_69) AT=235.025n

.meas tran vdout1_70ck460 FIND v(dout1_70) AT=235.025n

.meas tran vdout1_71ck460 FIND v(dout1_71) AT=235.025n

.meas tran vdout1_72ck460 FIND v(dout1_72) AT=235.025n

.meas tran vdout1_73ck460 FIND v(dout1_73) AT=235.025n

.meas tran vdout1_74ck460 FIND v(dout1_74) AT=235.025n

.meas tran vdout1_75ck460 FIND v(dout1_75) AT=235.025n

.meas tran vdout1_76ck460 FIND v(dout1_76) AT=235.025n

.meas tran vdout1_77ck460 FIND v(dout1_77) AT=235.025n

.meas tran vdout1_78ck460 FIND v(dout1_78) AT=235.025n

.meas tran vdout1_79ck460 FIND v(dout1_79) AT=235.025n

.meas tran vdout1_80ck460 FIND v(dout1_80) AT=235.025n

.meas tran vdout1_81ck460 FIND v(dout1_81) AT=235.025n

.meas tran vdout1_82ck460 FIND v(dout1_82) AT=235.025n

.meas tran vdout1_83ck460 FIND v(dout1_83) AT=235.025n

.meas tran vdout1_84ck460 FIND v(dout1_84) AT=235.025n

.meas tran vdout1_85ck460 FIND v(dout1_85) AT=235.025n

.meas tran vdout1_86ck460 FIND v(dout1_86) AT=235.025n

.meas tran vdout1_87ck460 FIND v(dout1_87) AT=235.025n

.meas tran vdout1_88ck460 FIND v(dout1_88) AT=235.025n

.meas tran vdout1_89ck460 FIND v(dout1_89) AT=235.025n

.meas tran vdout1_90ck460 FIND v(dout1_90) AT=235.025n

.meas tran vdout1_91ck460 FIND v(dout1_91) AT=235.025n

.meas tran vdout1_92ck460 FIND v(dout1_92) AT=235.025n

.meas tran vdout1_93ck460 FIND v(dout1_93) AT=235.025n

.meas tran vdout1_94ck460 FIND v(dout1_94) AT=235.025n

.meas tran vdout1_95ck460 FIND v(dout1_95) AT=235.025n

.meas tran vdout1_96ck460 FIND v(dout1_96) AT=235.025n

.meas tran vdout1_97ck460 FIND v(dout1_97) AT=235.025n

.meas tran vdout1_98ck460 FIND v(dout1_98) AT=235.025n

.meas tran vdout1_99ck460 FIND v(dout1_99) AT=235.025n

.meas tran vdout1_100ck460 FIND v(dout1_100) AT=235.025n

.meas tran vdout1_101ck460 FIND v(dout1_101) AT=235.025n

.meas tran vdout1_102ck460 FIND v(dout1_102) AT=235.025n

.meas tran vdout1_103ck460 FIND v(dout1_103) AT=235.025n

.meas tran vdout1_104ck460 FIND v(dout1_104) AT=235.025n

.meas tran vdout1_105ck460 FIND v(dout1_105) AT=235.025n

.meas tran vdout1_106ck460 FIND v(dout1_106) AT=235.025n

.meas tran vdout1_107ck460 FIND v(dout1_107) AT=235.025n

.meas tran vdout1_108ck460 FIND v(dout1_108) AT=235.025n

.meas tran vdout1_109ck460 FIND v(dout1_109) AT=235.025n

.meas tran vdout1_110ck460 FIND v(dout1_110) AT=235.025n

.meas tran vdout1_111ck460 FIND v(dout1_111) AT=235.025n

.meas tran vdout1_112ck460 FIND v(dout1_112) AT=235.025n

.meas tran vdout1_113ck460 FIND v(dout1_113) AT=235.025n

.meas tran vdout1_114ck460 FIND v(dout1_114) AT=235.025n

.meas tran vdout1_115ck460 FIND v(dout1_115) AT=235.025n

.meas tran vdout1_116ck460 FIND v(dout1_116) AT=235.025n

.meas tran vdout1_117ck460 FIND v(dout1_117) AT=235.025n

.meas tran vdout1_118ck460 FIND v(dout1_118) AT=235.025n

.meas tran vdout1_119ck460 FIND v(dout1_119) AT=235.025n

.meas tran vdout1_120ck460 FIND v(dout1_120) AT=235.025n

.meas tran vdout1_121ck460 FIND v(dout1_121) AT=235.025n

.meas tran vdout1_122ck460 FIND v(dout1_122) AT=235.025n

.meas tran vdout1_123ck460 FIND v(dout1_123) AT=235.025n

.meas tran vdout1_124ck460 FIND v(dout1_124) AT=235.025n

.meas tran vdout1_125ck460 FIND v(dout1_125) AT=235.025n

.meas tran vdout1_126ck460 FIND v(dout1_126) AT=235.025n

.meas tran vdout1_127ck460 FIND v(dout1_127) AT=235.025n

.meas tran vdout1_0ck480 FIND v(dout1_0) AT=245.025n

.meas tran vdout1_1ck480 FIND v(dout1_1) AT=245.025n

.meas tran vdout1_2ck480 FIND v(dout1_2) AT=245.025n

.meas tran vdout1_3ck480 FIND v(dout1_3) AT=245.025n

.meas tran vdout1_4ck480 FIND v(dout1_4) AT=245.025n

.meas tran vdout1_5ck480 FIND v(dout1_5) AT=245.025n

.meas tran vdout1_6ck480 FIND v(dout1_6) AT=245.025n

.meas tran vdout1_7ck480 FIND v(dout1_7) AT=245.025n

.meas tran vdout1_8ck480 FIND v(dout1_8) AT=245.025n

.meas tran vdout1_9ck480 FIND v(dout1_9) AT=245.025n

.meas tran vdout1_10ck480 FIND v(dout1_10) AT=245.025n

.meas tran vdout1_11ck480 FIND v(dout1_11) AT=245.025n

.meas tran vdout1_12ck480 FIND v(dout1_12) AT=245.025n

.meas tran vdout1_13ck480 FIND v(dout1_13) AT=245.025n

.meas tran vdout1_14ck480 FIND v(dout1_14) AT=245.025n

.meas tran vdout1_15ck480 FIND v(dout1_15) AT=245.025n

.meas tran vdout1_16ck480 FIND v(dout1_16) AT=245.025n

.meas tran vdout1_17ck480 FIND v(dout1_17) AT=245.025n

.meas tran vdout1_18ck480 FIND v(dout1_18) AT=245.025n

.meas tran vdout1_19ck480 FIND v(dout1_19) AT=245.025n

.meas tran vdout1_20ck480 FIND v(dout1_20) AT=245.025n

.meas tran vdout1_21ck480 FIND v(dout1_21) AT=245.025n

.meas tran vdout1_22ck480 FIND v(dout1_22) AT=245.025n

.meas tran vdout1_23ck480 FIND v(dout1_23) AT=245.025n

.meas tran vdout1_24ck480 FIND v(dout1_24) AT=245.025n

.meas tran vdout1_25ck480 FIND v(dout1_25) AT=245.025n

.meas tran vdout1_26ck480 FIND v(dout1_26) AT=245.025n

.meas tran vdout1_27ck480 FIND v(dout1_27) AT=245.025n

.meas tran vdout1_28ck480 FIND v(dout1_28) AT=245.025n

.meas tran vdout1_29ck480 FIND v(dout1_29) AT=245.025n

.meas tran vdout1_30ck480 FIND v(dout1_30) AT=245.025n

.meas tran vdout1_31ck480 FIND v(dout1_31) AT=245.025n

.meas tran vdout1_32ck480 FIND v(dout1_32) AT=245.025n

.meas tran vdout1_33ck480 FIND v(dout1_33) AT=245.025n

.meas tran vdout1_34ck480 FIND v(dout1_34) AT=245.025n

.meas tran vdout1_35ck480 FIND v(dout1_35) AT=245.025n

.meas tran vdout1_36ck480 FIND v(dout1_36) AT=245.025n

.meas tran vdout1_37ck480 FIND v(dout1_37) AT=245.025n

.meas tran vdout1_38ck480 FIND v(dout1_38) AT=245.025n

.meas tran vdout1_39ck480 FIND v(dout1_39) AT=245.025n

.meas tran vdout1_40ck480 FIND v(dout1_40) AT=245.025n

.meas tran vdout1_41ck480 FIND v(dout1_41) AT=245.025n

.meas tran vdout1_42ck480 FIND v(dout1_42) AT=245.025n

.meas tran vdout1_43ck480 FIND v(dout1_43) AT=245.025n

.meas tran vdout1_44ck480 FIND v(dout1_44) AT=245.025n

.meas tran vdout1_45ck480 FIND v(dout1_45) AT=245.025n

.meas tran vdout1_46ck480 FIND v(dout1_46) AT=245.025n

.meas tran vdout1_47ck480 FIND v(dout1_47) AT=245.025n

.meas tran vdout1_48ck480 FIND v(dout1_48) AT=245.025n

.meas tran vdout1_49ck480 FIND v(dout1_49) AT=245.025n

.meas tran vdout1_50ck480 FIND v(dout1_50) AT=245.025n

.meas tran vdout1_51ck480 FIND v(dout1_51) AT=245.025n

.meas tran vdout1_52ck480 FIND v(dout1_52) AT=245.025n

.meas tran vdout1_53ck480 FIND v(dout1_53) AT=245.025n

.meas tran vdout1_54ck480 FIND v(dout1_54) AT=245.025n

.meas tran vdout1_55ck480 FIND v(dout1_55) AT=245.025n

.meas tran vdout1_56ck480 FIND v(dout1_56) AT=245.025n

.meas tran vdout1_57ck480 FIND v(dout1_57) AT=245.025n

.meas tran vdout1_58ck480 FIND v(dout1_58) AT=245.025n

.meas tran vdout1_59ck480 FIND v(dout1_59) AT=245.025n

.meas tran vdout1_60ck480 FIND v(dout1_60) AT=245.025n

.meas tran vdout1_61ck480 FIND v(dout1_61) AT=245.025n

.meas tran vdout1_62ck480 FIND v(dout1_62) AT=245.025n

.meas tran vdout1_63ck480 FIND v(dout1_63) AT=245.025n

.meas tran vdout1_64ck480 FIND v(dout1_64) AT=245.025n

.meas tran vdout1_65ck480 FIND v(dout1_65) AT=245.025n

.meas tran vdout1_66ck480 FIND v(dout1_66) AT=245.025n

.meas tran vdout1_67ck480 FIND v(dout1_67) AT=245.025n

.meas tran vdout1_68ck480 FIND v(dout1_68) AT=245.025n

.meas tran vdout1_69ck480 FIND v(dout1_69) AT=245.025n

.meas tran vdout1_70ck480 FIND v(dout1_70) AT=245.025n

.meas tran vdout1_71ck480 FIND v(dout1_71) AT=245.025n

.meas tran vdout1_72ck480 FIND v(dout1_72) AT=245.025n

.meas tran vdout1_73ck480 FIND v(dout1_73) AT=245.025n

.meas tran vdout1_74ck480 FIND v(dout1_74) AT=245.025n

.meas tran vdout1_75ck480 FIND v(dout1_75) AT=245.025n

.meas tran vdout1_76ck480 FIND v(dout1_76) AT=245.025n

.meas tran vdout1_77ck480 FIND v(dout1_77) AT=245.025n

.meas tran vdout1_78ck480 FIND v(dout1_78) AT=245.025n

.meas tran vdout1_79ck480 FIND v(dout1_79) AT=245.025n

.meas tran vdout1_80ck480 FIND v(dout1_80) AT=245.025n

.meas tran vdout1_81ck480 FIND v(dout1_81) AT=245.025n

.meas tran vdout1_82ck480 FIND v(dout1_82) AT=245.025n

.meas tran vdout1_83ck480 FIND v(dout1_83) AT=245.025n

.meas tran vdout1_84ck480 FIND v(dout1_84) AT=245.025n

.meas tran vdout1_85ck480 FIND v(dout1_85) AT=245.025n

.meas tran vdout1_86ck480 FIND v(dout1_86) AT=245.025n

.meas tran vdout1_87ck480 FIND v(dout1_87) AT=245.025n

.meas tran vdout1_88ck480 FIND v(dout1_88) AT=245.025n

.meas tran vdout1_89ck480 FIND v(dout1_89) AT=245.025n

.meas tran vdout1_90ck480 FIND v(dout1_90) AT=245.025n

.meas tran vdout1_91ck480 FIND v(dout1_91) AT=245.025n

.meas tran vdout1_92ck480 FIND v(dout1_92) AT=245.025n

.meas tran vdout1_93ck480 FIND v(dout1_93) AT=245.025n

.meas tran vdout1_94ck480 FIND v(dout1_94) AT=245.025n

.meas tran vdout1_95ck480 FIND v(dout1_95) AT=245.025n

.meas tran vdout1_96ck480 FIND v(dout1_96) AT=245.025n

.meas tran vdout1_97ck480 FIND v(dout1_97) AT=245.025n

.meas tran vdout1_98ck480 FIND v(dout1_98) AT=245.025n

.meas tran vdout1_99ck480 FIND v(dout1_99) AT=245.025n

.meas tran vdout1_100ck480 FIND v(dout1_100) AT=245.025n

.meas tran vdout1_101ck480 FIND v(dout1_101) AT=245.025n

.meas tran vdout1_102ck480 FIND v(dout1_102) AT=245.025n

.meas tran vdout1_103ck480 FIND v(dout1_103) AT=245.025n

.meas tran vdout1_104ck480 FIND v(dout1_104) AT=245.025n

.meas tran vdout1_105ck480 FIND v(dout1_105) AT=245.025n

.meas tran vdout1_106ck480 FIND v(dout1_106) AT=245.025n

.meas tran vdout1_107ck480 FIND v(dout1_107) AT=245.025n

.meas tran vdout1_108ck480 FIND v(dout1_108) AT=245.025n

.meas tran vdout1_109ck480 FIND v(dout1_109) AT=245.025n

.meas tran vdout1_110ck480 FIND v(dout1_110) AT=245.025n

.meas tran vdout1_111ck480 FIND v(dout1_111) AT=245.025n

.meas tran vdout1_112ck480 FIND v(dout1_112) AT=245.025n

.meas tran vdout1_113ck480 FIND v(dout1_113) AT=245.025n

.meas tran vdout1_114ck480 FIND v(dout1_114) AT=245.025n

.meas tran vdout1_115ck480 FIND v(dout1_115) AT=245.025n

.meas tran vdout1_116ck480 FIND v(dout1_116) AT=245.025n

.meas tran vdout1_117ck480 FIND v(dout1_117) AT=245.025n

.meas tran vdout1_118ck480 FIND v(dout1_118) AT=245.025n

.meas tran vdout1_119ck480 FIND v(dout1_119) AT=245.025n

.meas tran vdout1_120ck480 FIND v(dout1_120) AT=245.025n

.meas tran vdout1_121ck480 FIND v(dout1_121) AT=245.025n

.meas tran vdout1_122ck480 FIND v(dout1_122) AT=245.025n

.meas tran vdout1_123ck480 FIND v(dout1_123) AT=245.025n

.meas tran vdout1_124ck480 FIND v(dout1_124) AT=245.025n

.meas tran vdout1_125ck480 FIND v(dout1_125) AT=245.025n

.meas tran vdout1_126ck480 FIND v(dout1_126) AT=245.025n

.meas tran vdout1_127ck480 FIND v(dout1_127) AT=245.025n

.meas tran vdout1_0ck530 FIND v(dout1_0) AT=270.025n

.meas tran vdout1_1ck530 FIND v(dout1_1) AT=270.025n

.meas tran vdout1_2ck530 FIND v(dout1_2) AT=270.025n

.meas tran vdout1_3ck530 FIND v(dout1_3) AT=270.025n

.meas tran vdout1_4ck530 FIND v(dout1_4) AT=270.025n

.meas tran vdout1_5ck530 FIND v(dout1_5) AT=270.025n

.meas tran vdout1_6ck530 FIND v(dout1_6) AT=270.025n

.meas tran vdout1_7ck530 FIND v(dout1_7) AT=270.025n

.meas tran vdout1_8ck530 FIND v(dout1_8) AT=270.025n

.meas tran vdout1_9ck530 FIND v(dout1_9) AT=270.025n

.meas tran vdout1_10ck530 FIND v(dout1_10) AT=270.025n

.meas tran vdout1_11ck530 FIND v(dout1_11) AT=270.025n

.meas tran vdout1_12ck530 FIND v(dout1_12) AT=270.025n

.meas tran vdout1_13ck530 FIND v(dout1_13) AT=270.025n

.meas tran vdout1_14ck530 FIND v(dout1_14) AT=270.025n

.meas tran vdout1_15ck530 FIND v(dout1_15) AT=270.025n

.meas tran vdout1_16ck530 FIND v(dout1_16) AT=270.025n

.meas tran vdout1_17ck530 FIND v(dout1_17) AT=270.025n

.meas tran vdout1_18ck530 FIND v(dout1_18) AT=270.025n

.meas tran vdout1_19ck530 FIND v(dout1_19) AT=270.025n

.meas tran vdout1_20ck530 FIND v(dout1_20) AT=270.025n

.meas tran vdout1_21ck530 FIND v(dout1_21) AT=270.025n

.meas tran vdout1_22ck530 FIND v(dout1_22) AT=270.025n

.meas tran vdout1_23ck530 FIND v(dout1_23) AT=270.025n

.meas tran vdout1_24ck530 FIND v(dout1_24) AT=270.025n

.meas tran vdout1_25ck530 FIND v(dout1_25) AT=270.025n

.meas tran vdout1_26ck530 FIND v(dout1_26) AT=270.025n

.meas tran vdout1_27ck530 FIND v(dout1_27) AT=270.025n

.meas tran vdout1_28ck530 FIND v(dout1_28) AT=270.025n

.meas tran vdout1_29ck530 FIND v(dout1_29) AT=270.025n

.meas tran vdout1_30ck530 FIND v(dout1_30) AT=270.025n

.meas tran vdout1_31ck530 FIND v(dout1_31) AT=270.025n

.meas tran vdout1_32ck530 FIND v(dout1_32) AT=270.025n

.meas tran vdout1_33ck530 FIND v(dout1_33) AT=270.025n

.meas tran vdout1_34ck530 FIND v(dout1_34) AT=270.025n

.meas tran vdout1_35ck530 FIND v(dout1_35) AT=270.025n

.meas tran vdout1_36ck530 FIND v(dout1_36) AT=270.025n

.meas tran vdout1_37ck530 FIND v(dout1_37) AT=270.025n

.meas tran vdout1_38ck530 FIND v(dout1_38) AT=270.025n

.meas tran vdout1_39ck530 FIND v(dout1_39) AT=270.025n

.meas tran vdout1_40ck530 FIND v(dout1_40) AT=270.025n

.meas tran vdout1_41ck530 FIND v(dout1_41) AT=270.025n

.meas tran vdout1_42ck530 FIND v(dout1_42) AT=270.025n

.meas tran vdout1_43ck530 FIND v(dout1_43) AT=270.025n

.meas tran vdout1_44ck530 FIND v(dout1_44) AT=270.025n

.meas tran vdout1_45ck530 FIND v(dout1_45) AT=270.025n

.meas tran vdout1_46ck530 FIND v(dout1_46) AT=270.025n

.meas tran vdout1_47ck530 FIND v(dout1_47) AT=270.025n

.meas tran vdout1_48ck530 FIND v(dout1_48) AT=270.025n

.meas tran vdout1_49ck530 FIND v(dout1_49) AT=270.025n

.meas tran vdout1_50ck530 FIND v(dout1_50) AT=270.025n

.meas tran vdout1_51ck530 FIND v(dout1_51) AT=270.025n

.meas tran vdout1_52ck530 FIND v(dout1_52) AT=270.025n

.meas tran vdout1_53ck530 FIND v(dout1_53) AT=270.025n

.meas tran vdout1_54ck530 FIND v(dout1_54) AT=270.025n

.meas tran vdout1_55ck530 FIND v(dout1_55) AT=270.025n

.meas tran vdout1_56ck530 FIND v(dout1_56) AT=270.025n

.meas tran vdout1_57ck530 FIND v(dout1_57) AT=270.025n

.meas tran vdout1_58ck530 FIND v(dout1_58) AT=270.025n

.meas tran vdout1_59ck530 FIND v(dout1_59) AT=270.025n

.meas tran vdout1_60ck530 FIND v(dout1_60) AT=270.025n

.meas tran vdout1_61ck530 FIND v(dout1_61) AT=270.025n

.meas tran vdout1_62ck530 FIND v(dout1_62) AT=270.025n

.meas tran vdout1_63ck530 FIND v(dout1_63) AT=270.025n

.meas tran vdout1_64ck530 FIND v(dout1_64) AT=270.025n

.meas tran vdout1_65ck530 FIND v(dout1_65) AT=270.025n

.meas tran vdout1_66ck530 FIND v(dout1_66) AT=270.025n

.meas tran vdout1_67ck530 FIND v(dout1_67) AT=270.025n

.meas tran vdout1_68ck530 FIND v(dout1_68) AT=270.025n

.meas tran vdout1_69ck530 FIND v(dout1_69) AT=270.025n

.meas tran vdout1_70ck530 FIND v(dout1_70) AT=270.025n

.meas tran vdout1_71ck530 FIND v(dout1_71) AT=270.025n

.meas tran vdout1_72ck530 FIND v(dout1_72) AT=270.025n

.meas tran vdout1_73ck530 FIND v(dout1_73) AT=270.025n

.meas tran vdout1_74ck530 FIND v(dout1_74) AT=270.025n

.meas tran vdout1_75ck530 FIND v(dout1_75) AT=270.025n

.meas tran vdout1_76ck530 FIND v(dout1_76) AT=270.025n

.meas tran vdout1_77ck530 FIND v(dout1_77) AT=270.025n

.meas tran vdout1_78ck530 FIND v(dout1_78) AT=270.025n

.meas tran vdout1_79ck530 FIND v(dout1_79) AT=270.025n

.meas tran vdout1_80ck530 FIND v(dout1_80) AT=270.025n

.meas tran vdout1_81ck530 FIND v(dout1_81) AT=270.025n

.meas tran vdout1_82ck530 FIND v(dout1_82) AT=270.025n

.meas tran vdout1_83ck530 FIND v(dout1_83) AT=270.025n

.meas tran vdout1_84ck530 FIND v(dout1_84) AT=270.025n

.meas tran vdout1_85ck530 FIND v(dout1_85) AT=270.025n

.meas tran vdout1_86ck530 FIND v(dout1_86) AT=270.025n

.meas tran vdout1_87ck530 FIND v(dout1_87) AT=270.025n

.meas tran vdout1_88ck530 FIND v(dout1_88) AT=270.025n

.meas tran vdout1_89ck530 FIND v(dout1_89) AT=270.025n

.meas tran vdout1_90ck530 FIND v(dout1_90) AT=270.025n

.meas tran vdout1_91ck530 FIND v(dout1_91) AT=270.025n

.meas tran vdout1_92ck530 FIND v(dout1_92) AT=270.025n

.meas tran vdout1_93ck530 FIND v(dout1_93) AT=270.025n

.meas tran vdout1_94ck530 FIND v(dout1_94) AT=270.025n

.meas tran vdout1_95ck530 FIND v(dout1_95) AT=270.025n

.meas tran vdout1_96ck530 FIND v(dout1_96) AT=270.025n

.meas tran vdout1_97ck530 FIND v(dout1_97) AT=270.025n

.meas tran vdout1_98ck530 FIND v(dout1_98) AT=270.025n

.meas tran vdout1_99ck530 FIND v(dout1_99) AT=270.025n

.meas tran vdout1_100ck530 FIND v(dout1_100) AT=270.025n

.meas tran vdout1_101ck530 FIND v(dout1_101) AT=270.025n

.meas tran vdout1_102ck530 FIND v(dout1_102) AT=270.025n

.meas tran vdout1_103ck530 FIND v(dout1_103) AT=270.025n

.meas tran vdout1_104ck530 FIND v(dout1_104) AT=270.025n

.meas tran vdout1_105ck530 FIND v(dout1_105) AT=270.025n

.meas tran vdout1_106ck530 FIND v(dout1_106) AT=270.025n

.meas tran vdout1_107ck530 FIND v(dout1_107) AT=270.025n

.meas tran vdout1_108ck530 FIND v(dout1_108) AT=270.025n

.meas tran vdout1_109ck530 FIND v(dout1_109) AT=270.025n

.meas tran vdout1_110ck530 FIND v(dout1_110) AT=270.025n

.meas tran vdout1_111ck530 FIND v(dout1_111) AT=270.025n

.meas tran vdout1_112ck530 FIND v(dout1_112) AT=270.025n

.meas tran vdout1_113ck530 FIND v(dout1_113) AT=270.025n

.meas tran vdout1_114ck530 FIND v(dout1_114) AT=270.025n

.meas tran vdout1_115ck530 FIND v(dout1_115) AT=270.025n

.meas tran vdout1_116ck530 FIND v(dout1_116) AT=270.025n

.meas tran vdout1_117ck530 FIND v(dout1_117) AT=270.025n

.meas tran vdout1_118ck530 FIND v(dout1_118) AT=270.025n

.meas tran vdout1_119ck530 FIND v(dout1_119) AT=270.025n

.meas tran vdout1_120ck530 FIND v(dout1_120) AT=270.025n

.meas tran vdout1_121ck530 FIND v(dout1_121) AT=270.025n

.meas tran vdout1_122ck530 FIND v(dout1_122) AT=270.025n

.meas tran vdout1_123ck530 FIND v(dout1_123) AT=270.025n

.meas tran vdout1_124ck530 FIND v(dout1_124) AT=270.025n

.meas tran vdout1_125ck530 FIND v(dout1_125) AT=270.025n

.meas tran vdout1_126ck530 FIND v(dout1_126) AT=270.025n

.meas tran vdout1_127ck530 FIND v(dout1_127) AT=270.025n

.meas tran vdout1_0ck540 FIND v(dout1_0) AT=275.025n

.meas tran vdout1_1ck540 FIND v(dout1_1) AT=275.025n

.meas tran vdout1_2ck540 FIND v(dout1_2) AT=275.025n

.meas tran vdout1_3ck540 FIND v(dout1_3) AT=275.025n

.meas tran vdout1_4ck540 FIND v(dout1_4) AT=275.025n

.meas tran vdout1_5ck540 FIND v(dout1_5) AT=275.025n

.meas tran vdout1_6ck540 FIND v(dout1_6) AT=275.025n

.meas tran vdout1_7ck540 FIND v(dout1_7) AT=275.025n

.meas tran vdout1_8ck540 FIND v(dout1_8) AT=275.025n

.meas tran vdout1_9ck540 FIND v(dout1_9) AT=275.025n

.meas tran vdout1_10ck540 FIND v(dout1_10) AT=275.025n

.meas tran vdout1_11ck540 FIND v(dout1_11) AT=275.025n

.meas tran vdout1_12ck540 FIND v(dout1_12) AT=275.025n

.meas tran vdout1_13ck540 FIND v(dout1_13) AT=275.025n

.meas tran vdout1_14ck540 FIND v(dout1_14) AT=275.025n

.meas tran vdout1_15ck540 FIND v(dout1_15) AT=275.025n

.meas tran vdout1_16ck540 FIND v(dout1_16) AT=275.025n

.meas tran vdout1_17ck540 FIND v(dout1_17) AT=275.025n

.meas tran vdout1_18ck540 FIND v(dout1_18) AT=275.025n

.meas tran vdout1_19ck540 FIND v(dout1_19) AT=275.025n

.meas tran vdout1_20ck540 FIND v(dout1_20) AT=275.025n

.meas tran vdout1_21ck540 FIND v(dout1_21) AT=275.025n

.meas tran vdout1_22ck540 FIND v(dout1_22) AT=275.025n

.meas tran vdout1_23ck540 FIND v(dout1_23) AT=275.025n

.meas tran vdout1_24ck540 FIND v(dout1_24) AT=275.025n

.meas tran vdout1_25ck540 FIND v(dout1_25) AT=275.025n

.meas tran vdout1_26ck540 FIND v(dout1_26) AT=275.025n

.meas tran vdout1_27ck540 FIND v(dout1_27) AT=275.025n

.meas tran vdout1_28ck540 FIND v(dout1_28) AT=275.025n

.meas tran vdout1_29ck540 FIND v(dout1_29) AT=275.025n

.meas tran vdout1_30ck540 FIND v(dout1_30) AT=275.025n

.meas tran vdout1_31ck540 FIND v(dout1_31) AT=275.025n

.meas tran vdout1_32ck540 FIND v(dout1_32) AT=275.025n

.meas tran vdout1_33ck540 FIND v(dout1_33) AT=275.025n

.meas tran vdout1_34ck540 FIND v(dout1_34) AT=275.025n

.meas tran vdout1_35ck540 FIND v(dout1_35) AT=275.025n

.meas tran vdout1_36ck540 FIND v(dout1_36) AT=275.025n

.meas tran vdout1_37ck540 FIND v(dout1_37) AT=275.025n

.meas tran vdout1_38ck540 FIND v(dout1_38) AT=275.025n

.meas tran vdout1_39ck540 FIND v(dout1_39) AT=275.025n

.meas tran vdout1_40ck540 FIND v(dout1_40) AT=275.025n

.meas tran vdout1_41ck540 FIND v(dout1_41) AT=275.025n

.meas tran vdout1_42ck540 FIND v(dout1_42) AT=275.025n

.meas tran vdout1_43ck540 FIND v(dout1_43) AT=275.025n

.meas tran vdout1_44ck540 FIND v(dout1_44) AT=275.025n

.meas tran vdout1_45ck540 FIND v(dout1_45) AT=275.025n

.meas tran vdout1_46ck540 FIND v(dout1_46) AT=275.025n

.meas tran vdout1_47ck540 FIND v(dout1_47) AT=275.025n

.meas tran vdout1_48ck540 FIND v(dout1_48) AT=275.025n

.meas tran vdout1_49ck540 FIND v(dout1_49) AT=275.025n

.meas tran vdout1_50ck540 FIND v(dout1_50) AT=275.025n

.meas tran vdout1_51ck540 FIND v(dout1_51) AT=275.025n

.meas tran vdout1_52ck540 FIND v(dout1_52) AT=275.025n

.meas tran vdout1_53ck540 FIND v(dout1_53) AT=275.025n

.meas tran vdout1_54ck540 FIND v(dout1_54) AT=275.025n

.meas tran vdout1_55ck540 FIND v(dout1_55) AT=275.025n

.meas tran vdout1_56ck540 FIND v(dout1_56) AT=275.025n

.meas tran vdout1_57ck540 FIND v(dout1_57) AT=275.025n

.meas tran vdout1_58ck540 FIND v(dout1_58) AT=275.025n

.meas tran vdout1_59ck540 FIND v(dout1_59) AT=275.025n

.meas tran vdout1_60ck540 FIND v(dout1_60) AT=275.025n

.meas tran vdout1_61ck540 FIND v(dout1_61) AT=275.025n

.meas tran vdout1_62ck540 FIND v(dout1_62) AT=275.025n

.meas tran vdout1_63ck540 FIND v(dout1_63) AT=275.025n

.meas tran vdout1_64ck540 FIND v(dout1_64) AT=275.025n

.meas tran vdout1_65ck540 FIND v(dout1_65) AT=275.025n

.meas tran vdout1_66ck540 FIND v(dout1_66) AT=275.025n

.meas tran vdout1_67ck540 FIND v(dout1_67) AT=275.025n

.meas tran vdout1_68ck540 FIND v(dout1_68) AT=275.025n

.meas tran vdout1_69ck540 FIND v(dout1_69) AT=275.025n

.meas tran vdout1_70ck540 FIND v(dout1_70) AT=275.025n

.meas tran vdout1_71ck540 FIND v(dout1_71) AT=275.025n

.meas tran vdout1_72ck540 FIND v(dout1_72) AT=275.025n

.meas tran vdout1_73ck540 FIND v(dout1_73) AT=275.025n

.meas tran vdout1_74ck540 FIND v(dout1_74) AT=275.025n

.meas tran vdout1_75ck540 FIND v(dout1_75) AT=275.025n

.meas tran vdout1_76ck540 FIND v(dout1_76) AT=275.025n

.meas tran vdout1_77ck540 FIND v(dout1_77) AT=275.025n

.meas tran vdout1_78ck540 FIND v(dout1_78) AT=275.025n

.meas tran vdout1_79ck540 FIND v(dout1_79) AT=275.025n

.meas tran vdout1_80ck540 FIND v(dout1_80) AT=275.025n

.meas tran vdout1_81ck540 FIND v(dout1_81) AT=275.025n

.meas tran vdout1_82ck540 FIND v(dout1_82) AT=275.025n

.meas tran vdout1_83ck540 FIND v(dout1_83) AT=275.025n

.meas tran vdout1_84ck540 FIND v(dout1_84) AT=275.025n

.meas tran vdout1_85ck540 FIND v(dout1_85) AT=275.025n

.meas tran vdout1_86ck540 FIND v(dout1_86) AT=275.025n

.meas tran vdout1_87ck540 FIND v(dout1_87) AT=275.025n

.meas tran vdout1_88ck540 FIND v(dout1_88) AT=275.025n

.meas tran vdout1_89ck540 FIND v(dout1_89) AT=275.025n

.meas tran vdout1_90ck540 FIND v(dout1_90) AT=275.025n

.meas tran vdout1_91ck540 FIND v(dout1_91) AT=275.025n

.meas tran vdout1_92ck540 FIND v(dout1_92) AT=275.025n

.meas tran vdout1_93ck540 FIND v(dout1_93) AT=275.025n

.meas tran vdout1_94ck540 FIND v(dout1_94) AT=275.025n

.meas tran vdout1_95ck540 FIND v(dout1_95) AT=275.025n

.meas tran vdout1_96ck540 FIND v(dout1_96) AT=275.025n

.meas tran vdout1_97ck540 FIND v(dout1_97) AT=275.025n

.meas tran vdout1_98ck540 FIND v(dout1_98) AT=275.025n

.meas tran vdout1_99ck540 FIND v(dout1_99) AT=275.025n

.meas tran vdout1_100ck540 FIND v(dout1_100) AT=275.025n

.meas tran vdout1_101ck540 FIND v(dout1_101) AT=275.025n

.meas tran vdout1_102ck540 FIND v(dout1_102) AT=275.025n

.meas tran vdout1_103ck540 FIND v(dout1_103) AT=275.025n

.meas tran vdout1_104ck540 FIND v(dout1_104) AT=275.025n

.meas tran vdout1_105ck540 FIND v(dout1_105) AT=275.025n

.meas tran vdout1_106ck540 FIND v(dout1_106) AT=275.025n

.meas tran vdout1_107ck540 FIND v(dout1_107) AT=275.025n

.meas tran vdout1_108ck540 FIND v(dout1_108) AT=275.025n

.meas tran vdout1_109ck540 FIND v(dout1_109) AT=275.025n

.meas tran vdout1_110ck540 FIND v(dout1_110) AT=275.025n

.meas tran vdout1_111ck540 FIND v(dout1_111) AT=275.025n

.meas tran vdout1_112ck540 FIND v(dout1_112) AT=275.025n

.meas tran vdout1_113ck540 FIND v(dout1_113) AT=275.025n

.meas tran vdout1_114ck540 FIND v(dout1_114) AT=275.025n

.meas tran vdout1_115ck540 FIND v(dout1_115) AT=275.025n

.meas tran vdout1_116ck540 FIND v(dout1_116) AT=275.025n

.meas tran vdout1_117ck540 FIND v(dout1_117) AT=275.025n

.meas tran vdout1_118ck540 FIND v(dout1_118) AT=275.025n

.meas tran vdout1_119ck540 FIND v(dout1_119) AT=275.025n

.meas tran vdout1_120ck540 FIND v(dout1_120) AT=275.025n

.meas tran vdout1_121ck540 FIND v(dout1_121) AT=275.025n

.meas tran vdout1_122ck540 FIND v(dout1_122) AT=275.025n

.meas tran vdout1_123ck540 FIND v(dout1_123) AT=275.025n

.meas tran vdout1_124ck540 FIND v(dout1_124) AT=275.025n

.meas tran vdout1_125ck540 FIND v(dout1_125) AT=275.025n

.meas tran vdout1_126ck540 FIND v(dout1_126) AT=275.025n

.meas tran vdout1_127ck540 FIND v(dout1_127) AT=275.025n

.meas tran vdout1_0ck570 FIND v(dout1_0) AT=290.025n

.meas tran vdout1_1ck570 FIND v(dout1_1) AT=290.025n

.meas tran vdout1_2ck570 FIND v(dout1_2) AT=290.025n

.meas tran vdout1_3ck570 FIND v(dout1_3) AT=290.025n

.meas tran vdout1_4ck570 FIND v(dout1_4) AT=290.025n

.meas tran vdout1_5ck570 FIND v(dout1_5) AT=290.025n

.meas tran vdout1_6ck570 FIND v(dout1_6) AT=290.025n

.meas tran vdout1_7ck570 FIND v(dout1_7) AT=290.025n

.meas tran vdout1_8ck570 FIND v(dout1_8) AT=290.025n

.meas tran vdout1_9ck570 FIND v(dout1_9) AT=290.025n

.meas tran vdout1_10ck570 FIND v(dout1_10) AT=290.025n

.meas tran vdout1_11ck570 FIND v(dout1_11) AT=290.025n

.meas tran vdout1_12ck570 FIND v(dout1_12) AT=290.025n

.meas tran vdout1_13ck570 FIND v(dout1_13) AT=290.025n

.meas tran vdout1_14ck570 FIND v(dout1_14) AT=290.025n

.meas tran vdout1_15ck570 FIND v(dout1_15) AT=290.025n

.meas tran vdout1_16ck570 FIND v(dout1_16) AT=290.025n

.meas tran vdout1_17ck570 FIND v(dout1_17) AT=290.025n

.meas tran vdout1_18ck570 FIND v(dout1_18) AT=290.025n

.meas tran vdout1_19ck570 FIND v(dout1_19) AT=290.025n

.meas tran vdout1_20ck570 FIND v(dout1_20) AT=290.025n

.meas tran vdout1_21ck570 FIND v(dout1_21) AT=290.025n

.meas tran vdout1_22ck570 FIND v(dout1_22) AT=290.025n

.meas tran vdout1_23ck570 FIND v(dout1_23) AT=290.025n

.meas tran vdout1_24ck570 FIND v(dout1_24) AT=290.025n

.meas tran vdout1_25ck570 FIND v(dout1_25) AT=290.025n

.meas tran vdout1_26ck570 FIND v(dout1_26) AT=290.025n

.meas tran vdout1_27ck570 FIND v(dout1_27) AT=290.025n

.meas tran vdout1_28ck570 FIND v(dout1_28) AT=290.025n

.meas tran vdout1_29ck570 FIND v(dout1_29) AT=290.025n

.meas tran vdout1_30ck570 FIND v(dout1_30) AT=290.025n

.meas tran vdout1_31ck570 FIND v(dout1_31) AT=290.025n

.meas tran vdout1_32ck570 FIND v(dout1_32) AT=290.025n

.meas tran vdout1_33ck570 FIND v(dout1_33) AT=290.025n

.meas tran vdout1_34ck570 FIND v(dout1_34) AT=290.025n

.meas tran vdout1_35ck570 FIND v(dout1_35) AT=290.025n

.meas tran vdout1_36ck570 FIND v(dout1_36) AT=290.025n

.meas tran vdout1_37ck570 FIND v(dout1_37) AT=290.025n

.meas tran vdout1_38ck570 FIND v(dout1_38) AT=290.025n

.meas tran vdout1_39ck570 FIND v(dout1_39) AT=290.025n

.meas tran vdout1_40ck570 FIND v(dout1_40) AT=290.025n

.meas tran vdout1_41ck570 FIND v(dout1_41) AT=290.025n

.meas tran vdout1_42ck570 FIND v(dout1_42) AT=290.025n

.meas tran vdout1_43ck570 FIND v(dout1_43) AT=290.025n

.meas tran vdout1_44ck570 FIND v(dout1_44) AT=290.025n

.meas tran vdout1_45ck570 FIND v(dout1_45) AT=290.025n

.meas tran vdout1_46ck570 FIND v(dout1_46) AT=290.025n

.meas tran vdout1_47ck570 FIND v(dout1_47) AT=290.025n

.meas tran vdout1_48ck570 FIND v(dout1_48) AT=290.025n

.meas tran vdout1_49ck570 FIND v(dout1_49) AT=290.025n

.meas tran vdout1_50ck570 FIND v(dout1_50) AT=290.025n

.meas tran vdout1_51ck570 FIND v(dout1_51) AT=290.025n

.meas tran vdout1_52ck570 FIND v(dout1_52) AT=290.025n

.meas tran vdout1_53ck570 FIND v(dout1_53) AT=290.025n

.meas tran vdout1_54ck570 FIND v(dout1_54) AT=290.025n

.meas tran vdout1_55ck570 FIND v(dout1_55) AT=290.025n

.meas tran vdout1_56ck570 FIND v(dout1_56) AT=290.025n

.meas tran vdout1_57ck570 FIND v(dout1_57) AT=290.025n

.meas tran vdout1_58ck570 FIND v(dout1_58) AT=290.025n

.meas tran vdout1_59ck570 FIND v(dout1_59) AT=290.025n

.meas tran vdout1_60ck570 FIND v(dout1_60) AT=290.025n

.meas tran vdout1_61ck570 FIND v(dout1_61) AT=290.025n

.meas tran vdout1_62ck570 FIND v(dout1_62) AT=290.025n

.meas tran vdout1_63ck570 FIND v(dout1_63) AT=290.025n

.meas tran vdout1_64ck570 FIND v(dout1_64) AT=290.025n

.meas tran vdout1_65ck570 FIND v(dout1_65) AT=290.025n

.meas tran vdout1_66ck570 FIND v(dout1_66) AT=290.025n

.meas tran vdout1_67ck570 FIND v(dout1_67) AT=290.025n

.meas tran vdout1_68ck570 FIND v(dout1_68) AT=290.025n

.meas tran vdout1_69ck570 FIND v(dout1_69) AT=290.025n

.meas tran vdout1_70ck570 FIND v(dout1_70) AT=290.025n

.meas tran vdout1_71ck570 FIND v(dout1_71) AT=290.025n

.meas tran vdout1_72ck570 FIND v(dout1_72) AT=290.025n

.meas tran vdout1_73ck570 FIND v(dout1_73) AT=290.025n

.meas tran vdout1_74ck570 FIND v(dout1_74) AT=290.025n

.meas tran vdout1_75ck570 FIND v(dout1_75) AT=290.025n

.meas tran vdout1_76ck570 FIND v(dout1_76) AT=290.025n

.meas tran vdout1_77ck570 FIND v(dout1_77) AT=290.025n

.meas tran vdout1_78ck570 FIND v(dout1_78) AT=290.025n

.meas tran vdout1_79ck570 FIND v(dout1_79) AT=290.025n

.meas tran vdout1_80ck570 FIND v(dout1_80) AT=290.025n

.meas tran vdout1_81ck570 FIND v(dout1_81) AT=290.025n

.meas tran vdout1_82ck570 FIND v(dout1_82) AT=290.025n

.meas tran vdout1_83ck570 FIND v(dout1_83) AT=290.025n

.meas tran vdout1_84ck570 FIND v(dout1_84) AT=290.025n

.meas tran vdout1_85ck570 FIND v(dout1_85) AT=290.025n

.meas tran vdout1_86ck570 FIND v(dout1_86) AT=290.025n

.meas tran vdout1_87ck570 FIND v(dout1_87) AT=290.025n

.meas tran vdout1_88ck570 FIND v(dout1_88) AT=290.025n

.meas tran vdout1_89ck570 FIND v(dout1_89) AT=290.025n

.meas tran vdout1_90ck570 FIND v(dout1_90) AT=290.025n

.meas tran vdout1_91ck570 FIND v(dout1_91) AT=290.025n

.meas tran vdout1_92ck570 FIND v(dout1_92) AT=290.025n

.meas tran vdout1_93ck570 FIND v(dout1_93) AT=290.025n

.meas tran vdout1_94ck570 FIND v(dout1_94) AT=290.025n

.meas tran vdout1_95ck570 FIND v(dout1_95) AT=290.025n

.meas tran vdout1_96ck570 FIND v(dout1_96) AT=290.025n

.meas tran vdout1_97ck570 FIND v(dout1_97) AT=290.025n

.meas tran vdout1_98ck570 FIND v(dout1_98) AT=290.025n

.meas tran vdout1_99ck570 FIND v(dout1_99) AT=290.025n

.meas tran vdout1_100ck570 FIND v(dout1_100) AT=290.025n

.meas tran vdout1_101ck570 FIND v(dout1_101) AT=290.025n

.meas tran vdout1_102ck570 FIND v(dout1_102) AT=290.025n

.meas tran vdout1_103ck570 FIND v(dout1_103) AT=290.025n

.meas tran vdout1_104ck570 FIND v(dout1_104) AT=290.025n

.meas tran vdout1_105ck570 FIND v(dout1_105) AT=290.025n

.meas tran vdout1_106ck570 FIND v(dout1_106) AT=290.025n

.meas tran vdout1_107ck570 FIND v(dout1_107) AT=290.025n

.meas tran vdout1_108ck570 FIND v(dout1_108) AT=290.025n

.meas tran vdout1_109ck570 FIND v(dout1_109) AT=290.025n

.meas tran vdout1_110ck570 FIND v(dout1_110) AT=290.025n

.meas tran vdout1_111ck570 FIND v(dout1_111) AT=290.025n

.meas tran vdout1_112ck570 FIND v(dout1_112) AT=290.025n

.meas tran vdout1_113ck570 FIND v(dout1_113) AT=290.025n

.meas tran vdout1_114ck570 FIND v(dout1_114) AT=290.025n

.meas tran vdout1_115ck570 FIND v(dout1_115) AT=290.025n

.meas tran vdout1_116ck570 FIND v(dout1_116) AT=290.025n

.meas tran vdout1_117ck570 FIND v(dout1_117) AT=290.025n

.meas tran vdout1_118ck570 FIND v(dout1_118) AT=290.025n

.meas tran vdout1_119ck570 FIND v(dout1_119) AT=290.025n

.meas tran vdout1_120ck570 FIND v(dout1_120) AT=290.025n

.meas tran vdout1_121ck570 FIND v(dout1_121) AT=290.025n

.meas tran vdout1_122ck570 FIND v(dout1_122) AT=290.025n

.meas tran vdout1_123ck570 FIND v(dout1_123) AT=290.025n

.meas tran vdout1_124ck570 FIND v(dout1_124) AT=290.025n

.meas tran vdout1_125ck570 FIND v(dout1_125) AT=290.025n

.meas tran vdout1_126ck570 FIND v(dout1_126) AT=290.025n

.meas tran vdout1_127ck570 FIND v(dout1_127) AT=290.025n

.meas tran vdout1_0ck600 FIND v(dout1_0) AT=305.025n

.meas tran vdout1_1ck600 FIND v(dout1_1) AT=305.025n

.meas tran vdout1_2ck600 FIND v(dout1_2) AT=305.025n

.meas tran vdout1_3ck600 FIND v(dout1_3) AT=305.025n

.meas tran vdout1_4ck600 FIND v(dout1_4) AT=305.025n

.meas tran vdout1_5ck600 FIND v(dout1_5) AT=305.025n

.meas tran vdout1_6ck600 FIND v(dout1_6) AT=305.025n

.meas tran vdout1_7ck600 FIND v(dout1_7) AT=305.025n

.meas tran vdout1_8ck600 FIND v(dout1_8) AT=305.025n

.meas tran vdout1_9ck600 FIND v(dout1_9) AT=305.025n

.meas tran vdout1_10ck600 FIND v(dout1_10) AT=305.025n

.meas tran vdout1_11ck600 FIND v(dout1_11) AT=305.025n

.meas tran vdout1_12ck600 FIND v(dout1_12) AT=305.025n

.meas tran vdout1_13ck600 FIND v(dout1_13) AT=305.025n

.meas tran vdout1_14ck600 FIND v(dout1_14) AT=305.025n

.meas tran vdout1_15ck600 FIND v(dout1_15) AT=305.025n

.meas tran vdout1_16ck600 FIND v(dout1_16) AT=305.025n

.meas tran vdout1_17ck600 FIND v(dout1_17) AT=305.025n

.meas tran vdout1_18ck600 FIND v(dout1_18) AT=305.025n

.meas tran vdout1_19ck600 FIND v(dout1_19) AT=305.025n

.meas tran vdout1_20ck600 FIND v(dout1_20) AT=305.025n

.meas tran vdout1_21ck600 FIND v(dout1_21) AT=305.025n

.meas tran vdout1_22ck600 FIND v(dout1_22) AT=305.025n

.meas tran vdout1_23ck600 FIND v(dout1_23) AT=305.025n

.meas tran vdout1_24ck600 FIND v(dout1_24) AT=305.025n

.meas tran vdout1_25ck600 FIND v(dout1_25) AT=305.025n

.meas tran vdout1_26ck600 FIND v(dout1_26) AT=305.025n

.meas tran vdout1_27ck600 FIND v(dout1_27) AT=305.025n

.meas tran vdout1_28ck600 FIND v(dout1_28) AT=305.025n

.meas tran vdout1_29ck600 FIND v(dout1_29) AT=305.025n

.meas tran vdout1_30ck600 FIND v(dout1_30) AT=305.025n

.meas tran vdout1_31ck600 FIND v(dout1_31) AT=305.025n

.meas tran vdout1_32ck600 FIND v(dout1_32) AT=305.025n

.meas tran vdout1_33ck600 FIND v(dout1_33) AT=305.025n

.meas tran vdout1_34ck600 FIND v(dout1_34) AT=305.025n

.meas tran vdout1_35ck600 FIND v(dout1_35) AT=305.025n

.meas tran vdout1_36ck600 FIND v(dout1_36) AT=305.025n

.meas tran vdout1_37ck600 FIND v(dout1_37) AT=305.025n

.meas tran vdout1_38ck600 FIND v(dout1_38) AT=305.025n

.meas tran vdout1_39ck600 FIND v(dout1_39) AT=305.025n

.meas tran vdout1_40ck600 FIND v(dout1_40) AT=305.025n

.meas tran vdout1_41ck600 FIND v(dout1_41) AT=305.025n

.meas tran vdout1_42ck600 FIND v(dout1_42) AT=305.025n

.meas tran vdout1_43ck600 FIND v(dout1_43) AT=305.025n

.meas tran vdout1_44ck600 FIND v(dout1_44) AT=305.025n

.meas tran vdout1_45ck600 FIND v(dout1_45) AT=305.025n

.meas tran vdout1_46ck600 FIND v(dout1_46) AT=305.025n

.meas tran vdout1_47ck600 FIND v(dout1_47) AT=305.025n

.meas tran vdout1_48ck600 FIND v(dout1_48) AT=305.025n

.meas tran vdout1_49ck600 FIND v(dout1_49) AT=305.025n

.meas tran vdout1_50ck600 FIND v(dout1_50) AT=305.025n

.meas tran vdout1_51ck600 FIND v(dout1_51) AT=305.025n

.meas tran vdout1_52ck600 FIND v(dout1_52) AT=305.025n

.meas tran vdout1_53ck600 FIND v(dout1_53) AT=305.025n

.meas tran vdout1_54ck600 FIND v(dout1_54) AT=305.025n

.meas tran vdout1_55ck600 FIND v(dout1_55) AT=305.025n

.meas tran vdout1_56ck600 FIND v(dout1_56) AT=305.025n

.meas tran vdout1_57ck600 FIND v(dout1_57) AT=305.025n

.meas tran vdout1_58ck600 FIND v(dout1_58) AT=305.025n

.meas tran vdout1_59ck600 FIND v(dout1_59) AT=305.025n

.meas tran vdout1_60ck600 FIND v(dout1_60) AT=305.025n

.meas tran vdout1_61ck600 FIND v(dout1_61) AT=305.025n

.meas tran vdout1_62ck600 FIND v(dout1_62) AT=305.025n

.meas tran vdout1_63ck600 FIND v(dout1_63) AT=305.025n

.meas tran vdout1_64ck600 FIND v(dout1_64) AT=305.025n

.meas tran vdout1_65ck600 FIND v(dout1_65) AT=305.025n

.meas tran vdout1_66ck600 FIND v(dout1_66) AT=305.025n

.meas tran vdout1_67ck600 FIND v(dout1_67) AT=305.025n

.meas tran vdout1_68ck600 FIND v(dout1_68) AT=305.025n

.meas tran vdout1_69ck600 FIND v(dout1_69) AT=305.025n

.meas tran vdout1_70ck600 FIND v(dout1_70) AT=305.025n

.meas tran vdout1_71ck600 FIND v(dout1_71) AT=305.025n

.meas tran vdout1_72ck600 FIND v(dout1_72) AT=305.025n

.meas tran vdout1_73ck600 FIND v(dout1_73) AT=305.025n

.meas tran vdout1_74ck600 FIND v(dout1_74) AT=305.025n

.meas tran vdout1_75ck600 FIND v(dout1_75) AT=305.025n

.meas tran vdout1_76ck600 FIND v(dout1_76) AT=305.025n

.meas tran vdout1_77ck600 FIND v(dout1_77) AT=305.025n

.meas tran vdout1_78ck600 FIND v(dout1_78) AT=305.025n

.meas tran vdout1_79ck600 FIND v(dout1_79) AT=305.025n

.meas tran vdout1_80ck600 FIND v(dout1_80) AT=305.025n

.meas tran vdout1_81ck600 FIND v(dout1_81) AT=305.025n

.meas tran vdout1_82ck600 FIND v(dout1_82) AT=305.025n

.meas tran vdout1_83ck600 FIND v(dout1_83) AT=305.025n

.meas tran vdout1_84ck600 FIND v(dout1_84) AT=305.025n

.meas tran vdout1_85ck600 FIND v(dout1_85) AT=305.025n

.meas tran vdout1_86ck600 FIND v(dout1_86) AT=305.025n

.meas tran vdout1_87ck600 FIND v(dout1_87) AT=305.025n

.meas tran vdout1_88ck600 FIND v(dout1_88) AT=305.025n

.meas tran vdout1_89ck600 FIND v(dout1_89) AT=305.025n

.meas tran vdout1_90ck600 FIND v(dout1_90) AT=305.025n

.meas tran vdout1_91ck600 FIND v(dout1_91) AT=305.025n

.meas tran vdout1_92ck600 FIND v(dout1_92) AT=305.025n

.meas tran vdout1_93ck600 FIND v(dout1_93) AT=305.025n

.meas tran vdout1_94ck600 FIND v(dout1_94) AT=305.025n

.meas tran vdout1_95ck600 FIND v(dout1_95) AT=305.025n

.meas tran vdout1_96ck600 FIND v(dout1_96) AT=305.025n

.meas tran vdout1_97ck600 FIND v(dout1_97) AT=305.025n

.meas tran vdout1_98ck600 FIND v(dout1_98) AT=305.025n

.meas tran vdout1_99ck600 FIND v(dout1_99) AT=305.025n

.meas tran vdout1_100ck600 FIND v(dout1_100) AT=305.025n

.meas tran vdout1_101ck600 FIND v(dout1_101) AT=305.025n

.meas tran vdout1_102ck600 FIND v(dout1_102) AT=305.025n

.meas tran vdout1_103ck600 FIND v(dout1_103) AT=305.025n

.meas tran vdout1_104ck600 FIND v(dout1_104) AT=305.025n

.meas tran vdout1_105ck600 FIND v(dout1_105) AT=305.025n

.meas tran vdout1_106ck600 FIND v(dout1_106) AT=305.025n

.meas tran vdout1_107ck600 FIND v(dout1_107) AT=305.025n

.meas tran vdout1_108ck600 FIND v(dout1_108) AT=305.025n

.meas tran vdout1_109ck600 FIND v(dout1_109) AT=305.025n

.meas tran vdout1_110ck600 FIND v(dout1_110) AT=305.025n

.meas tran vdout1_111ck600 FIND v(dout1_111) AT=305.025n

.meas tran vdout1_112ck600 FIND v(dout1_112) AT=305.025n

.meas tran vdout1_113ck600 FIND v(dout1_113) AT=305.025n

.meas tran vdout1_114ck600 FIND v(dout1_114) AT=305.025n

.meas tran vdout1_115ck600 FIND v(dout1_115) AT=305.025n

.meas tran vdout1_116ck600 FIND v(dout1_116) AT=305.025n

.meas tran vdout1_117ck600 FIND v(dout1_117) AT=305.025n

.meas tran vdout1_118ck600 FIND v(dout1_118) AT=305.025n

.meas tran vdout1_119ck600 FIND v(dout1_119) AT=305.025n

.meas tran vdout1_120ck600 FIND v(dout1_120) AT=305.025n

.meas tran vdout1_121ck600 FIND v(dout1_121) AT=305.025n

.meas tran vdout1_122ck600 FIND v(dout1_122) AT=305.025n

.meas tran vdout1_123ck600 FIND v(dout1_123) AT=305.025n

.meas tran vdout1_124ck600 FIND v(dout1_124) AT=305.025n

.meas tran vdout1_125ck600 FIND v(dout1_125) AT=305.025n

.meas tran vdout1_126ck600 FIND v(dout1_126) AT=305.025n

.meas tran vdout1_127ck600 FIND v(dout1_127) AT=305.025n

.meas tran vdout1_0ck670 FIND v(dout1_0) AT=340.025n

.meas tran vdout1_1ck670 FIND v(dout1_1) AT=340.025n

.meas tran vdout1_2ck670 FIND v(dout1_2) AT=340.025n

.meas tran vdout1_3ck670 FIND v(dout1_3) AT=340.025n

.meas tran vdout1_4ck670 FIND v(dout1_4) AT=340.025n

.meas tran vdout1_5ck670 FIND v(dout1_5) AT=340.025n

.meas tran vdout1_6ck670 FIND v(dout1_6) AT=340.025n

.meas tran vdout1_7ck670 FIND v(dout1_7) AT=340.025n

.meas tran vdout1_8ck670 FIND v(dout1_8) AT=340.025n

.meas tran vdout1_9ck670 FIND v(dout1_9) AT=340.025n

.meas tran vdout1_10ck670 FIND v(dout1_10) AT=340.025n

.meas tran vdout1_11ck670 FIND v(dout1_11) AT=340.025n

.meas tran vdout1_12ck670 FIND v(dout1_12) AT=340.025n

.meas tran vdout1_13ck670 FIND v(dout1_13) AT=340.025n

.meas tran vdout1_14ck670 FIND v(dout1_14) AT=340.025n

.meas tran vdout1_15ck670 FIND v(dout1_15) AT=340.025n

.meas tran vdout1_16ck670 FIND v(dout1_16) AT=340.025n

.meas tran vdout1_17ck670 FIND v(dout1_17) AT=340.025n

.meas tran vdout1_18ck670 FIND v(dout1_18) AT=340.025n

.meas tran vdout1_19ck670 FIND v(dout1_19) AT=340.025n

.meas tran vdout1_20ck670 FIND v(dout1_20) AT=340.025n

.meas tran vdout1_21ck670 FIND v(dout1_21) AT=340.025n

.meas tran vdout1_22ck670 FIND v(dout1_22) AT=340.025n

.meas tran vdout1_23ck670 FIND v(dout1_23) AT=340.025n

.meas tran vdout1_24ck670 FIND v(dout1_24) AT=340.025n

.meas tran vdout1_25ck670 FIND v(dout1_25) AT=340.025n

.meas tran vdout1_26ck670 FIND v(dout1_26) AT=340.025n

.meas tran vdout1_27ck670 FIND v(dout1_27) AT=340.025n

.meas tran vdout1_28ck670 FIND v(dout1_28) AT=340.025n

.meas tran vdout1_29ck670 FIND v(dout1_29) AT=340.025n

.meas tran vdout1_30ck670 FIND v(dout1_30) AT=340.025n

.meas tran vdout1_31ck670 FIND v(dout1_31) AT=340.025n

.meas tran vdout1_32ck670 FIND v(dout1_32) AT=340.025n

.meas tran vdout1_33ck670 FIND v(dout1_33) AT=340.025n

.meas tran vdout1_34ck670 FIND v(dout1_34) AT=340.025n

.meas tran vdout1_35ck670 FIND v(dout1_35) AT=340.025n

.meas tran vdout1_36ck670 FIND v(dout1_36) AT=340.025n

.meas tran vdout1_37ck670 FIND v(dout1_37) AT=340.025n

.meas tran vdout1_38ck670 FIND v(dout1_38) AT=340.025n

.meas tran vdout1_39ck670 FIND v(dout1_39) AT=340.025n

.meas tran vdout1_40ck670 FIND v(dout1_40) AT=340.025n

.meas tran vdout1_41ck670 FIND v(dout1_41) AT=340.025n

.meas tran vdout1_42ck670 FIND v(dout1_42) AT=340.025n

.meas tran vdout1_43ck670 FIND v(dout1_43) AT=340.025n

.meas tran vdout1_44ck670 FIND v(dout1_44) AT=340.025n

.meas tran vdout1_45ck670 FIND v(dout1_45) AT=340.025n

.meas tran vdout1_46ck670 FIND v(dout1_46) AT=340.025n

.meas tran vdout1_47ck670 FIND v(dout1_47) AT=340.025n

.meas tran vdout1_48ck670 FIND v(dout1_48) AT=340.025n

.meas tran vdout1_49ck670 FIND v(dout1_49) AT=340.025n

.meas tran vdout1_50ck670 FIND v(dout1_50) AT=340.025n

.meas tran vdout1_51ck670 FIND v(dout1_51) AT=340.025n

.meas tran vdout1_52ck670 FIND v(dout1_52) AT=340.025n

.meas tran vdout1_53ck670 FIND v(dout1_53) AT=340.025n

.meas tran vdout1_54ck670 FIND v(dout1_54) AT=340.025n

.meas tran vdout1_55ck670 FIND v(dout1_55) AT=340.025n

.meas tran vdout1_56ck670 FIND v(dout1_56) AT=340.025n

.meas tran vdout1_57ck670 FIND v(dout1_57) AT=340.025n

.meas tran vdout1_58ck670 FIND v(dout1_58) AT=340.025n

.meas tran vdout1_59ck670 FIND v(dout1_59) AT=340.025n

.meas tran vdout1_60ck670 FIND v(dout1_60) AT=340.025n

.meas tran vdout1_61ck670 FIND v(dout1_61) AT=340.025n

.meas tran vdout1_62ck670 FIND v(dout1_62) AT=340.025n

.meas tran vdout1_63ck670 FIND v(dout1_63) AT=340.025n

.meas tran vdout1_64ck670 FIND v(dout1_64) AT=340.025n

.meas tran vdout1_65ck670 FIND v(dout1_65) AT=340.025n

.meas tran vdout1_66ck670 FIND v(dout1_66) AT=340.025n

.meas tran vdout1_67ck670 FIND v(dout1_67) AT=340.025n

.meas tran vdout1_68ck670 FIND v(dout1_68) AT=340.025n

.meas tran vdout1_69ck670 FIND v(dout1_69) AT=340.025n

.meas tran vdout1_70ck670 FIND v(dout1_70) AT=340.025n

.meas tran vdout1_71ck670 FIND v(dout1_71) AT=340.025n

.meas tran vdout1_72ck670 FIND v(dout1_72) AT=340.025n

.meas tran vdout1_73ck670 FIND v(dout1_73) AT=340.025n

.meas tran vdout1_74ck670 FIND v(dout1_74) AT=340.025n

.meas tran vdout1_75ck670 FIND v(dout1_75) AT=340.025n

.meas tran vdout1_76ck670 FIND v(dout1_76) AT=340.025n

.meas tran vdout1_77ck670 FIND v(dout1_77) AT=340.025n

.meas tran vdout1_78ck670 FIND v(dout1_78) AT=340.025n

.meas tran vdout1_79ck670 FIND v(dout1_79) AT=340.025n

.meas tran vdout1_80ck670 FIND v(dout1_80) AT=340.025n

.meas tran vdout1_81ck670 FIND v(dout1_81) AT=340.025n

.meas tran vdout1_82ck670 FIND v(dout1_82) AT=340.025n

.meas tran vdout1_83ck670 FIND v(dout1_83) AT=340.025n

.meas tran vdout1_84ck670 FIND v(dout1_84) AT=340.025n

.meas tran vdout1_85ck670 FIND v(dout1_85) AT=340.025n

.meas tran vdout1_86ck670 FIND v(dout1_86) AT=340.025n

.meas tran vdout1_87ck670 FIND v(dout1_87) AT=340.025n

.meas tran vdout1_88ck670 FIND v(dout1_88) AT=340.025n

.meas tran vdout1_89ck670 FIND v(dout1_89) AT=340.025n

.meas tran vdout1_90ck670 FIND v(dout1_90) AT=340.025n

.meas tran vdout1_91ck670 FIND v(dout1_91) AT=340.025n

.meas tran vdout1_92ck670 FIND v(dout1_92) AT=340.025n

.meas tran vdout1_93ck670 FIND v(dout1_93) AT=340.025n

.meas tran vdout1_94ck670 FIND v(dout1_94) AT=340.025n

.meas tran vdout1_95ck670 FIND v(dout1_95) AT=340.025n

.meas tran vdout1_96ck670 FIND v(dout1_96) AT=340.025n

.meas tran vdout1_97ck670 FIND v(dout1_97) AT=340.025n

.meas tran vdout1_98ck670 FIND v(dout1_98) AT=340.025n

.meas tran vdout1_99ck670 FIND v(dout1_99) AT=340.025n

.meas tran vdout1_100ck670 FIND v(dout1_100) AT=340.025n

.meas tran vdout1_101ck670 FIND v(dout1_101) AT=340.025n

.meas tran vdout1_102ck670 FIND v(dout1_102) AT=340.025n

.meas tran vdout1_103ck670 FIND v(dout1_103) AT=340.025n

.meas tran vdout1_104ck670 FIND v(dout1_104) AT=340.025n

.meas tran vdout1_105ck670 FIND v(dout1_105) AT=340.025n

.meas tran vdout1_106ck670 FIND v(dout1_106) AT=340.025n

.meas tran vdout1_107ck670 FIND v(dout1_107) AT=340.025n

.meas tran vdout1_108ck670 FIND v(dout1_108) AT=340.025n

.meas tran vdout1_109ck670 FIND v(dout1_109) AT=340.025n

.meas tran vdout1_110ck670 FIND v(dout1_110) AT=340.025n

.meas tran vdout1_111ck670 FIND v(dout1_111) AT=340.025n

.meas tran vdout1_112ck670 FIND v(dout1_112) AT=340.025n

.meas tran vdout1_113ck670 FIND v(dout1_113) AT=340.025n

.meas tran vdout1_114ck670 FIND v(dout1_114) AT=340.025n

.meas tran vdout1_115ck670 FIND v(dout1_115) AT=340.025n

.meas tran vdout1_116ck670 FIND v(dout1_116) AT=340.025n

.meas tran vdout1_117ck670 FIND v(dout1_117) AT=340.025n

.meas tran vdout1_118ck670 FIND v(dout1_118) AT=340.025n

.meas tran vdout1_119ck670 FIND v(dout1_119) AT=340.025n

.meas tran vdout1_120ck670 FIND v(dout1_120) AT=340.025n

.meas tran vdout1_121ck670 FIND v(dout1_121) AT=340.025n

.meas tran vdout1_122ck670 FIND v(dout1_122) AT=340.025n

.meas tran vdout1_123ck670 FIND v(dout1_123) AT=340.025n

.meas tran vdout1_124ck670 FIND v(dout1_124) AT=340.025n

.meas tran vdout1_125ck670 FIND v(dout1_125) AT=340.025n

.meas tran vdout1_126ck670 FIND v(dout1_126) AT=340.025n

.meas tran vdout1_127ck670 FIND v(dout1_127) AT=340.025n

.meas tran vdout1_0ck740 FIND v(dout1_0) AT=375.025n

.meas tran vdout1_1ck740 FIND v(dout1_1) AT=375.025n

.meas tran vdout1_2ck740 FIND v(dout1_2) AT=375.025n

.meas tran vdout1_3ck740 FIND v(dout1_3) AT=375.025n

.meas tran vdout1_4ck740 FIND v(dout1_4) AT=375.025n

.meas tran vdout1_5ck740 FIND v(dout1_5) AT=375.025n

.meas tran vdout1_6ck740 FIND v(dout1_6) AT=375.025n

.meas tran vdout1_7ck740 FIND v(dout1_7) AT=375.025n

.meas tran vdout1_8ck740 FIND v(dout1_8) AT=375.025n

.meas tran vdout1_9ck740 FIND v(dout1_9) AT=375.025n

.meas tran vdout1_10ck740 FIND v(dout1_10) AT=375.025n

.meas tran vdout1_11ck740 FIND v(dout1_11) AT=375.025n

.meas tran vdout1_12ck740 FIND v(dout1_12) AT=375.025n

.meas tran vdout1_13ck740 FIND v(dout1_13) AT=375.025n

.meas tran vdout1_14ck740 FIND v(dout1_14) AT=375.025n

.meas tran vdout1_15ck740 FIND v(dout1_15) AT=375.025n

.meas tran vdout1_16ck740 FIND v(dout1_16) AT=375.025n

.meas tran vdout1_17ck740 FIND v(dout1_17) AT=375.025n

.meas tran vdout1_18ck740 FIND v(dout1_18) AT=375.025n

.meas tran vdout1_19ck740 FIND v(dout1_19) AT=375.025n

.meas tran vdout1_20ck740 FIND v(dout1_20) AT=375.025n

.meas tran vdout1_21ck740 FIND v(dout1_21) AT=375.025n

.meas tran vdout1_22ck740 FIND v(dout1_22) AT=375.025n

.meas tran vdout1_23ck740 FIND v(dout1_23) AT=375.025n

.meas tran vdout1_24ck740 FIND v(dout1_24) AT=375.025n

.meas tran vdout1_25ck740 FIND v(dout1_25) AT=375.025n

.meas tran vdout1_26ck740 FIND v(dout1_26) AT=375.025n

.meas tran vdout1_27ck740 FIND v(dout1_27) AT=375.025n

.meas tran vdout1_28ck740 FIND v(dout1_28) AT=375.025n

.meas tran vdout1_29ck740 FIND v(dout1_29) AT=375.025n

.meas tran vdout1_30ck740 FIND v(dout1_30) AT=375.025n

.meas tran vdout1_31ck740 FIND v(dout1_31) AT=375.025n

.meas tran vdout1_32ck740 FIND v(dout1_32) AT=375.025n

.meas tran vdout1_33ck740 FIND v(dout1_33) AT=375.025n

.meas tran vdout1_34ck740 FIND v(dout1_34) AT=375.025n

.meas tran vdout1_35ck740 FIND v(dout1_35) AT=375.025n

.meas tran vdout1_36ck740 FIND v(dout1_36) AT=375.025n

.meas tran vdout1_37ck740 FIND v(dout1_37) AT=375.025n

.meas tran vdout1_38ck740 FIND v(dout1_38) AT=375.025n

.meas tran vdout1_39ck740 FIND v(dout1_39) AT=375.025n

.meas tran vdout1_40ck740 FIND v(dout1_40) AT=375.025n

.meas tran vdout1_41ck740 FIND v(dout1_41) AT=375.025n

.meas tran vdout1_42ck740 FIND v(dout1_42) AT=375.025n

.meas tran vdout1_43ck740 FIND v(dout1_43) AT=375.025n

.meas tran vdout1_44ck740 FIND v(dout1_44) AT=375.025n

.meas tran vdout1_45ck740 FIND v(dout1_45) AT=375.025n

.meas tran vdout1_46ck740 FIND v(dout1_46) AT=375.025n

.meas tran vdout1_47ck740 FIND v(dout1_47) AT=375.025n

.meas tran vdout1_48ck740 FIND v(dout1_48) AT=375.025n

.meas tran vdout1_49ck740 FIND v(dout1_49) AT=375.025n

.meas tran vdout1_50ck740 FIND v(dout1_50) AT=375.025n

.meas tran vdout1_51ck740 FIND v(dout1_51) AT=375.025n

.meas tran vdout1_52ck740 FIND v(dout1_52) AT=375.025n

.meas tran vdout1_53ck740 FIND v(dout1_53) AT=375.025n

.meas tran vdout1_54ck740 FIND v(dout1_54) AT=375.025n

.meas tran vdout1_55ck740 FIND v(dout1_55) AT=375.025n

.meas tran vdout1_56ck740 FIND v(dout1_56) AT=375.025n

.meas tran vdout1_57ck740 FIND v(dout1_57) AT=375.025n

.meas tran vdout1_58ck740 FIND v(dout1_58) AT=375.025n

.meas tran vdout1_59ck740 FIND v(dout1_59) AT=375.025n

.meas tran vdout1_60ck740 FIND v(dout1_60) AT=375.025n

.meas tran vdout1_61ck740 FIND v(dout1_61) AT=375.025n

.meas tran vdout1_62ck740 FIND v(dout1_62) AT=375.025n

.meas tran vdout1_63ck740 FIND v(dout1_63) AT=375.025n

.meas tran vdout1_64ck740 FIND v(dout1_64) AT=375.025n

.meas tran vdout1_65ck740 FIND v(dout1_65) AT=375.025n

.meas tran vdout1_66ck740 FIND v(dout1_66) AT=375.025n

.meas tran vdout1_67ck740 FIND v(dout1_67) AT=375.025n

.meas tran vdout1_68ck740 FIND v(dout1_68) AT=375.025n

.meas tran vdout1_69ck740 FIND v(dout1_69) AT=375.025n

.meas tran vdout1_70ck740 FIND v(dout1_70) AT=375.025n

.meas tran vdout1_71ck740 FIND v(dout1_71) AT=375.025n

.meas tran vdout1_72ck740 FIND v(dout1_72) AT=375.025n

.meas tran vdout1_73ck740 FIND v(dout1_73) AT=375.025n

.meas tran vdout1_74ck740 FIND v(dout1_74) AT=375.025n

.meas tran vdout1_75ck740 FIND v(dout1_75) AT=375.025n

.meas tran vdout1_76ck740 FIND v(dout1_76) AT=375.025n

.meas tran vdout1_77ck740 FIND v(dout1_77) AT=375.025n

.meas tran vdout1_78ck740 FIND v(dout1_78) AT=375.025n

.meas tran vdout1_79ck740 FIND v(dout1_79) AT=375.025n

.meas tran vdout1_80ck740 FIND v(dout1_80) AT=375.025n

.meas tran vdout1_81ck740 FIND v(dout1_81) AT=375.025n

.meas tran vdout1_82ck740 FIND v(dout1_82) AT=375.025n

.meas tran vdout1_83ck740 FIND v(dout1_83) AT=375.025n

.meas tran vdout1_84ck740 FIND v(dout1_84) AT=375.025n

.meas tran vdout1_85ck740 FIND v(dout1_85) AT=375.025n

.meas tran vdout1_86ck740 FIND v(dout1_86) AT=375.025n

.meas tran vdout1_87ck740 FIND v(dout1_87) AT=375.025n

.meas tran vdout1_88ck740 FIND v(dout1_88) AT=375.025n

.meas tran vdout1_89ck740 FIND v(dout1_89) AT=375.025n

.meas tran vdout1_90ck740 FIND v(dout1_90) AT=375.025n

.meas tran vdout1_91ck740 FIND v(dout1_91) AT=375.025n

.meas tran vdout1_92ck740 FIND v(dout1_92) AT=375.025n

.meas tran vdout1_93ck740 FIND v(dout1_93) AT=375.025n

.meas tran vdout1_94ck740 FIND v(dout1_94) AT=375.025n

.meas tran vdout1_95ck740 FIND v(dout1_95) AT=375.025n

.meas tran vdout1_96ck740 FIND v(dout1_96) AT=375.025n

.meas tran vdout1_97ck740 FIND v(dout1_97) AT=375.025n

.meas tran vdout1_98ck740 FIND v(dout1_98) AT=375.025n

.meas tran vdout1_99ck740 FIND v(dout1_99) AT=375.025n

.meas tran vdout1_100ck740 FIND v(dout1_100) AT=375.025n

.meas tran vdout1_101ck740 FIND v(dout1_101) AT=375.025n

.meas tran vdout1_102ck740 FIND v(dout1_102) AT=375.025n

.meas tran vdout1_103ck740 FIND v(dout1_103) AT=375.025n

.meas tran vdout1_104ck740 FIND v(dout1_104) AT=375.025n

.meas tran vdout1_105ck740 FIND v(dout1_105) AT=375.025n

.meas tran vdout1_106ck740 FIND v(dout1_106) AT=375.025n

.meas tran vdout1_107ck740 FIND v(dout1_107) AT=375.025n

.meas tran vdout1_108ck740 FIND v(dout1_108) AT=375.025n

.meas tran vdout1_109ck740 FIND v(dout1_109) AT=375.025n

.meas tran vdout1_110ck740 FIND v(dout1_110) AT=375.025n

.meas tran vdout1_111ck740 FIND v(dout1_111) AT=375.025n

.meas tran vdout1_112ck740 FIND v(dout1_112) AT=375.025n

.meas tran vdout1_113ck740 FIND v(dout1_113) AT=375.025n

.meas tran vdout1_114ck740 FIND v(dout1_114) AT=375.025n

.meas tran vdout1_115ck740 FIND v(dout1_115) AT=375.025n

.meas tran vdout1_116ck740 FIND v(dout1_116) AT=375.025n

.meas tran vdout1_117ck740 FIND v(dout1_117) AT=375.025n

.meas tran vdout1_118ck740 FIND v(dout1_118) AT=375.025n

.meas tran vdout1_119ck740 FIND v(dout1_119) AT=375.025n

.meas tran vdout1_120ck740 FIND v(dout1_120) AT=375.025n

.meas tran vdout1_121ck740 FIND v(dout1_121) AT=375.025n

.meas tran vdout1_122ck740 FIND v(dout1_122) AT=375.025n

.meas tran vdout1_123ck740 FIND v(dout1_123) AT=375.025n

.meas tran vdout1_124ck740 FIND v(dout1_124) AT=375.025n

.meas tran vdout1_125ck740 FIND v(dout1_125) AT=375.025n

.meas tran vdout1_126ck740 FIND v(dout1_126) AT=375.025n

.meas tran vdout1_127ck740 FIND v(dout1_127) AT=375.025n

.meas tran vdout1_0ck770 FIND v(dout1_0) AT=390.025n

.meas tran vdout1_1ck770 FIND v(dout1_1) AT=390.025n

.meas tran vdout1_2ck770 FIND v(dout1_2) AT=390.025n

.meas tran vdout1_3ck770 FIND v(dout1_3) AT=390.025n

.meas tran vdout1_4ck770 FIND v(dout1_4) AT=390.025n

.meas tran vdout1_5ck770 FIND v(dout1_5) AT=390.025n

.meas tran vdout1_6ck770 FIND v(dout1_6) AT=390.025n

.meas tran vdout1_7ck770 FIND v(dout1_7) AT=390.025n

.meas tran vdout1_8ck770 FIND v(dout1_8) AT=390.025n

.meas tran vdout1_9ck770 FIND v(dout1_9) AT=390.025n

.meas tran vdout1_10ck770 FIND v(dout1_10) AT=390.025n

.meas tran vdout1_11ck770 FIND v(dout1_11) AT=390.025n

.meas tran vdout1_12ck770 FIND v(dout1_12) AT=390.025n

.meas tran vdout1_13ck770 FIND v(dout1_13) AT=390.025n

.meas tran vdout1_14ck770 FIND v(dout1_14) AT=390.025n

.meas tran vdout1_15ck770 FIND v(dout1_15) AT=390.025n

.meas tran vdout1_16ck770 FIND v(dout1_16) AT=390.025n

.meas tran vdout1_17ck770 FIND v(dout1_17) AT=390.025n

.meas tran vdout1_18ck770 FIND v(dout1_18) AT=390.025n

.meas tran vdout1_19ck770 FIND v(dout1_19) AT=390.025n

.meas tran vdout1_20ck770 FIND v(dout1_20) AT=390.025n

.meas tran vdout1_21ck770 FIND v(dout1_21) AT=390.025n

.meas tran vdout1_22ck770 FIND v(dout1_22) AT=390.025n

.meas tran vdout1_23ck770 FIND v(dout1_23) AT=390.025n

.meas tran vdout1_24ck770 FIND v(dout1_24) AT=390.025n

.meas tran vdout1_25ck770 FIND v(dout1_25) AT=390.025n

.meas tran vdout1_26ck770 FIND v(dout1_26) AT=390.025n

.meas tran vdout1_27ck770 FIND v(dout1_27) AT=390.025n

.meas tran vdout1_28ck770 FIND v(dout1_28) AT=390.025n

.meas tran vdout1_29ck770 FIND v(dout1_29) AT=390.025n

.meas tran vdout1_30ck770 FIND v(dout1_30) AT=390.025n

.meas tran vdout1_31ck770 FIND v(dout1_31) AT=390.025n

.meas tran vdout1_32ck770 FIND v(dout1_32) AT=390.025n

.meas tran vdout1_33ck770 FIND v(dout1_33) AT=390.025n

.meas tran vdout1_34ck770 FIND v(dout1_34) AT=390.025n

.meas tran vdout1_35ck770 FIND v(dout1_35) AT=390.025n

.meas tran vdout1_36ck770 FIND v(dout1_36) AT=390.025n

.meas tran vdout1_37ck770 FIND v(dout1_37) AT=390.025n

.meas tran vdout1_38ck770 FIND v(dout1_38) AT=390.025n

.meas tran vdout1_39ck770 FIND v(dout1_39) AT=390.025n

.meas tran vdout1_40ck770 FIND v(dout1_40) AT=390.025n

.meas tran vdout1_41ck770 FIND v(dout1_41) AT=390.025n

.meas tran vdout1_42ck770 FIND v(dout1_42) AT=390.025n

.meas tran vdout1_43ck770 FIND v(dout1_43) AT=390.025n

.meas tran vdout1_44ck770 FIND v(dout1_44) AT=390.025n

.meas tran vdout1_45ck770 FIND v(dout1_45) AT=390.025n

.meas tran vdout1_46ck770 FIND v(dout1_46) AT=390.025n

.meas tran vdout1_47ck770 FIND v(dout1_47) AT=390.025n

.meas tran vdout1_48ck770 FIND v(dout1_48) AT=390.025n

.meas tran vdout1_49ck770 FIND v(dout1_49) AT=390.025n

.meas tran vdout1_50ck770 FIND v(dout1_50) AT=390.025n

.meas tran vdout1_51ck770 FIND v(dout1_51) AT=390.025n

.meas tran vdout1_52ck770 FIND v(dout1_52) AT=390.025n

.meas tran vdout1_53ck770 FIND v(dout1_53) AT=390.025n

.meas tran vdout1_54ck770 FIND v(dout1_54) AT=390.025n

.meas tran vdout1_55ck770 FIND v(dout1_55) AT=390.025n

.meas tran vdout1_56ck770 FIND v(dout1_56) AT=390.025n

.meas tran vdout1_57ck770 FIND v(dout1_57) AT=390.025n

.meas tran vdout1_58ck770 FIND v(dout1_58) AT=390.025n

.meas tran vdout1_59ck770 FIND v(dout1_59) AT=390.025n

.meas tran vdout1_60ck770 FIND v(dout1_60) AT=390.025n

.meas tran vdout1_61ck770 FIND v(dout1_61) AT=390.025n

.meas tran vdout1_62ck770 FIND v(dout1_62) AT=390.025n

.meas tran vdout1_63ck770 FIND v(dout1_63) AT=390.025n

.meas tran vdout1_64ck770 FIND v(dout1_64) AT=390.025n

.meas tran vdout1_65ck770 FIND v(dout1_65) AT=390.025n

.meas tran vdout1_66ck770 FIND v(dout1_66) AT=390.025n

.meas tran vdout1_67ck770 FIND v(dout1_67) AT=390.025n

.meas tran vdout1_68ck770 FIND v(dout1_68) AT=390.025n

.meas tran vdout1_69ck770 FIND v(dout1_69) AT=390.025n

.meas tran vdout1_70ck770 FIND v(dout1_70) AT=390.025n

.meas tran vdout1_71ck770 FIND v(dout1_71) AT=390.025n

.meas tran vdout1_72ck770 FIND v(dout1_72) AT=390.025n

.meas tran vdout1_73ck770 FIND v(dout1_73) AT=390.025n

.meas tran vdout1_74ck770 FIND v(dout1_74) AT=390.025n

.meas tran vdout1_75ck770 FIND v(dout1_75) AT=390.025n

.meas tran vdout1_76ck770 FIND v(dout1_76) AT=390.025n

.meas tran vdout1_77ck770 FIND v(dout1_77) AT=390.025n

.meas tran vdout1_78ck770 FIND v(dout1_78) AT=390.025n

.meas tran vdout1_79ck770 FIND v(dout1_79) AT=390.025n

.meas tran vdout1_80ck770 FIND v(dout1_80) AT=390.025n

.meas tran vdout1_81ck770 FIND v(dout1_81) AT=390.025n

.meas tran vdout1_82ck770 FIND v(dout1_82) AT=390.025n

.meas tran vdout1_83ck770 FIND v(dout1_83) AT=390.025n

.meas tran vdout1_84ck770 FIND v(dout1_84) AT=390.025n

.meas tran vdout1_85ck770 FIND v(dout1_85) AT=390.025n

.meas tran vdout1_86ck770 FIND v(dout1_86) AT=390.025n

.meas tran vdout1_87ck770 FIND v(dout1_87) AT=390.025n

.meas tran vdout1_88ck770 FIND v(dout1_88) AT=390.025n

.meas tran vdout1_89ck770 FIND v(dout1_89) AT=390.025n

.meas tran vdout1_90ck770 FIND v(dout1_90) AT=390.025n

.meas tran vdout1_91ck770 FIND v(dout1_91) AT=390.025n

.meas tran vdout1_92ck770 FIND v(dout1_92) AT=390.025n

.meas tran vdout1_93ck770 FIND v(dout1_93) AT=390.025n

.meas tran vdout1_94ck770 FIND v(dout1_94) AT=390.025n

.meas tran vdout1_95ck770 FIND v(dout1_95) AT=390.025n

.meas tran vdout1_96ck770 FIND v(dout1_96) AT=390.025n

.meas tran vdout1_97ck770 FIND v(dout1_97) AT=390.025n

.meas tran vdout1_98ck770 FIND v(dout1_98) AT=390.025n

.meas tran vdout1_99ck770 FIND v(dout1_99) AT=390.025n

.meas tran vdout1_100ck770 FIND v(dout1_100) AT=390.025n

.meas tran vdout1_101ck770 FIND v(dout1_101) AT=390.025n

.meas tran vdout1_102ck770 FIND v(dout1_102) AT=390.025n

.meas tran vdout1_103ck770 FIND v(dout1_103) AT=390.025n

.meas tran vdout1_104ck770 FIND v(dout1_104) AT=390.025n

.meas tran vdout1_105ck770 FIND v(dout1_105) AT=390.025n

.meas tran vdout1_106ck770 FIND v(dout1_106) AT=390.025n

.meas tran vdout1_107ck770 FIND v(dout1_107) AT=390.025n

.meas tran vdout1_108ck770 FIND v(dout1_108) AT=390.025n

.meas tran vdout1_109ck770 FIND v(dout1_109) AT=390.025n

.meas tran vdout1_110ck770 FIND v(dout1_110) AT=390.025n

.meas tran vdout1_111ck770 FIND v(dout1_111) AT=390.025n

.meas tran vdout1_112ck770 FIND v(dout1_112) AT=390.025n

.meas tran vdout1_113ck770 FIND v(dout1_113) AT=390.025n

.meas tran vdout1_114ck770 FIND v(dout1_114) AT=390.025n

.meas tran vdout1_115ck770 FIND v(dout1_115) AT=390.025n

.meas tran vdout1_116ck770 FIND v(dout1_116) AT=390.025n

.meas tran vdout1_117ck770 FIND v(dout1_117) AT=390.025n

.meas tran vdout1_118ck770 FIND v(dout1_118) AT=390.025n

.meas tran vdout1_119ck770 FIND v(dout1_119) AT=390.025n

.meas tran vdout1_120ck770 FIND v(dout1_120) AT=390.025n

.meas tran vdout1_121ck770 FIND v(dout1_121) AT=390.025n

.meas tran vdout1_122ck770 FIND v(dout1_122) AT=390.025n

.meas tran vdout1_123ck770 FIND v(dout1_123) AT=390.025n

.meas tran vdout1_124ck770 FIND v(dout1_124) AT=390.025n

.meas tran vdout1_125ck770 FIND v(dout1_125) AT=390.025n

.meas tran vdout1_126ck770 FIND v(dout1_126) AT=390.025n

.meas tran vdout1_127ck770 FIND v(dout1_127) AT=390.025n

.meas tran vdout1_0ck790 FIND v(dout1_0) AT=400.025n

.meas tran vdout1_1ck790 FIND v(dout1_1) AT=400.025n

.meas tran vdout1_2ck790 FIND v(dout1_2) AT=400.025n

.meas tran vdout1_3ck790 FIND v(dout1_3) AT=400.025n

.meas tran vdout1_4ck790 FIND v(dout1_4) AT=400.025n

.meas tran vdout1_5ck790 FIND v(dout1_5) AT=400.025n

.meas tran vdout1_6ck790 FIND v(dout1_6) AT=400.025n

.meas tran vdout1_7ck790 FIND v(dout1_7) AT=400.025n

.meas tran vdout1_8ck790 FIND v(dout1_8) AT=400.025n

.meas tran vdout1_9ck790 FIND v(dout1_9) AT=400.025n

.meas tran vdout1_10ck790 FIND v(dout1_10) AT=400.025n

.meas tran vdout1_11ck790 FIND v(dout1_11) AT=400.025n

.meas tran vdout1_12ck790 FIND v(dout1_12) AT=400.025n

.meas tran vdout1_13ck790 FIND v(dout1_13) AT=400.025n

.meas tran vdout1_14ck790 FIND v(dout1_14) AT=400.025n

.meas tran vdout1_15ck790 FIND v(dout1_15) AT=400.025n

.meas tran vdout1_16ck790 FIND v(dout1_16) AT=400.025n

.meas tran vdout1_17ck790 FIND v(dout1_17) AT=400.025n

.meas tran vdout1_18ck790 FIND v(dout1_18) AT=400.025n

.meas tran vdout1_19ck790 FIND v(dout1_19) AT=400.025n

.meas tran vdout1_20ck790 FIND v(dout1_20) AT=400.025n

.meas tran vdout1_21ck790 FIND v(dout1_21) AT=400.025n

.meas tran vdout1_22ck790 FIND v(dout1_22) AT=400.025n

.meas tran vdout1_23ck790 FIND v(dout1_23) AT=400.025n

.meas tran vdout1_24ck790 FIND v(dout1_24) AT=400.025n

.meas tran vdout1_25ck790 FIND v(dout1_25) AT=400.025n

.meas tran vdout1_26ck790 FIND v(dout1_26) AT=400.025n

.meas tran vdout1_27ck790 FIND v(dout1_27) AT=400.025n

.meas tran vdout1_28ck790 FIND v(dout1_28) AT=400.025n

.meas tran vdout1_29ck790 FIND v(dout1_29) AT=400.025n

.meas tran vdout1_30ck790 FIND v(dout1_30) AT=400.025n

.meas tran vdout1_31ck790 FIND v(dout1_31) AT=400.025n

.meas tran vdout1_32ck790 FIND v(dout1_32) AT=400.025n

.meas tran vdout1_33ck790 FIND v(dout1_33) AT=400.025n

.meas tran vdout1_34ck790 FIND v(dout1_34) AT=400.025n

.meas tran vdout1_35ck790 FIND v(dout1_35) AT=400.025n

.meas tran vdout1_36ck790 FIND v(dout1_36) AT=400.025n

.meas tran vdout1_37ck790 FIND v(dout1_37) AT=400.025n

.meas tran vdout1_38ck790 FIND v(dout1_38) AT=400.025n

.meas tran vdout1_39ck790 FIND v(dout1_39) AT=400.025n

.meas tran vdout1_40ck790 FIND v(dout1_40) AT=400.025n

.meas tran vdout1_41ck790 FIND v(dout1_41) AT=400.025n

.meas tran vdout1_42ck790 FIND v(dout1_42) AT=400.025n

.meas tran vdout1_43ck790 FIND v(dout1_43) AT=400.025n

.meas tran vdout1_44ck790 FIND v(dout1_44) AT=400.025n

.meas tran vdout1_45ck790 FIND v(dout1_45) AT=400.025n

.meas tran vdout1_46ck790 FIND v(dout1_46) AT=400.025n

.meas tran vdout1_47ck790 FIND v(dout1_47) AT=400.025n

.meas tran vdout1_48ck790 FIND v(dout1_48) AT=400.025n

.meas tran vdout1_49ck790 FIND v(dout1_49) AT=400.025n

.meas tran vdout1_50ck790 FIND v(dout1_50) AT=400.025n

.meas tran vdout1_51ck790 FIND v(dout1_51) AT=400.025n

.meas tran vdout1_52ck790 FIND v(dout1_52) AT=400.025n

.meas tran vdout1_53ck790 FIND v(dout1_53) AT=400.025n

.meas tran vdout1_54ck790 FIND v(dout1_54) AT=400.025n

.meas tran vdout1_55ck790 FIND v(dout1_55) AT=400.025n

.meas tran vdout1_56ck790 FIND v(dout1_56) AT=400.025n

.meas tran vdout1_57ck790 FIND v(dout1_57) AT=400.025n

.meas tran vdout1_58ck790 FIND v(dout1_58) AT=400.025n

.meas tran vdout1_59ck790 FIND v(dout1_59) AT=400.025n

.meas tran vdout1_60ck790 FIND v(dout1_60) AT=400.025n

.meas tran vdout1_61ck790 FIND v(dout1_61) AT=400.025n

.meas tran vdout1_62ck790 FIND v(dout1_62) AT=400.025n

.meas tran vdout1_63ck790 FIND v(dout1_63) AT=400.025n

.meas tran vdout1_64ck790 FIND v(dout1_64) AT=400.025n

.meas tran vdout1_65ck790 FIND v(dout1_65) AT=400.025n

.meas tran vdout1_66ck790 FIND v(dout1_66) AT=400.025n

.meas tran vdout1_67ck790 FIND v(dout1_67) AT=400.025n

.meas tran vdout1_68ck790 FIND v(dout1_68) AT=400.025n

.meas tran vdout1_69ck790 FIND v(dout1_69) AT=400.025n

.meas tran vdout1_70ck790 FIND v(dout1_70) AT=400.025n

.meas tran vdout1_71ck790 FIND v(dout1_71) AT=400.025n

.meas tran vdout1_72ck790 FIND v(dout1_72) AT=400.025n

.meas tran vdout1_73ck790 FIND v(dout1_73) AT=400.025n

.meas tran vdout1_74ck790 FIND v(dout1_74) AT=400.025n

.meas tran vdout1_75ck790 FIND v(dout1_75) AT=400.025n

.meas tran vdout1_76ck790 FIND v(dout1_76) AT=400.025n

.meas tran vdout1_77ck790 FIND v(dout1_77) AT=400.025n

.meas tran vdout1_78ck790 FIND v(dout1_78) AT=400.025n

.meas tran vdout1_79ck790 FIND v(dout1_79) AT=400.025n

.meas tran vdout1_80ck790 FIND v(dout1_80) AT=400.025n

.meas tran vdout1_81ck790 FIND v(dout1_81) AT=400.025n

.meas tran vdout1_82ck790 FIND v(dout1_82) AT=400.025n

.meas tran vdout1_83ck790 FIND v(dout1_83) AT=400.025n

.meas tran vdout1_84ck790 FIND v(dout1_84) AT=400.025n

.meas tran vdout1_85ck790 FIND v(dout1_85) AT=400.025n

.meas tran vdout1_86ck790 FIND v(dout1_86) AT=400.025n

.meas tran vdout1_87ck790 FIND v(dout1_87) AT=400.025n

.meas tran vdout1_88ck790 FIND v(dout1_88) AT=400.025n

.meas tran vdout1_89ck790 FIND v(dout1_89) AT=400.025n

.meas tran vdout1_90ck790 FIND v(dout1_90) AT=400.025n

.meas tran vdout1_91ck790 FIND v(dout1_91) AT=400.025n

.meas tran vdout1_92ck790 FIND v(dout1_92) AT=400.025n

.meas tran vdout1_93ck790 FIND v(dout1_93) AT=400.025n

.meas tran vdout1_94ck790 FIND v(dout1_94) AT=400.025n

.meas tran vdout1_95ck790 FIND v(dout1_95) AT=400.025n

.meas tran vdout1_96ck790 FIND v(dout1_96) AT=400.025n

.meas tran vdout1_97ck790 FIND v(dout1_97) AT=400.025n

.meas tran vdout1_98ck790 FIND v(dout1_98) AT=400.025n

.meas tran vdout1_99ck790 FIND v(dout1_99) AT=400.025n

.meas tran vdout1_100ck790 FIND v(dout1_100) AT=400.025n

.meas tran vdout1_101ck790 FIND v(dout1_101) AT=400.025n

.meas tran vdout1_102ck790 FIND v(dout1_102) AT=400.025n

.meas tran vdout1_103ck790 FIND v(dout1_103) AT=400.025n

.meas tran vdout1_104ck790 FIND v(dout1_104) AT=400.025n

.meas tran vdout1_105ck790 FIND v(dout1_105) AT=400.025n

.meas tran vdout1_106ck790 FIND v(dout1_106) AT=400.025n

.meas tran vdout1_107ck790 FIND v(dout1_107) AT=400.025n

.meas tran vdout1_108ck790 FIND v(dout1_108) AT=400.025n

.meas tran vdout1_109ck790 FIND v(dout1_109) AT=400.025n

.meas tran vdout1_110ck790 FIND v(dout1_110) AT=400.025n

.meas tran vdout1_111ck790 FIND v(dout1_111) AT=400.025n

.meas tran vdout1_112ck790 FIND v(dout1_112) AT=400.025n

.meas tran vdout1_113ck790 FIND v(dout1_113) AT=400.025n

.meas tran vdout1_114ck790 FIND v(dout1_114) AT=400.025n

.meas tran vdout1_115ck790 FIND v(dout1_115) AT=400.025n

.meas tran vdout1_116ck790 FIND v(dout1_116) AT=400.025n

.meas tran vdout1_117ck790 FIND v(dout1_117) AT=400.025n

.meas tran vdout1_118ck790 FIND v(dout1_118) AT=400.025n

.meas tran vdout1_119ck790 FIND v(dout1_119) AT=400.025n

.meas tran vdout1_120ck790 FIND v(dout1_120) AT=400.025n

.meas tran vdout1_121ck790 FIND v(dout1_121) AT=400.025n

.meas tran vdout1_122ck790 FIND v(dout1_122) AT=400.025n

.meas tran vdout1_123ck790 FIND v(dout1_123) AT=400.025n

.meas tran vdout1_124ck790 FIND v(dout1_124) AT=400.025n

.meas tran vdout1_125ck790 FIND v(dout1_125) AT=400.025n

.meas tran vdout1_126ck790 FIND v(dout1_126) AT=400.025n

.meas tran vdout1_127ck790 FIND v(dout1_127) AT=400.025n

.meas tran vdout1_0ck820 FIND v(dout1_0) AT=415.025n

.meas tran vdout1_1ck820 FIND v(dout1_1) AT=415.025n

.meas tran vdout1_2ck820 FIND v(dout1_2) AT=415.025n

.meas tran vdout1_3ck820 FIND v(dout1_3) AT=415.025n

.meas tran vdout1_4ck820 FIND v(dout1_4) AT=415.025n

.meas tran vdout1_5ck820 FIND v(dout1_5) AT=415.025n

.meas tran vdout1_6ck820 FIND v(dout1_6) AT=415.025n

.meas tran vdout1_7ck820 FIND v(dout1_7) AT=415.025n

.meas tran vdout1_8ck820 FIND v(dout1_8) AT=415.025n

.meas tran vdout1_9ck820 FIND v(dout1_9) AT=415.025n

.meas tran vdout1_10ck820 FIND v(dout1_10) AT=415.025n

.meas tran vdout1_11ck820 FIND v(dout1_11) AT=415.025n

.meas tran vdout1_12ck820 FIND v(dout1_12) AT=415.025n

.meas tran vdout1_13ck820 FIND v(dout1_13) AT=415.025n

.meas tran vdout1_14ck820 FIND v(dout1_14) AT=415.025n

.meas tran vdout1_15ck820 FIND v(dout1_15) AT=415.025n

.meas tran vdout1_16ck820 FIND v(dout1_16) AT=415.025n

.meas tran vdout1_17ck820 FIND v(dout1_17) AT=415.025n

.meas tran vdout1_18ck820 FIND v(dout1_18) AT=415.025n

.meas tran vdout1_19ck820 FIND v(dout1_19) AT=415.025n

.meas tran vdout1_20ck820 FIND v(dout1_20) AT=415.025n

.meas tran vdout1_21ck820 FIND v(dout1_21) AT=415.025n

.meas tran vdout1_22ck820 FIND v(dout1_22) AT=415.025n

.meas tran vdout1_23ck820 FIND v(dout1_23) AT=415.025n

.meas tran vdout1_24ck820 FIND v(dout1_24) AT=415.025n

.meas tran vdout1_25ck820 FIND v(dout1_25) AT=415.025n

.meas tran vdout1_26ck820 FIND v(dout1_26) AT=415.025n

.meas tran vdout1_27ck820 FIND v(dout1_27) AT=415.025n

.meas tran vdout1_28ck820 FIND v(dout1_28) AT=415.025n

.meas tran vdout1_29ck820 FIND v(dout1_29) AT=415.025n

.meas tran vdout1_30ck820 FIND v(dout1_30) AT=415.025n

.meas tran vdout1_31ck820 FIND v(dout1_31) AT=415.025n

.meas tran vdout1_32ck820 FIND v(dout1_32) AT=415.025n

.meas tran vdout1_33ck820 FIND v(dout1_33) AT=415.025n

.meas tran vdout1_34ck820 FIND v(dout1_34) AT=415.025n

.meas tran vdout1_35ck820 FIND v(dout1_35) AT=415.025n

.meas tran vdout1_36ck820 FIND v(dout1_36) AT=415.025n

.meas tran vdout1_37ck820 FIND v(dout1_37) AT=415.025n

.meas tran vdout1_38ck820 FIND v(dout1_38) AT=415.025n

.meas tran vdout1_39ck820 FIND v(dout1_39) AT=415.025n

.meas tran vdout1_40ck820 FIND v(dout1_40) AT=415.025n

.meas tran vdout1_41ck820 FIND v(dout1_41) AT=415.025n

.meas tran vdout1_42ck820 FIND v(dout1_42) AT=415.025n

.meas tran vdout1_43ck820 FIND v(dout1_43) AT=415.025n

.meas tran vdout1_44ck820 FIND v(dout1_44) AT=415.025n

.meas tran vdout1_45ck820 FIND v(dout1_45) AT=415.025n

.meas tran vdout1_46ck820 FIND v(dout1_46) AT=415.025n

.meas tran vdout1_47ck820 FIND v(dout1_47) AT=415.025n

.meas tran vdout1_48ck820 FIND v(dout1_48) AT=415.025n

.meas tran vdout1_49ck820 FIND v(dout1_49) AT=415.025n

.meas tran vdout1_50ck820 FIND v(dout1_50) AT=415.025n

.meas tran vdout1_51ck820 FIND v(dout1_51) AT=415.025n

.meas tran vdout1_52ck820 FIND v(dout1_52) AT=415.025n

.meas tran vdout1_53ck820 FIND v(dout1_53) AT=415.025n

.meas tran vdout1_54ck820 FIND v(dout1_54) AT=415.025n

.meas tran vdout1_55ck820 FIND v(dout1_55) AT=415.025n

.meas tran vdout1_56ck820 FIND v(dout1_56) AT=415.025n

.meas tran vdout1_57ck820 FIND v(dout1_57) AT=415.025n

.meas tran vdout1_58ck820 FIND v(dout1_58) AT=415.025n

.meas tran vdout1_59ck820 FIND v(dout1_59) AT=415.025n

.meas tran vdout1_60ck820 FIND v(dout1_60) AT=415.025n

.meas tran vdout1_61ck820 FIND v(dout1_61) AT=415.025n

.meas tran vdout1_62ck820 FIND v(dout1_62) AT=415.025n

.meas tran vdout1_63ck820 FIND v(dout1_63) AT=415.025n

.meas tran vdout1_64ck820 FIND v(dout1_64) AT=415.025n

.meas tran vdout1_65ck820 FIND v(dout1_65) AT=415.025n

.meas tran vdout1_66ck820 FIND v(dout1_66) AT=415.025n

.meas tran vdout1_67ck820 FIND v(dout1_67) AT=415.025n

.meas tran vdout1_68ck820 FIND v(dout1_68) AT=415.025n

.meas tran vdout1_69ck820 FIND v(dout1_69) AT=415.025n

.meas tran vdout1_70ck820 FIND v(dout1_70) AT=415.025n

.meas tran vdout1_71ck820 FIND v(dout1_71) AT=415.025n

.meas tran vdout1_72ck820 FIND v(dout1_72) AT=415.025n

.meas tran vdout1_73ck820 FIND v(dout1_73) AT=415.025n

.meas tran vdout1_74ck820 FIND v(dout1_74) AT=415.025n

.meas tran vdout1_75ck820 FIND v(dout1_75) AT=415.025n

.meas tran vdout1_76ck820 FIND v(dout1_76) AT=415.025n

.meas tran vdout1_77ck820 FIND v(dout1_77) AT=415.025n

.meas tran vdout1_78ck820 FIND v(dout1_78) AT=415.025n

.meas tran vdout1_79ck820 FIND v(dout1_79) AT=415.025n

.meas tran vdout1_80ck820 FIND v(dout1_80) AT=415.025n

.meas tran vdout1_81ck820 FIND v(dout1_81) AT=415.025n

.meas tran vdout1_82ck820 FIND v(dout1_82) AT=415.025n

.meas tran vdout1_83ck820 FIND v(dout1_83) AT=415.025n

.meas tran vdout1_84ck820 FIND v(dout1_84) AT=415.025n

.meas tran vdout1_85ck820 FIND v(dout1_85) AT=415.025n

.meas tran vdout1_86ck820 FIND v(dout1_86) AT=415.025n

.meas tran vdout1_87ck820 FIND v(dout1_87) AT=415.025n

.meas tran vdout1_88ck820 FIND v(dout1_88) AT=415.025n

.meas tran vdout1_89ck820 FIND v(dout1_89) AT=415.025n

.meas tran vdout1_90ck820 FIND v(dout1_90) AT=415.025n

.meas tran vdout1_91ck820 FIND v(dout1_91) AT=415.025n

.meas tran vdout1_92ck820 FIND v(dout1_92) AT=415.025n

.meas tran vdout1_93ck820 FIND v(dout1_93) AT=415.025n

.meas tran vdout1_94ck820 FIND v(dout1_94) AT=415.025n

.meas tran vdout1_95ck820 FIND v(dout1_95) AT=415.025n

.meas tran vdout1_96ck820 FIND v(dout1_96) AT=415.025n

.meas tran vdout1_97ck820 FIND v(dout1_97) AT=415.025n

.meas tran vdout1_98ck820 FIND v(dout1_98) AT=415.025n

.meas tran vdout1_99ck820 FIND v(dout1_99) AT=415.025n

.meas tran vdout1_100ck820 FIND v(dout1_100) AT=415.025n

.meas tran vdout1_101ck820 FIND v(dout1_101) AT=415.025n

.meas tran vdout1_102ck820 FIND v(dout1_102) AT=415.025n

.meas tran vdout1_103ck820 FIND v(dout1_103) AT=415.025n

.meas tran vdout1_104ck820 FIND v(dout1_104) AT=415.025n

.meas tran vdout1_105ck820 FIND v(dout1_105) AT=415.025n

.meas tran vdout1_106ck820 FIND v(dout1_106) AT=415.025n

.meas tran vdout1_107ck820 FIND v(dout1_107) AT=415.025n

.meas tran vdout1_108ck820 FIND v(dout1_108) AT=415.025n

.meas tran vdout1_109ck820 FIND v(dout1_109) AT=415.025n

.meas tran vdout1_110ck820 FIND v(dout1_110) AT=415.025n

.meas tran vdout1_111ck820 FIND v(dout1_111) AT=415.025n

.meas tran vdout1_112ck820 FIND v(dout1_112) AT=415.025n

.meas tran vdout1_113ck820 FIND v(dout1_113) AT=415.025n

.meas tran vdout1_114ck820 FIND v(dout1_114) AT=415.025n

.meas tran vdout1_115ck820 FIND v(dout1_115) AT=415.025n

.meas tran vdout1_116ck820 FIND v(dout1_116) AT=415.025n

.meas tran vdout1_117ck820 FIND v(dout1_117) AT=415.025n

.meas tran vdout1_118ck820 FIND v(dout1_118) AT=415.025n

.meas tran vdout1_119ck820 FIND v(dout1_119) AT=415.025n

.meas tran vdout1_120ck820 FIND v(dout1_120) AT=415.025n

.meas tran vdout1_121ck820 FIND v(dout1_121) AT=415.025n

.meas tran vdout1_122ck820 FIND v(dout1_122) AT=415.025n

.meas tran vdout1_123ck820 FIND v(dout1_123) AT=415.025n

.meas tran vdout1_124ck820 FIND v(dout1_124) AT=415.025n

.meas tran vdout1_125ck820 FIND v(dout1_125) AT=415.025n

.meas tran vdout1_126ck820 FIND v(dout1_126) AT=415.025n

.meas tran vdout1_127ck820 FIND v(dout1_127) AT=415.025n

.meas tran vdout1_0ck830 FIND v(dout1_0) AT=420.025n

.meas tran vdout1_1ck830 FIND v(dout1_1) AT=420.025n

.meas tran vdout1_2ck830 FIND v(dout1_2) AT=420.025n

.meas tran vdout1_3ck830 FIND v(dout1_3) AT=420.025n

.meas tran vdout1_4ck830 FIND v(dout1_4) AT=420.025n

.meas tran vdout1_5ck830 FIND v(dout1_5) AT=420.025n

.meas tran vdout1_6ck830 FIND v(dout1_6) AT=420.025n

.meas tran vdout1_7ck830 FIND v(dout1_7) AT=420.025n

.meas tran vdout1_8ck830 FIND v(dout1_8) AT=420.025n

.meas tran vdout1_9ck830 FIND v(dout1_9) AT=420.025n

.meas tran vdout1_10ck830 FIND v(dout1_10) AT=420.025n

.meas tran vdout1_11ck830 FIND v(dout1_11) AT=420.025n

.meas tran vdout1_12ck830 FIND v(dout1_12) AT=420.025n

.meas tran vdout1_13ck830 FIND v(dout1_13) AT=420.025n

.meas tran vdout1_14ck830 FIND v(dout1_14) AT=420.025n

.meas tran vdout1_15ck830 FIND v(dout1_15) AT=420.025n

.meas tran vdout1_16ck830 FIND v(dout1_16) AT=420.025n

.meas tran vdout1_17ck830 FIND v(dout1_17) AT=420.025n

.meas tran vdout1_18ck830 FIND v(dout1_18) AT=420.025n

.meas tran vdout1_19ck830 FIND v(dout1_19) AT=420.025n

.meas tran vdout1_20ck830 FIND v(dout1_20) AT=420.025n

.meas tran vdout1_21ck830 FIND v(dout1_21) AT=420.025n

.meas tran vdout1_22ck830 FIND v(dout1_22) AT=420.025n

.meas tran vdout1_23ck830 FIND v(dout1_23) AT=420.025n

.meas tran vdout1_24ck830 FIND v(dout1_24) AT=420.025n

.meas tran vdout1_25ck830 FIND v(dout1_25) AT=420.025n

.meas tran vdout1_26ck830 FIND v(dout1_26) AT=420.025n

.meas tran vdout1_27ck830 FIND v(dout1_27) AT=420.025n

.meas tran vdout1_28ck830 FIND v(dout1_28) AT=420.025n

.meas tran vdout1_29ck830 FIND v(dout1_29) AT=420.025n

.meas tran vdout1_30ck830 FIND v(dout1_30) AT=420.025n

.meas tran vdout1_31ck830 FIND v(dout1_31) AT=420.025n

.meas tran vdout1_32ck830 FIND v(dout1_32) AT=420.025n

.meas tran vdout1_33ck830 FIND v(dout1_33) AT=420.025n

.meas tran vdout1_34ck830 FIND v(dout1_34) AT=420.025n

.meas tran vdout1_35ck830 FIND v(dout1_35) AT=420.025n

.meas tran vdout1_36ck830 FIND v(dout1_36) AT=420.025n

.meas tran vdout1_37ck830 FIND v(dout1_37) AT=420.025n

.meas tran vdout1_38ck830 FIND v(dout1_38) AT=420.025n

.meas tran vdout1_39ck830 FIND v(dout1_39) AT=420.025n

.meas tran vdout1_40ck830 FIND v(dout1_40) AT=420.025n

.meas tran vdout1_41ck830 FIND v(dout1_41) AT=420.025n

.meas tran vdout1_42ck830 FIND v(dout1_42) AT=420.025n

.meas tran vdout1_43ck830 FIND v(dout1_43) AT=420.025n

.meas tran vdout1_44ck830 FIND v(dout1_44) AT=420.025n

.meas tran vdout1_45ck830 FIND v(dout1_45) AT=420.025n

.meas tran vdout1_46ck830 FIND v(dout1_46) AT=420.025n

.meas tran vdout1_47ck830 FIND v(dout1_47) AT=420.025n

.meas tran vdout1_48ck830 FIND v(dout1_48) AT=420.025n

.meas tran vdout1_49ck830 FIND v(dout1_49) AT=420.025n

.meas tran vdout1_50ck830 FIND v(dout1_50) AT=420.025n

.meas tran vdout1_51ck830 FIND v(dout1_51) AT=420.025n

.meas tran vdout1_52ck830 FIND v(dout1_52) AT=420.025n

.meas tran vdout1_53ck830 FIND v(dout1_53) AT=420.025n

.meas tran vdout1_54ck830 FIND v(dout1_54) AT=420.025n

.meas tran vdout1_55ck830 FIND v(dout1_55) AT=420.025n

.meas tran vdout1_56ck830 FIND v(dout1_56) AT=420.025n

.meas tran vdout1_57ck830 FIND v(dout1_57) AT=420.025n

.meas tran vdout1_58ck830 FIND v(dout1_58) AT=420.025n

.meas tran vdout1_59ck830 FIND v(dout1_59) AT=420.025n

.meas tran vdout1_60ck830 FIND v(dout1_60) AT=420.025n

.meas tran vdout1_61ck830 FIND v(dout1_61) AT=420.025n

.meas tran vdout1_62ck830 FIND v(dout1_62) AT=420.025n

.meas tran vdout1_63ck830 FIND v(dout1_63) AT=420.025n

.meas tran vdout1_64ck830 FIND v(dout1_64) AT=420.025n

.meas tran vdout1_65ck830 FIND v(dout1_65) AT=420.025n

.meas tran vdout1_66ck830 FIND v(dout1_66) AT=420.025n

.meas tran vdout1_67ck830 FIND v(dout1_67) AT=420.025n

.meas tran vdout1_68ck830 FIND v(dout1_68) AT=420.025n

.meas tran vdout1_69ck830 FIND v(dout1_69) AT=420.025n

.meas tran vdout1_70ck830 FIND v(dout1_70) AT=420.025n

.meas tran vdout1_71ck830 FIND v(dout1_71) AT=420.025n

.meas tran vdout1_72ck830 FIND v(dout1_72) AT=420.025n

.meas tran vdout1_73ck830 FIND v(dout1_73) AT=420.025n

.meas tran vdout1_74ck830 FIND v(dout1_74) AT=420.025n

.meas tran vdout1_75ck830 FIND v(dout1_75) AT=420.025n

.meas tran vdout1_76ck830 FIND v(dout1_76) AT=420.025n

.meas tran vdout1_77ck830 FIND v(dout1_77) AT=420.025n

.meas tran vdout1_78ck830 FIND v(dout1_78) AT=420.025n

.meas tran vdout1_79ck830 FIND v(dout1_79) AT=420.025n

.meas tran vdout1_80ck830 FIND v(dout1_80) AT=420.025n

.meas tran vdout1_81ck830 FIND v(dout1_81) AT=420.025n

.meas tran vdout1_82ck830 FIND v(dout1_82) AT=420.025n

.meas tran vdout1_83ck830 FIND v(dout1_83) AT=420.025n

.meas tran vdout1_84ck830 FIND v(dout1_84) AT=420.025n

.meas tran vdout1_85ck830 FIND v(dout1_85) AT=420.025n

.meas tran vdout1_86ck830 FIND v(dout1_86) AT=420.025n

.meas tran vdout1_87ck830 FIND v(dout1_87) AT=420.025n

.meas tran vdout1_88ck830 FIND v(dout1_88) AT=420.025n

.meas tran vdout1_89ck830 FIND v(dout1_89) AT=420.025n

.meas tran vdout1_90ck830 FIND v(dout1_90) AT=420.025n

.meas tran vdout1_91ck830 FIND v(dout1_91) AT=420.025n

.meas tran vdout1_92ck830 FIND v(dout1_92) AT=420.025n

.meas tran vdout1_93ck830 FIND v(dout1_93) AT=420.025n

.meas tran vdout1_94ck830 FIND v(dout1_94) AT=420.025n

.meas tran vdout1_95ck830 FIND v(dout1_95) AT=420.025n

.meas tran vdout1_96ck830 FIND v(dout1_96) AT=420.025n

.meas tran vdout1_97ck830 FIND v(dout1_97) AT=420.025n

.meas tran vdout1_98ck830 FIND v(dout1_98) AT=420.025n

.meas tran vdout1_99ck830 FIND v(dout1_99) AT=420.025n

.meas tran vdout1_100ck830 FIND v(dout1_100) AT=420.025n

.meas tran vdout1_101ck830 FIND v(dout1_101) AT=420.025n

.meas tran vdout1_102ck830 FIND v(dout1_102) AT=420.025n

.meas tran vdout1_103ck830 FIND v(dout1_103) AT=420.025n

.meas tran vdout1_104ck830 FIND v(dout1_104) AT=420.025n

.meas tran vdout1_105ck830 FIND v(dout1_105) AT=420.025n

.meas tran vdout1_106ck830 FIND v(dout1_106) AT=420.025n

.meas tran vdout1_107ck830 FIND v(dout1_107) AT=420.025n

.meas tran vdout1_108ck830 FIND v(dout1_108) AT=420.025n

.meas tran vdout1_109ck830 FIND v(dout1_109) AT=420.025n

.meas tran vdout1_110ck830 FIND v(dout1_110) AT=420.025n

.meas tran vdout1_111ck830 FIND v(dout1_111) AT=420.025n

.meas tran vdout1_112ck830 FIND v(dout1_112) AT=420.025n

.meas tran vdout1_113ck830 FIND v(dout1_113) AT=420.025n

.meas tran vdout1_114ck830 FIND v(dout1_114) AT=420.025n

.meas tran vdout1_115ck830 FIND v(dout1_115) AT=420.025n

.meas tran vdout1_116ck830 FIND v(dout1_116) AT=420.025n

.meas tran vdout1_117ck830 FIND v(dout1_117) AT=420.025n

.meas tran vdout1_118ck830 FIND v(dout1_118) AT=420.025n

.meas tran vdout1_119ck830 FIND v(dout1_119) AT=420.025n

.meas tran vdout1_120ck830 FIND v(dout1_120) AT=420.025n

.meas tran vdout1_121ck830 FIND v(dout1_121) AT=420.025n

.meas tran vdout1_122ck830 FIND v(dout1_122) AT=420.025n

.meas tran vdout1_123ck830 FIND v(dout1_123) AT=420.025n

.meas tran vdout1_124ck830 FIND v(dout1_124) AT=420.025n

.meas tran vdout1_125ck830 FIND v(dout1_125) AT=420.025n

.meas tran vdout1_126ck830 FIND v(dout1_126) AT=420.025n

.meas tran vdout1_127ck830 FIND v(dout1_127) AT=420.025n

.meas tran vdout1_0ck860 FIND v(dout1_0) AT=435.025n

.meas tran vdout1_1ck860 FIND v(dout1_1) AT=435.025n

.meas tran vdout1_2ck860 FIND v(dout1_2) AT=435.025n

.meas tran vdout1_3ck860 FIND v(dout1_3) AT=435.025n

.meas tran vdout1_4ck860 FIND v(dout1_4) AT=435.025n

.meas tran vdout1_5ck860 FIND v(dout1_5) AT=435.025n

.meas tran vdout1_6ck860 FIND v(dout1_6) AT=435.025n

.meas tran vdout1_7ck860 FIND v(dout1_7) AT=435.025n

.meas tran vdout1_8ck860 FIND v(dout1_8) AT=435.025n

.meas tran vdout1_9ck860 FIND v(dout1_9) AT=435.025n

.meas tran vdout1_10ck860 FIND v(dout1_10) AT=435.025n

.meas tran vdout1_11ck860 FIND v(dout1_11) AT=435.025n

.meas tran vdout1_12ck860 FIND v(dout1_12) AT=435.025n

.meas tran vdout1_13ck860 FIND v(dout1_13) AT=435.025n

.meas tran vdout1_14ck860 FIND v(dout1_14) AT=435.025n

.meas tran vdout1_15ck860 FIND v(dout1_15) AT=435.025n

.meas tran vdout1_16ck860 FIND v(dout1_16) AT=435.025n

.meas tran vdout1_17ck860 FIND v(dout1_17) AT=435.025n

.meas tran vdout1_18ck860 FIND v(dout1_18) AT=435.025n

.meas tran vdout1_19ck860 FIND v(dout1_19) AT=435.025n

.meas tran vdout1_20ck860 FIND v(dout1_20) AT=435.025n

.meas tran vdout1_21ck860 FIND v(dout1_21) AT=435.025n

.meas tran vdout1_22ck860 FIND v(dout1_22) AT=435.025n

.meas tran vdout1_23ck860 FIND v(dout1_23) AT=435.025n

.meas tran vdout1_24ck860 FIND v(dout1_24) AT=435.025n

.meas tran vdout1_25ck860 FIND v(dout1_25) AT=435.025n

.meas tran vdout1_26ck860 FIND v(dout1_26) AT=435.025n

.meas tran vdout1_27ck860 FIND v(dout1_27) AT=435.025n

.meas tran vdout1_28ck860 FIND v(dout1_28) AT=435.025n

.meas tran vdout1_29ck860 FIND v(dout1_29) AT=435.025n

.meas tran vdout1_30ck860 FIND v(dout1_30) AT=435.025n

.meas tran vdout1_31ck860 FIND v(dout1_31) AT=435.025n

.meas tran vdout1_32ck860 FIND v(dout1_32) AT=435.025n

.meas tran vdout1_33ck860 FIND v(dout1_33) AT=435.025n

.meas tran vdout1_34ck860 FIND v(dout1_34) AT=435.025n

.meas tran vdout1_35ck860 FIND v(dout1_35) AT=435.025n

.meas tran vdout1_36ck860 FIND v(dout1_36) AT=435.025n

.meas tran vdout1_37ck860 FIND v(dout1_37) AT=435.025n

.meas tran vdout1_38ck860 FIND v(dout1_38) AT=435.025n

.meas tran vdout1_39ck860 FIND v(dout1_39) AT=435.025n

.meas tran vdout1_40ck860 FIND v(dout1_40) AT=435.025n

.meas tran vdout1_41ck860 FIND v(dout1_41) AT=435.025n

.meas tran vdout1_42ck860 FIND v(dout1_42) AT=435.025n

.meas tran vdout1_43ck860 FIND v(dout1_43) AT=435.025n

.meas tran vdout1_44ck860 FIND v(dout1_44) AT=435.025n

.meas tran vdout1_45ck860 FIND v(dout1_45) AT=435.025n

.meas tran vdout1_46ck860 FIND v(dout1_46) AT=435.025n

.meas tran vdout1_47ck860 FIND v(dout1_47) AT=435.025n

.meas tran vdout1_48ck860 FIND v(dout1_48) AT=435.025n

.meas tran vdout1_49ck860 FIND v(dout1_49) AT=435.025n

.meas tran vdout1_50ck860 FIND v(dout1_50) AT=435.025n

.meas tran vdout1_51ck860 FIND v(dout1_51) AT=435.025n

.meas tran vdout1_52ck860 FIND v(dout1_52) AT=435.025n

.meas tran vdout1_53ck860 FIND v(dout1_53) AT=435.025n

.meas tran vdout1_54ck860 FIND v(dout1_54) AT=435.025n

.meas tran vdout1_55ck860 FIND v(dout1_55) AT=435.025n

.meas tran vdout1_56ck860 FIND v(dout1_56) AT=435.025n

.meas tran vdout1_57ck860 FIND v(dout1_57) AT=435.025n

.meas tran vdout1_58ck860 FIND v(dout1_58) AT=435.025n

.meas tran vdout1_59ck860 FIND v(dout1_59) AT=435.025n

.meas tran vdout1_60ck860 FIND v(dout1_60) AT=435.025n

.meas tran vdout1_61ck860 FIND v(dout1_61) AT=435.025n

.meas tran vdout1_62ck860 FIND v(dout1_62) AT=435.025n

.meas tran vdout1_63ck860 FIND v(dout1_63) AT=435.025n

.meas tran vdout1_64ck860 FIND v(dout1_64) AT=435.025n

.meas tran vdout1_65ck860 FIND v(dout1_65) AT=435.025n

.meas tran vdout1_66ck860 FIND v(dout1_66) AT=435.025n

.meas tran vdout1_67ck860 FIND v(dout1_67) AT=435.025n

.meas tran vdout1_68ck860 FIND v(dout1_68) AT=435.025n

.meas tran vdout1_69ck860 FIND v(dout1_69) AT=435.025n

.meas tran vdout1_70ck860 FIND v(dout1_70) AT=435.025n

.meas tran vdout1_71ck860 FIND v(dout1_71) AT=435.025n

.meas tran vdout1_72ck860 FIND v(dout1_72) AT=435.025n

.meas tran vdout1_73ck860 FIND v(dout1_73) AT=435.025n

.meas tran vdout1_74ck860 FIND v(dout1_74) AT=435.025n

.meas tran vdout1_75ck860 FIND v(dout1_75) AT=435.025n

.meas tran vdout1_76ck860 FIND v(dout1_76) AT=435.025n

.meas tran vdout1_77ck860 FIND v(dout1_77) AT=435.025n

.meas tran vdout1_78ck860 FIND v(dout1_78) AT=435.025n

.meas tran vdout1_79ck860 FIND v(dout1_79) AT=435.025n

.meas tran vdout1_80ck860 FIND v(dout1_80) AT=435.025n

.meas tran vdout1_81ck860 FIND v(dout1_81) AT=435.025n

.meas tran vdout1_82ck860 FIND v(dout1_82) AT=435.025n

.meas tran vdout1_83ck860 FIND v(dout1_83) AT=435.025n

.meas tran vdout1_84ck860 FIND v(dout1_84) AT=435.025n

.meas tran vdout1_85ck860 FIND v(dout1_85) AT=435.025n

.meas tran vdout1_86ck860 FIND v(dout1_86) AT=435.025n

.meas tran vdout1_87ck860 FIND v(dout1_87) AT=435.025n

.meas tran vdout1_88ck860 FIND v(dout1_88) AT=435.025n

.meas tran vdout1_89ck860 FIND v(dout1_89) AT=435.025n

.meas tran vdout1_90ck860 FIND v(dout1_90) AT=435.025n

.meas tran vdout1_91ck860 FIND v(dout1_91) AT=435.025n

.meas tran vdout1_92ck860 FIND v(dout1_92) AT=435.025n

.meas tran vdout1_93ck860 FIND v(dout1_93) AT=435.025n

.meas tran vdout1_94ck860 FIND v(dout1_94) AT=435.025n

.meas tran vdout1_95ck860 FIND v(dout1_95) AT=435.025n

.meas tran vdout1_96ck860 FIND v(dout1_96) AT=435.025n

.meas tran vdout1_97ck860 FIND v(dout1_97) AT=435.025n

.meas tran vdout1_98ck860 FIND v(dout1_98) AT=435.025n

.meas tran vdout1_99ck860 FIND v(dout1_99) AT=435.025n

.meas tran vdout1_100ck860 FIND v(dout1_100) AT=435.025n

.meas tran vdout1_101ck860 FIND v(dout1_101) AT=435.025n

.meas tran vdout1_102ck860 FIND v(dout1_102) AT=435.025n

.meas tran vdout1_103ck860 FIND v(dout1_103) AT=435.025n

.meas tran vdout1_104ck860 FIND v(dout1_104) AT=435.025n

.meas tran vdout1_105ck860 FIND v(dout1_105) AT=435.025n

.meas tran vdout1_106ck860 FIND v(dout1_106) AT=435.025n

.meas tran vdout1_107ck860 FIND v(dout1_107) AT=435.025n

.meas tran vdout1_108ck860 FIND v(dout1_108) AT=435.025n

.meas tran vdout1_109ck860 FIND v(dout1_109) AT=435.025n

.meas tran vdout1_110ck860 FIND v(dout1_110) AT=435.025n

.meas tran vdout1_111ck860 FIND v(dout1_111) AT=435.025n

.meas tran vdout1_112ck860 FIND v(dout1_112) AT=435.025n

.meas tran vdout1_113ck860 FIND v(dout1_113) AT=435.025n

.meas tran vdout1_114ck860 FIND v(dout1_114) AT=435.025n

.meas tran vdout1_115ck860 FIND v(dout1_115) AT=435.025n

.meas tran vdout1_116ck860 FIND v(dout1_116) AT=435.025n

.meas tran vdout1_117ck860 FIND v(dout1_117) AT=435.025n

.meas tran vdout1_118ck860 FIND v(dout1_118) AT=435.025n

.meas tran vdout1_119ck860 FIND v(dout1_119) AT=435.025n

.meas tran vdout1_120ck860 FIND v(dout1_120) AT=435.025n

.meas tran vdout1_121ck860 FIND v(dout1_121) AT=435.025n

.meas tran vdout1_122ck860 FIND v(dout1_122) AT=435.025n

.meas tran vdout1_123ck860 FIND v(dout1_123) AT=435.025n

.meas tran vdout1_124ck860 FIND v(dout1_124) AT=435.025n

.meas tran vdout1_125ck860 FIND v(dout1_125) AT=435.025n

.meas tran vdout1_126ck860 FIND v(dout1_126) AT=435.025n

.meas tran vdout1_127ck860 FIND v(dout1_127) AT=435.025n

.meas tran vdout1_0ck880 FIND v(dout1_0) AT=445.025n

.meas tran vdout1_1ck880 FIND v(dout1_1) AT=445.025n

.meas tran vdout1_2ck880 FIND v(dout1_2) AT=445.025n

.meas tran vdout1_3ck880 FIND v(dout1_3) AT=445.025n

.meas tran vdout1_4ck880 FIND v(dout1_4) AT=445.025n

.meas tran vdout1_5ck880 FIND v(dout1_5) AT=445.025n

.meas tran vdout1_6ck880 FIND v(dout1_6) AT=445.025n

.meas tran vdout1_7ck880 FIND v(dout1_7) AT=445.025n

.meas tran vdout1_8ck880 FIND v(dout1_8) AT=445.025n

.meas tran vdout1_9ck880 FIND v(dout1_9) AT=445.025n

.meas tran vdout1_10ck880 FIND v(dout1_10) AT=445.025n

.meas tran vdout1_11ck880 FIND v(dout1_11) AT=445.025n

.meas tran vdout1_12ck880 FIND v(dout1_12) AT=445.025n

.meas tran vdout1_13ck880 FIND v(dout1_13) AT=445.025n

.meas tran vdout1_14ck880 FIND v(dout1_14) AT=445.025n

.meas tran vdout1_15ck880 FIND v(dout1_15) AT=445.025n

.meas tran vdout1_16ck880 FIND v(dout1_16) AT=445.025n

.meas tran vdout1_17ck880 FIND v(dout1_17) AT=445.025n

.meas tran vdout1_18ck880 FIND v(dout1_18) AT=445.025n

.meas tran vdout1_19ck880 FIND v(dout1_19) AT=445.025n

.meas tran vdout1_20ck880 FIND v(dout1_20) AT=445.025n

.meas tran vdout1_21ck880 FIND v(dout1_21) AT=445.025n

.meas tran vdout1_22ck880 FIND v(dout1_22) AT=445.025n

.meas tran vdout1_23ck880 FIND v(dout1_23) AT=445.025n

.meas tran vdout1_24ck880 FIND v(dout1_24) AT=445.025n

.meas tran vdout1_25ck880 FIND v(dout1_25) AT=445.025n

.meas tran vdout1_26ck880 FIND v(dout1_26) AT=445.025n

.meas tran vdout1_27ck880 FIND v(dout1_27) AT=445.025n

.meas tran vdout1_28ck880 FIND v(dout1_28) AT=445.025n

.meas tran vdout1_29ck880 FIND v(dout1_29) AT=445.025n

.meas tran vdout1_30ck880 FIND v(dout1_30) AT=445.025n

.meas tran vdout1_31ck880 FIND v(dout1_31) AT=445.025n

.meas tran vdout1_32ck880 FIND v(dout1_32) AT=445.025n

.meas tran vdout1_33ck880 FIND v(dout1_33) AT=445.025n

.meas tran vdout1_34ck880 FIND v(dout1_34) AT=445.025n

.meas tran vdout1_35ck880 FIND v(dout1_35) AT=445.025n

.meas tran vdout1_36ck880 FIND v(dout1_36) AT=445.025n

.meas tran vdout1_37ck880 FIND v(dout1_37) AT=445.025n

.meas tran vdout1_38ck880 FIND v(dout1_38) AT=445.025n

.meas tran vdout1_39ck880 FIND v(dout1_39) AT=445.025n

.meas tran vdout1_40ck880 FIND v(dout1_40) AT=445.025n

.meas tran vdout1_41ck880 FIND v(dout1_41) AT=445.025n

.meas tran vdout1_42ck880 FIND v(dout1_42) AT=445.025n

.meas tran vdout1_43ck880 FIND v(dout1_43) AT=445.025n

.meas tran vdout1_44ck880 FIND v(dout1_44) AT=445.025n

.meas tran vdout1_45ck880 FIND v(dout1_45) AT=445.025n

.meas tran vdout1_46ck880 FIND v(dout1_46) AT=445.025n

.meas tran vdout1_47ck880 FIND v(dout1_47) AT=445.025n

.meas tran vdout1_48ck880 FIND v(dout1_48) AT=445.025n

.meas tran vdout1_49ck880 FIND v(dout1_49) AT=445.025n

.meas tran vdout1_50ck880 FIND v(dout1_50) AT=445.025n

.meas tran vdout1_51ck880 FIND v(dout1_51) AT=445.025n

.meas tran vdout1_52ck880 FIND v(dout1_52) AT=445.025n

.meas tran vdout1_53ck880 FIND v(dout1_53) AT=445.025n

.meas tran vdout1_54ck880 FIND v(dout1_54) AT=445.025n

.meas tran vdout1_55ck880 FIND v(dout1_55) AT=445.025n

.meas tran vdout1_56ck880 FIND v(dout1_56) AT=445.025n

.meas tran vdout1_57ck880 FIND v(dout1_57) AT=445.025n

.meas tran vdout1_58ck880 FIND v(dout1_58) AT=445.025n

.meas tran vdout1_59ck880 FIND v(dout1_59) AT=445.025n

.meas tran vdout1_60ck880 FIND v(dout1_60) AT=445.025n

.meas tran vdout1_61ck880 FIND v(dout1_61) AT=445.025n

.meas tran vdout1_62ck880 FIND v(dout1_62) AT=445.025n

.meas tran vdout1_63ck880 FIND v(dout1_63) AT=445.025n

.meas tran vdout1_64ck880 FIND v(dout1_64) AT=445.025n

.meas tran vdout1_65ck880 FIND v(dout1_65) AT=445.025n

.meas tran vdout1_66ck880 FIND v(dout1_66) AT=445.025n

.meas tran vdout1_67ck880 FIND v(dout1_67) AT=445.025n

.meas tran vdout1_68ck880 FIND v(dout1_68) AT=445.025n

.meas tran vdout1_69ck880 FIND v(dout1_69) AT=445.025n

.meas tran vdout1_70ck880 FIND v(dout1_70) AT=445.025n

.meas tran vdout1_71ck880 FIND v(dout1_71) AT=445.025n

.meas tran vdout1_72ck880 FIND v(dout1_72) AT=445.025n

.meas tran vdout1_73ck880 FIND v(dout1_73) AT=445.025n

.meas tran vdout1_74ck880 FIND v(dout1_74) AT=445.025n

.meas tran vdout1_75ck880 FIND v(dout1_75) AT=445.025n

.meas tran vdout1_76ck880 FIND v(dout1_76) AT=445.025n

.meas tran vdout1_77ck880 FIND v(dout1_77) AT=445.025n

.meas tran vdout1_78ck880 FIND v(dout1_78) AT=445.025n

.meas tran vdout1_79ck880 FIND v(dout1_79) AT=445.025n

.meas tran vdout1_80ck880 FIND v(dout1_80) AT=445.025n

.meas tran vdout1_81ck880 FIND v(dout1_81) AT=445.025n

.meas tran vdout1_82ck880 FIND v(dout1_82) AT=445.025n

.meas tran vdout1_83ck880 FIND v(dout1_83) AT=445.025n

.meas tran vdout1_84ck880 FIND v(dout1_84) AT=445.025n

.meas tran vdout1_85ck880 FIND v(dout1_85) AT=445.025n

.meas tran vdout1_86ck880 FIND v(dout1_86) AT=445.025n

.meas tran vdout1_87ck880 FIND v(dout1_87) AT=445.025n

.meas tran vdout1_88ck880 FIND v(dout1_88) AT=445.025n

.meas tran vdout1_89ck880 FIND v(dout1_89) AT=445.025n

.meas tran vdout1_90ck880 FIND v(dout1_90) AT=445.025n

.meas tran vdout1_91ck880 FIND v(dout1_91) AT=445.025n

.meas tran vdout1_92ck880 FIND v(dout1_92) AT=445.025n

.meas tran vdout1_93ck880 FIND v(dout1_93) AT=445.025n

.meas tran vdout1_94ck880 FIND v(dout1_94) AT=445.025n

.meas tran vdout1_95ck880 FIND v(dout1_95) AT=445.025n

.meas tran vdout1_96ck880 FIND v(dout1_96) AT=445.025n

.meas tran vdout1_97ck880 FIND v(dout1_97) AT=445.025n

.meas tran vdout1_98ck880 FIND v(dout1_98) AT=445.025n

.meas tran vdout1_99ck880 FIND v(dout1_99) AT=445.025n

.meas tran vdout1_100ck880 FIND v(dout1_100) AT=445.025n

.meas tran vdout1_101ck880 FIND v(dout1_101) AT=445.025n

.meas tran vdout1_102ck880 FIND v(dout1_102) AT=445.025n

.meas tran vdout1_103ck880 FIND v(dout1_103) AT=445.025n

.meas tran vdout1_104ck880 FIND v(dout1_104) AT=445.025n

.meas tran vdout1_105ck880 FIND v(dout1_105) AT=445.025n

.meas tran vdout1_106ck880 FIND v(dout1_106) AT=445.025n

.meas tran vdout1_107ck880 FIND v(dout1_107) AT=445.025n

.meas tran vdout1_108ck880 FIND v(dout1_108) AT=445.025n

.meas tran vdout1_109ck880 FIND v(dout1_109) AT=445.025n

.meas tran vdout1_110ck880 FIND v(dout1_110) AT=445.025n

.meas tran vdout1_111ck880 FIND v(dout1_111) AT=445.025n

.meas tran vdout1_112ck880 FIND v(dout1_112) AT=445.025n

.meas tran vdout1_113ck880 FIND v(dout1_113) AT=445.025n

.meas tran vdout1_114ck880 FIND v(dout1_114) AT=445.025n

.meas tran vdout1_115ck880 FIND v(dout1_115) AT=445.025n

.meas tran vdout1_116ck880 FIND v(dout1_116) AT=445.025n

.meas tran vdout1_117ck880 FIND v(dout1_117) AT=445.025n

.meas tran vdout1_118ck880 FIND v(dout1_118) AT=445.025n

.meas tran vdout1_119ck880 FIND v(dout1_119) AT=445.025n

.meas tran vdout1_120ck880 FIND v(dout1_120) AT=445.025n

.meas tran vdout1_121ck880 FIND v(dout1_121) AT=445.025n

.meas tran vdout1_122ck880 FIND v(dout1_122) AT=445.025n

.meas tran vdout1_123ck880 FIND v(dout1_123) AT=445.025n

.meas tran vdout1_124ck880 FIND v(dout1_124) AT=445.025n

.meas tran vdout1_125ck880 FIND v(dout1_125) AT=445.025n

.meas tran vdout1_126ck880 FIND v(dout1_126) AT=445.025n

.meas tran vdout1_127ck880 FIND v(dout1_127) AT=445.025n

.meas tran vdout1_0ck890 FIND v(dout1_0) AT=450.025n

.meas tran vdout1_1ck890 FIND v(dout1_1) AT=450.025n

.meas tran vdout1_2ck890 FIND v(dout1_2) AT=450.025n

.meas tran vdout1_3ck890 FIND v(dout1_3) AT=450.025n

.meas tran vdout1_4ck890 FIND v(dout1_4) AT=450.025n

.meas tran vdout1_5ck890 FIND v(dout1_5) AT=450.025n

.meas tran vdout1_6ck890 FIND v(dout1_6) AT=450.025n

.meas tran vdout1_7ck890 FIND v(dout1_7) AT=450.025n

.meas tran vdout1_8ck890 FIND v(dout1_8) AT=450.025n

.meas tran vdout1_9ck890 FIND v(dout1_9) AT=450.025n

.meas tran vdout1_10ck890 FIND v(dout1_10) AT=450.025n

.meas tran vdout1_11ck890 FIND v(dout1_11) AT=450.025n

.meas tran vdout1_12ck890 FIND v(dout1_12) AT=450.025n

.meas tran vdout1_13ck890 FIND v(dout1_13) AT=450.025n

.meas tran vdout1_14ck890 FIND v(dout1_14) AT=450.025n

.meas tran vdout1_15ck890 FIND v(dout1_15) AT=450.025n

.meas tran vdout1_16ck890 FIND v(dout1_16) AT=450.025n

.meas tran vdout1_17ck890 FIND v(dout1_17) AT=450.025n

.meas tran vdout1_18ck890 FIND v(dout1_18) AT=450.025n

.meas tran vdout1_19ck890 FIND v(dout1_19) AT=450.025n

.meas tran vdout1_20ck890 FIND v(dout1_20) AT=450.025n

.meas tran vdout1_21ck890 FIND v(dout1_21) AT=450.025n

.meas tran vdout1_22ck890 FIND v(dout1_22) AT=450.025n

.meas tran vdout1_23ck890 FIND v(dout1_23) AT=450.025n

.meas tran vdout1_24ck890 FIND v(dout1_24) AT=450.025n

.meas tran vdout1_25ck890 FIND v(dout1_25) AT=450.025n

.meas tran vdout1_26ck890 FIND v(dout1_26) AT=450.025n

.meas tran vdout1_27ck890 FIND v(dout1_27) AT=450.025n

.meas tran vdout1_28ck890 FIND v(dout1_28) AT=450.025n

.meas tran vdout1_29ck890 FIND v(dout1_29) AT=450.025n

.meas tran vdout1_30ck890 FIND v(dout1_30) AT=450.025n

.meas tran vdout1_31ck890 FIND v(dout1_31) AT=450.025n

.meas tran vdout1_32ck890 FIND v(dout1_32) AT=450.025n

.meas tran vdout1_33ck890 FIND v(dout1_33) AT=450.025n

.meas tran vdout1_34ck890 FIND v(dout1_34) AT=450.025n

.meas tran vdout1_35ck890 FIND v(dout1_35) AT=450.025n

.meas tran vdout1_36ck890 FIND v(dout1_36) AT=450.025n

.meas tran vdout1_37ck890 FIND v(dout1_37) AT=450.025n

.meas tran vdout1_38ck890 FIND v(dout1_38) AT=450.025n

.meas tran vdout1_39ck890 FIND v(dout1_39) AT=450.025n

.meas tran vdout1_40ck890 FIND v(dout1_40) AT=450.025n

.meas tran vdout1_41ck890 FIND v(dout1_41) AT=450.025n

.meas tran vdout1_42ck890 FIND v(dout1_42) AT=450.025n

.meas tran vdout1_43ck890 FIND v(dout1_43) AT=450.025n

.meas tran vdout1_44ck890 FIND v(dout1_44) AT=450.025n

.meas tran vdout1_45ck890 FIND v(dout1_45) AT=450.025n

.meas tran vdout1_46ck890 FIND v(dout1_46) AT=450.025n

.meas tran vdout1_47ck890 FIND v(dout1_47) AT=450.025n

.meas tran vdout1_48ck890 FIND v(dout1_48) AT=450.025n

.meas tran vdout1_49ck890 FIND v(dout1_49) AT=450.025n

.meas tran vdout1_50ck890 FIND v(dout1_50) AT=450.025n

.meas tran vdout1_51ck890 FIND v(dout1_51) AT=450.025n

.meas tran vdout1_52ck890 FIND v(dout1_52) AT=450.025n

.meas tran vdout1_53ck890 FIND v(dout1_53) AT=450.025n

.meas tran vdout1_54ck890 FIND v(dout1_54) AT=450.025n

.meas tran vdout1_55ck890 FIND v(dout1_55) AT=450.025n

.meas tran vdout1_56ck890 FIND v(dout1_56) AT=450.025n

.meas tran vdout1_57ck890 FIND v(dout1_57) AT=450.025n

.meas tran vdout1_58ck890 FIND v(dout1_58) AT=450.025n

.meas tran vdout1_59ck890 FIND v(dout1_59) AT=450.025n

.meas tran vdout1_60ck890 FIND v(dout1_60) AT=450.025n

.meas tran vdout1_61ck890 FIND v(dout1_61) AT=450.025n

.meas tran vdout1_62ck890 FIND v(dout1_62) AT=450.025n

.meas tran vdout1_63ck890 FIND v(dout1_63) AT=450.025n

.meas tran vdout1_64ck890 FIND v(dout1_64) AT=450.025n

.meas tran vdout1_65ck890 FIND v(dout1_65) AT=450.025n

.meas tran vdout1_66ck890 FIND v(dout1_66) AT=450.025n

.meas tran vdout1_67ck890 FIND v(dout1_67) AT=450.025n

.meas tran vdout1_68ck890 FIND v(dout1_68) AT=450.025n

.meas tran vdout1_69ck890 FIND v(dout1_69) AT=450.025n

.meas tran vdout1_70ck890 FIND v(dout1_70) AT=450.025n

.meas tran vdout1_71ck890 FIND v(dout1_71) AT=450.025n

.meas tran vdout1_72ck890 FIND v(dout1_72) AT=450.025n

.meas tran vdout1_73ck890 FIND v(dout1_73) AT=450.025n

.meas tran vdout1_74ck890 FIND v(dout1_74) AT=450.025n

.meas tran vdout1_75ck890 FIND v(dout1_75) AT=450.025n

.meas tran vdout1_76ck890 FIND v(dout1_76) AT=450.025n

.meas tran vdout1_77ck890 FIND v(dout1_77) AT=450.025n

.meas tran vdout1_78ck890 FIND v(dout1_78) AT=450.025n

.meas tran vdout1_79ck890 FIND v(dout1_79) AT=450.025n

.meas tran vdout1_80ck890 FIND v(dout1_80) AT=450.025n

.meas tran vdout1_81ck890 FIND v(dout1_81) AT=450.025n

.meas tran vdout1_82ck890 FIND v(dout1_82) AT=450.025n

.meas tran vdout1_83ck890 FIND v(dout1_83) AT=450.025n

.meas tran vdout1_84ck890 FIND v(dout1_84) AT=450.025n

.meas tran vdout1_85ck890 FIND v(dout1_85) AT=450.025n

.meas tran vdout1_86ck890 FIND v(dout1_86) AT=450.025n

.meas tran vdout1_87ck890 FIND v(dout1_87) AT=450.025n

.meas tran vdout1_88ck890 FIND v(dout1_88) AT=450.025n

.meas tran vdout1_89ck890 FIND v(dout1_89) AT=450.025n

.meas tran vdout1_90ck890 FIND v(dout1_90) AT=450.025n

.meas tran vdout1_91ck890 FIND v(dout1_91) AT=450.025n

.meas tran vdout1_92ck890 FIND v(dout1_92) AT=450.025n

.meas tran vdout1_93ck890 FIND v(dout1_93) AT=450.025n

.meas tran vdout1_94ck890 FIND v(dout1_94) AT=450.025n

.meas tran vdout1_95ck890 FIND v(dout1_95) AT=450.025n

.meas tran vdout1_96ck890 FIND v(dout1_96) AT=450.025n

.meas tran vdout1_97ck890 FIND v(dout1_97) AT=450.025n

.meas tran vdout1_98ck890 FIND v(dout1_98) AT=450.025n

.meas tran vdout1_99ck890 FIND v(dout1_99) AT=450.025n

.meas tran vdout1_100ck890 FIND v(dout1_100) AT=450.025n

.meas tran vdout1_101ck890 FIND v(dout1_101) AT=450.025n

.meas tran vdout1_102ck890 FIND v(dout1_102) AT=450.025n

.meas tran vdout1_103ck890 FIND v(dout1_103) AT=450.025n

.meas tran vdout1_104ck890 FIND v(dout1_104) AT=450.025n

.meas tran vdout1_105ck890 FIND v(dout1_105) AT=450.025n

.meas tran vdout1_106ck890 FIND v(dout1_106) AT=450.025n

.meas tran vdout1_107ck890 FIND v(dout1_107) AT=450.025n

.meas tran vdout1_108ck890 FIND v(dout1_108) AT=450.025n

.meas tran vdout1_109ck890 FIND v(dout1_109) AT=450.025n

.meas tran vdout1_110ck890 FIND v(dout1_110) AT=450.025n

.meas tran vdout1_111ck890 FIND v(dout1_111) AT=450.025n

.meas tran vdout1_112ck890 FIND v(dout1_112) AT=450.025n

.meas tran vdout1_113ck890 FIND v(dout1_113) AT=450.025n

.meas tran vdout1_114ck890 FIND v(dout1_114) AT=450.025n

.meas tran vdout1_115ck890 FIND v(dout1_115) AT=450.025n

.meas tran vdout1_116ck890 FIND v(dout1_116) AT=450.025n

.meas tran vdout1_117ck890 FIND v(dout1_117) AT=450.025n

.meas tran vdout1_118ck890 FIND v(dout1_118) AT=450.025n

.meas tran vdout1_119ck890 FIND v(dout1_119) AT=450.025n

.meas tran vdout1_120ck890 FIND v(dout1_120) AT=450.025n

.meas tran vdout1_121ck890 FIND v(dout1_121) AT=450.025n

.meas tran vdout1_122ck890 FIND v(dout1_122) AT=450.025n

.meas tran vdout1_123ck890 FIND v(dout1_123) AT=450.025n

.meas tran vdout1_124ck890 FIND v(dout1_124) AT=450.025n

.meas tran vdout1_125ck890 FIND v(dout1_125) AT=450.025n

.meas tran vdout1_126ck890 FIND v(dout1_126) AT=450.025n

.meas tran vdout1_127ck890 FIND v(dout1_127) AT=450.025n

.meas tran vdout1_0ck930 FIND v(dout1_0) AT=470.025n

.meas tran vdout1_1ck930 FIND v(dout1_1) AT=470.025n

.meas tran vdout1_2ck930 FIND v(dout1_2) AT=470.025n

.meas tran vdout1_3ck930 FIND v(dout1_3) AT=470.025n

.meas tran vdout1_4ck930 FIND v(dout1_4) AT=470.025n

.meas tran vdout1_5ck930 FIND v(dout1_5) AT=470.025n

.meas tran vdout1_6ck930 FIND v(dout1_6) AT=470.025n

.meas tran vdout1_7ck930 FIND v(dout1_7) AT=470.025n

.meas tran vdout1_8ck930 FIND v(dout1_8) AT=470.025n

.meas tran vdout1_9ck930 FIND v(dout1_9) AT=470.025n

.meas tran vdout1_10ck930 FIND v(dout1_10) AT=470.025n

.meas tran vdout1_11ck930 FIND v(dout1_11) AT=470.025n

.meas tran vdout1_12ck930 FIND v(dout1_12) AT=470.025n

.meas tran vdout1_13ck930 FIND v(dout1_13) AT=470.025n

.meas tran vdout1_14ck930 FIND v(dout1_14) AT=470.025n

.meas tran vdout1_15ck930 FIND v(dout1_15) AT=470.025n

.meas tran vdout1_16ck930 FIND v(dout1_16) AT=470.025n

.meas tran vdout1_17ck930 FIND v(dout1_17) AT=470.025n

.meas tran vdout1_18ck930 FIND v(dout1_18) AT=470.025n

.meas tran vdout1_19ck930 FIND v(dout1_19) AT=470.025n

.meas tran vdout1_20ck930 FIND v(dout1_20) AT=470.025n

.meas tran vdout1_21ck930 FIND v(dout1_21) AT=470.025n

.meas tran vdout1_22ck930 FIND v(dout1_22) AT=470.025n

.meas tran vdout1_23ck930 FIND v(dout1_23) AT=470.025n

.meas tran vdout1_24ck930 FIND v(dout1_24) AT=470.025n

.meas tran vdout1_25ck930 FIND v(dout1_25) AT=470.025n

.meas tran vdout1_26ck930 FIND v(dout1_26) AT=470.025n

.meas tran vdout1_27ck930 FIND v(dout1_27) AT=470.025n

.meas tran vdout1_28ck930 FIND v(dout1_28) AT=470.025n

.meas tran vdout1_29ck930 FIND v(dout1_29) AT=470.025n

.meas tran vdout1_30ck930 FIND v(dout1_30) AT=470.025n

.meas tran vdout1_31ck930 FIND v(dout1_31) AT=470.025n

.meas tran vdout1_32ck930 FIND v(dout1_32) AT=470.025n

.meas tran vdout1_33ck930 FIND v(dout1_33) AT=470.025n

.meas tran vdout1_34ck930 FIND v(dout1_34) AT=470.025n

.meas tran vdout1_35ck930 FIND v(dout1_35) AT=470.025n

.meas tran vdout1_36ck930 FIND v(dout1_36) AT=470.025n

.meas tran vdout1_37ck930 FIND v(dout1_37) AT=470.025n

.meas tran vdout1_38ck930 FIND v(dout1_38) AT=470.025n

.meas tran vdout1_39ck930 FIND v(dout1_39) AT=470.025n

.meas tran vdout1_40ck930 FIND v(dout1_40) AT=470.025n

.meas tran vdout1_41ck930 FIND v(dout1_41) AT=470.025n

.meas tran vdout1_42ck930 FIND v(dout1_42) AT=470.025n

.meas tran vdout1_43ck930 FIND v(dout1_43) AT=470.025n

.meas tran vdout1_44ck930 FIND v(dout1_44) AT=470.025n

.meas tran vdout1_45ck930 FIND v(dout1_45) AT=470.025n

.meas tran vdout1_46ck930 FIND v(dout1_46) AT=470.025n

.meas tran vdout1_47ck930 FIND v(dout1_47) AT=470.025n

.meas tran vdout1_48ck930 FIND v(dout1_48) AT=470.025n

.meas tran vdout1_49ck930 FIND v(dout1_49) AT=470.025n

.meas tran vdout1_50ck930 FIND v(dout1_50) AT=470.025n

.meas tran vdout1_51ck930 FIND v(dout1_51) AT=470.025n

.meas tran vdout1_52ck930 FIND v(dout1_52) AT=470.025n

.meas tran vdout1_53ck930 FIND v(dout1_53) AT=470.025n

.meas tran vdout1_54ck930 FIND v(dout1_54) AT=470.025n

.meas tran vdout1_55ck930 FIND v(dout1_55) AT=470.025n

.meas tran vdout1_56ck930 FIND v(dout1_56) AT=470.025n

.meas tran vdout1_57ck930 FIND v(dout1_57) AT=470.025n

.meas tran vdout1_58ck930 FIND v(dout1_58) AT=470.025n

.meas tran vdout1_59ck930 FIND v(dout1_59) AT=470.025n

.meas tran vdout1_60ck930 FIND v(dout1_60) AT=470.025n

.meas tran vdout1_61ck930 FIND v(dout1_61) AT=470.025n

.meas tran vdout1_62ck930 FIND v(dout1_62) AT=470.025n

.meas tran vdout1_63ck930 FIND v(dout1_63) AT=470.025n

.meas tran vdout1_64ck930 FIND v(dout1_64) AT=470.025n

.meas tran vdout1_65ck930 FIND v(dout1_65) AT=470.025n

.meas tran vdout1_66ck930 FIND v(dout1_66) AT=470.025n

.meas tran vdout1_67ck930 FIND v(dout1_67) AT=470.025n

.meas tran vdout1_68ck930 FIND v(dout1_68) AT=470.025n

.meas tran vdout1_69ck930 FIND v(dout1_69) AT=470.025n

.meas tran vdout1_70ck930 FIND v(dout1_70) AT=470.025n

.meas tran vdout1_71ck930 FIND v(dout1_71) AT=470.025n

.meas tran vdout1_72ck930 FIND v(dout1_72) AT=470.025n

.meas tran vdout1_73ck930 FIND v(dout1_73) AT=470.025n

.meas tran vdout1_74ck930 FIND v(dout1_74) AT=470.025n

.meas tran vdout1_75ck930 FIND v(dout1_75) AT=470.025n

.meas tran vdout1_76ck930 FIND v(dout1_76) AT=470.025n

.meas tran vdout1_77ck930 FIND v(dout1_77) AT=470.025n

.meas tran vdout1_78ck930 FIND v(dout1_78) AT=470.025n

.meas tran vdout1_79ck930 FIND v(dout1_79) AT=470.025n

.meas tran vdout1_80ck930 FIND v(dout1_80) AT=470.025n

.meas tran vdout1_81ck930 FIND v(dout1_81) AT=470.025n

.meas tran vdout1_82ck930 FIND v(dout1_82) AT=470.025n

.meas tran vdout1_83ck930 FIND v(dout1_83) AT=470.025n

.meas tran vdout1_84ck930 FIND v(dout1_84) AT=470.025n

.meas tran vdout1_85ck930 FIND v(dout1_85) AT=470.025n

.meas tran vdout1_86ck930 FIND v(dout1_86) AT=470.025n

.meas tran vdout1_87ck930 FIND v(dout1_87) AT=470.025n

.meas tran vdout1_88ck930 FIND v(dout1_88) AT=470.025n

.meas tran vdout1_89ck930 FIND v(dout1_89) AT=470.025n

.meas tran vdout1_90ck930 FIND v(dout1_90) AT=470.025n

.meas tran vdout1_91ck930 FIND v(dout1_91) AT=470.025n

.meas tran vdout1_92ck930 FIND v(dout1_92) AT=470.025n

.meas tran vdout1_93ck930 FIND v(dout1_93) AT=470.025n

.meas tran vdout1_94ck930 FIND v(dout1_94) AT=470.025n

.meas tran vdout1_95ck930 FIND v(dout1_95) AT=470.025n

.meas tran vdout1_96ck930 FIND v(dout1_96) AT=470.025n

.meas tran vdout1_97ck930 FIND v(dout1_97) AT=470.025n

.meas tran vdout1_98ck930 FIND v(dout1_98) AT=470.025n

.meas tran vdout1_99ck930 FIND v(dout1_99) AT=470.025n

.meas tran vdout1_100ck930 FIND v(dout1_100) AT=470.025n

.meas tran vdout1_101ck930 FIND v(dout1_101) AT=470.025n

.meas tran vdout1_102ck930 FIND v(dout1_102) AT=470.025n

.meas tran vdout1_103ck930 FIND v(dout1_103) AT=470.025n

.meas tran vdout1_104ck930 FIND v(dout1_104) AT=470.025n

.meas tran vdout1_105ck930 FIND v(dout1_105) AT=470.025n

.meas tran vdout1_106ck930 FIND v(dout1_106) AT=470.025n

.meas tran vdout1_107ck930 FIND v(dout1_107) AT=470.025n

.meas tran vdout1_108ck930 FIND v(dout1_108) AT=470.025n

.meas tran vdout1_109ck930 FIND v(dout1_109) AT=470.025n

.meas tran vdout1_110ck930 FIND v(dout1_110) AT=470.025n

.meas tran vdout1_111ck930 FIND v(dout1_111) AT=470.025n

.meas tran vdout1_112ck930 FIND v(dout1_112) AT=470.025n

.meas tran vdout1_113ck930 FIND v(dout1_113) AT=470.025n

.meas tran vdout1_114ck930 FIND v(dout1_114) AT=470.025n

.meas tran vdout1_115ck930 FIND v(dout1_115) AT=470.025n

.meas tran vdout1_116ck930 FIND v(dout1_116) AT=470.025n

.meas tran vdout1_117ck930 FIND v(dout1_117) AT=470.025n

.meas tran vdout1_118ck930 FIND v(dout1_118) AT=470.025n

.meas tran vdout1_119ck930 FIND v(dout1_119) AT=470.025n

.meas tran vdout1_120ck930 FIND v(dout1_120) AT=470.025n

.meas tran vdout1_121ck930 FIND v(dout1_121) AT=470.025n

.meas tran vdout1_122ck930 FIND v(dout1_122) AT=470.025n

.meas tran vdout1_123ck930 FIND v(dout1_123) AT=470.025n

.meas tran vdout1_124ck930 FIND v(dout1_124) AT=470.025n

.meas tran vdout1_125ck930 FIND v(dout1_125) AT=470.025n

.meas tran vdout1_126ck930 FIND v(dout1_126) AT=470.025n

.meas tran vdout1_127ck930 FIND v(dout1_127) AT=470.025n

.meas tran vdout1_0ck940 FIND v(dout1_0) AT=475.025n

.meas tran vdout1_1ck940 FIND v(dout1_1) AT=475.025n

.meas tran vdout1_2ck940 FIND v(dout1_2) AT=475.025n

.meas tran vdout1_3ck940 FIND v(dout1_3) AT=475.025n

.meas tran vdout1_4ck940 FIND v(dout1_4) AT=475.025n

.meas tran vdout1_5ck940 FIND v(dout1_5) AT=475.025n

.meas tran vdout1_6ck940 FIND v(dout1_6) AT=475.025n

.meas tran vdout1_7ck940 FIND v(dout1_7) AT=475.025n

.meas tran vdout1_8ck940 FIND v(dout1_8) AT=475.025n

.meas tran vdout1_9ck940 FIND v(dout1_9) AT=475.025n

.meas tran vdout1_10ck940 FIND v(dout1_10) AT=475.025n

.meas tran vdout1_11ck940 FIND v(dout1_11) AT=475.025n

.meas tran vdout1_12ck940 FIND v(dout1_12) AT=475.025n

.meas tran vdout1_13ck940 FIND v(dout1_13) AT=475.025n

.meas tran vdout1_14ck940 FIND v(dout1_14) AT=475.025n

.meas tran vdout1_15ck940 FIND v(dout1_15) AT=475.025n

.meas tran vdout1_16ck940 FIND v(dout1_16) AT=475.025n

.meas tran vdout1_17ck940 FIND v(dout1_17) AT=475.025n

.meas tran vdout1_18ck940 FIND v(dout1_18) AT=475.025n

.meas tran vdout1_19ck940 FIND v(dout1_19) AT=475.025n

.meas tran vdout1_20ck940 FIND v(dout1_20) AT=475.025n

.meas tran vdout1_21ck940 FIND v(dout1_21) AT=475.025n

.meas tran vdout1_22ck940 FIND v(dout1_22) AT=475.025n

.meas tran vdout1_23ck940 FIND v(dout1_23) AT=475.025n

.meas tran vdout1_24ck940 FIND v(dout1_24) AT=475.025n

.meas tran vdout1_25ck940 FIND v(dout1_25) AT=475.025n

.meas tran vdout1_26ck940 FIND v(dout1_26) AT=475.025n

.meas tran vdout1_27ck940 FIND v(dout1_27) AT=475.025n

.meas tran vdout1_28ck940 FIND v(dout1_28) AT=475.025n

.meas tran vdout1_29ck940 FIND v(dout1_29) AT=475.025n

.meas tran vdout1_30ck940 FIND v(dout1_30) AT=475.025n

.meas tran vdout1_31ck940 FIND v(dout1_31) AT=475.025n

.meas tran vdout1_32ck940 FIND v(dout1_32) AT=475.025n

.meas tran vdout1_33ck940 FIND v(dout1_33) AT=475.025n

.meas tran vdout1_34ck940 FIND v(dout1_34) AT=475.025n

.meas tran vdout1_35ck940 FIND v(dout1_35) AT=475.025n

.meas tran vdout1_36ck940 FIND v(dout1_36) AT=475.025n

.meas tran vdout1_37ck940 FIND v(dout1_37) AT=475.025n

.meas tran vdout1_38ck940 FIND v(dout1_38) AT=475.025n

.meas tran vdout1_39ck940 FIND v(dout1_39) AT=475.025n

.meas tran vdout1_40ck940 FIND v(dout1_40) AT=475.025n

.meas tran vdout1_41ck940 FIND v(dout1_41) AT=475.025n

.meas tran vdout1_42ck940 FIND v(dout1_42) AT=475.025n

.meas tran vdout1_43ck940 FIND v(dout1_43) AT=475.025n

.meas tran vdout1_44ck940 FIND v(dout1_44) AT=475.025n

.meas tran vdout1_45ck940 FIND v(dout1_45) AT=475.025n

.meas tran vdout1_46ck940 FIND v(dout1_46) AT=475.025n

.meas tran vdout1_47ck940 FIND v(dout1_47) AT=475.025n

.meas tran vdout1_48ck940 FIND v(dout1_48) AT=475.025n

.meas tran vdout1_49ck940 FIND v(dout1_49) AT=475.025n

.meas tran vdout1_50ck940 FIND v(dout1_50) AT=475.025n

.meas tran vdout1_51ck940 FIND v(dout1_51) AT=475.025n

.meas tran vdout1_52ck940 FIND v(dout1_52) AT=475.025n

.meas tran vdout1_53ck940 FIND v(dout1_53) AT=475.025n

.meas tran vdout1_54ck940 FIND v(dout1_54) AT=475.025n

.meas tran vdout1_55ck940 FIND v(dout1_55) AT=475.025n

.meas tran vdout1_56ck940 FIND v(dout1_56) AT=475.025n

.meas tran vdout1_57ck940 FIND v(dout1_57) AT=475.025n

.meas tran vdout1_58ck940 FIND v(dout1_58) AT=475.025n

.meas tran vdout1_59ck940 FIND v(dout1_59) AT=475.025n

.meas tran vdout1_60ck940 FIND v(dout1_60) AT=475.025n

.meas tran vdout1_61ck940 FIND v(dout1_61) AT=475.025n

.meas tran vdout1_62ck940 FIND v(dout1_62) AT=475.025n

.meas tran vdout1_63ck940 FIND v(dout1_63) AT=475.025n

.meas tran vdout1_64ck940 FIND v(dout1_64) AT=475.025n

.meas tran vdout1_65ck940 FIND v(dout1_65) AT=475.025n

.meas tran vdout1_66ck940 FIND v(dout1_66) AT=475.025n

.meas tran vdout1_67ck940 FIND v(dout1_67) AT=475.025n

.meas tran vdout1_68ck940 FIND v(dout1_68) AT=475.025n

.meas tran vdout1_69ck940 FIND v(dout1_69) AT=475.025n

.meas tran vdout1_70ck940 FIND v(dout1_70) AT=475.025n

.meas tran vdout1_71ck940 FIND v(dout1_71) AT=475.025n

.meas tran vdout1_72ck940 FIND v(dout1_72) AT=475.025n

.meas tran vdout1_73ck940 FIND v(dout1_73) AT=475.025n

.meas tran vdout1_74ck940 FIND v(dout1_74) AT=475.025n

.meas tran vdout1_75ck940 FIND v(dout1_75) AT=475.025n

.meas tran vdout1_76ck940 FIND v(dout1_76) AT=475.025n

.meas tran vdout1_77ck940 FIND v(dout1_77) AT=475.025n

.meas tran vdout1_78ck940 FIND v(dout1_78) AT=475.025n

.meas tran vdout1_79ck940 FIND v(dout1_79) AT=475.025n

.meas tran vdout1_80ck940 FIND v(dout1_80) AT=475.025n

.meas tran vdout1_81ck940 FIND v(dout1_81) AT=475.025n

.meas tran vdout1_82ck940 FIND v(dout1_82) AT=475.025n

.meas tran vdout1_83ck940 FIND v(dout1_83) AT=475.025n

.meas tran vdout1_84ck940 FIND v(dout1_84) AT=475.025n

.meas tran vdout1_85ck940 FIND v(dout1_85) AT=475.025n

.meas tran vdout1_86ck940 FIND v(dout1_86) AT=475.025n

.meas tran vdout1_87ck940 FIND v(dout1_87) AT=475.025n

.meas tran vdout1_88ck940 FIND v(dout1_88) AT=475.025n

.meas tran vdout1_89ck940 FIND v(dout1_89) AT=475.025n

.meas tran vdout1_90ck940 FIND v(dout1_90) AT=475.025n

.meas tran vdout1_91ck940 FIND v(dout1_91) AT=475.025n

.meas tran vdout1_92ck940 FIND v(dout1_92) AT=475.025n

.meas tran vdout1_93ck940 FIND v(dout1_93) AT=475.025n

.meas tran vdout1_94ck940 FIND v(dout1_94) AT=475.025n

.meas tran vdout1_95ck940 FIND v(dout1_95) AT=475.025n

.meas tran vdout1_96ck940 FIND v(dout1_96) AT=475.025n

.meas tran vdout1_97ck940 FIND v(dout1_97) AT=475.025n

.meas tran vdout1_98ck940 FIND v(dout1_98) AT=475.025n

.meas tran vdout1_99ck940 FIND v(dout1_99) AT=475.025n

.meas tran vdout1_100ck940 FIND v(dout1_100) AT=475.025n

.meas tran vdout1_101ck940 FIND v(dout1_101) AT=475.025n

.meas tran vdout1_102ck940 FIND v(dout1_102) AT=475.025n

.meas tran vdout1_103ck940 FIND v(dout1_103) AT=475.025n

.meas tran vdout1_104ck940 FIND v(dout1_104) AT=475.025n

.meas tran vdout1_105ck940 FIND v(dout1_105) AT=475.025n

.meas tran vdout1_106ck940 FIND v(dout1_106) AT=475.025n

.meas tran vdout1_107ck940 FIND v(dout1_107) AT=475.025n

.meas tran vdout1_108ck940 FIND v(dout1_108) AT=475.025n

.meas tran vdout1_109ck940 FIND v(dout1_109) AT=475.025n

.meas tran vdout1_110ck940 FIND v(dout1_110) AT=475.025n

.meas tran vdout1_111ck940 FIND v(dout1_111) AT=475.025n

.meas tran vdout1_112ck940 FIND v(dout1_112) AT=475.025n

.meas tran vdout1_113ck940 FIND v(dout1_113) AT=475.025n

.meas tran vdout1_114ck940 FIND v(dout1_114) AT=475.025n

.meas tran vdout1_115ck940 FIND v(dout1_115) AT=475.025n

.meas tran vdout1_116ck940 FIND v(dout1_116) AT=475.025n

.meas tran vdout1_117ck940 FIND v(dout1_117) AT=475.025n

.meas tran vdout1_118ck940 FIND v(dout1_118) AT=475.025n

.meas tran vdout1_119ck940 FIND v(dout1_119) AT=475.025n

.meas tran vdout1_120ck940 FIND v(dout1_120) AT=475.025n

.meas tran vdout1_121ck940 FIND v(dout1_121) AT=475.025n

.meas tran vdout1_122ck940 FIND v(dout1_122) AT=475.025n

.meas tran vdout1_123ck940 FIND v(dout1_123) AT=475.025n

.meas tran vdout1_124ck940 FIND v(dout1_124) AT=475.025n

.meas tran vdout1_125ck940 FIND v(dout1_125) AT=475.025n

.meas tran vdout1_126ck940 FIND v(dout1_126) AT=475.025n

.meas tran vdout1_127ck940 FIND v(dout1_127) AT=475.025n

.meas tran vdout1_0ck950 FIND v(dout1_0) AT=480.025n

.meas tran vdout1_1ck950 FIND v(dout1_1) AT=480.025n

.meas tran vdout1_2ck950 FIND v(dout1_2) AT=480.025n

.meas tran vdout1_3ck950 FIND v(dout1_3) AT=480.025n

.meas tran vdout1_4ck950 FIND v(dout1_4) AT=480.025n

.meas tran vdout1_5ck950 FIND v(dout1_5) AT=480.025n

.meas tran vdout1_6ck950 FIND v(dout1_6) AT=480.025n

.meas tran vdout1_7ck950 FIND v(dout1_7) AT=480.025n

.meas tran vdout1_8ck950 FIND v(dout1_8) AT=480.025n

.meas tran vdout1_9ck950 FIND v(dout1_9) AT=480.025n

.meas tran vdout1_10ck950 FIND v(dout1_10) AT=480.025n

.meas tran vdout1_11ck950 FIND v(dout1_11) AT=480.025n

.meas tran vdout1_12ck950 FIND v(dout1_12) AT=480.025n

.meas tran vdout1_13ck950 FIND v(dout1_13) AT=480.025n

.meas tran vdout1_14ck950 FIND v(dout1_14) AT=480.025n

.meas tran vdout1_15ck950 FIND v(dout1_15) AT=480.025n

.meas tran vdout1_16ck950 FIND v(dout1_16) AT=480.025n

.meas tran vdout1_17ck950 FIND v(dout1_17) AT=480.025n

.meas tran vdout1_18ck950 FIND v(dout1_18) AT=480.025n

.meas tran vdout1_19ck950 FIND v(dout1_19) AT=480.025n

.meas tran vdout1_20ck950 FIND v(dout1_20) AT=480.025n

.meas tran vdout1_21ck950 FIND v(dout1_21) AT=480.025n

.meas tran vdout1_22ck950 FIND v(dout1_22) AT=480.025n

.meas tran vdout1_23ck950 FIND v(dout1_23) AT=480.025n

.meas tran vdout1_24ck950 FIND v(dout1_24) AT=480.025n

.meas tran vdout1_25ck950 FIND v(dout1_25) AT=480.025n

.meas tran vdout1_26ck950 FIND v(dout1_26) AT=480.025n

.meas tran vdout1_27ck950 FIND v(dout1_27) AT=480.025n

.meas tran vdout1_28ck950 FIND v(dout1_28) AT=480.025n

.meas tran vdout1_29ck950 FIND v(dout1_29) AT=480.025n

.meas tran vdout1_30ck950 FIND v(dout1_30) AT=480.025n

.meas tran vdout1_31ck950 FIND v(dout1_31) AT=480.025n

.meas tran vdout1_32ck950 FIND v(dout1_32) AT=480.025n

.meas tran vdout1_33ck950 FIND v(dout1_33) AT=480.025n

.meas tran vdout1_34ck950 FIND v(dout1_34) AT=480.025n

.meas tran vdout1_35ck950 FIND v(dout1_35) AT=480.025n

.meas tran vdout1_36ck950 FIND v(dout1_36) AT=480.025n

.meas tran vdout1_37ck950 FIND v(dout1_37) AT=480.025n

.meas tran vdout1_38ck950 FIND v(dout1_38) AT=480.025n

.meas tran vdout1_39ck950 FIND v(dout1_39) AT=480.025n

.meas tran vdout1_40ck950 FIND v(dout1_40) AT=480.025n

.meas tran vdout1_41ck950 FIND v(dout1_41) AT=480.025n

.meas tran vdout1_42ck950 FIND v(dout1_42) AT=480.025n

.meas tran vdout1_43ck950 FIND v(dout1_43) AT=480.025n

.meas tran vdout1_44ck950 FIND v(dout1_44) AT=480.025n

.meas tran vdout1_45ck950 FIND v(dout1_45) AT=480.025n

.meas tran vdout1_46ck950 FIND v(dout1_46) AT=480.025n

.meas tran vdout1_47ck950 FIND v(dout1_47) AT=480.025n

.meas tran vdout1_48ck950 FIND v(dout1_48) AT=480.025n

.meas tran vdout1_49ck950 FIND v(dout1_49) AT=480.025n

.meas tran vdout1_50ck950 FIND v(dout1_50) AT=480.025n

.meas tran vdout1_51ck950 FIND v(dout1_51) AT=480.025n

.meas tran vdout1_52ck950 FIND v(dout1_52) AT=480.025n

.meas tran vdout1_53ck950 FIND v(dout1_53) AT=480.025n

.meas tran vdout1_54ck950 FIND v(dout1_54) AT=480.025n

.meas tran vdout1_55ck950 FIND v(dout1_55) AT=480.025n

.meas tran vdout1_56ck950 FIND v(dout1_56) AT=480.025n

.meas tran vdout1_57ck950 FIND v(dout1_57) AT=480.025n

.meas tran vdout1_58ck950 FIND v(dout1_58) AT=480.025n

.meas tran vdout1_59ck950 FIND v(dout1_59) AT=480.025n

.meas tran vdout1_60ck950 FIND v(dout1_60) AT=480.025n

.meas tran vdout1_61ck950 FIND v(dout1_61) AT=480.025n

.meas tran vdout1_62ck950 FIND v(dout1_62) AT=480.025n

.meas tran vdout1_63ck950 FIND v(dout1_63) AT=480.025n

.meas tran vdout1_64ck950 FIND v(dout1_64) AT=480.025n

.meas tran vdout1_65ck950 FIND v(dout1_65) AT=480.025n

.meas tran vdout1_66ck950 FIND v(dout1_66) AT=480.025n

.meas tran vdout1_67ck950 FIND v(dout1_67) AT=480.025n

.meas tran vdout1_68ck950 FIND v(dout1_68) AT=480.025n

.meas tran vdout1_69ck950 FIND v(dout1_69) AT=480.025n

.meas tran vdout1_70ck950 FIND v(dout1_70) AT=480.025n

.meas tran vdout1_71ck950 FIND v(dout1_71) AT=480.025n

.meas tran vdout1_72ck950 FIND v(dout1_72) AT=480.025n

.meas tran vdout1_73ck950 FIND v(dout1_73) AT=480.025n

.meas tran vdout1_74ck950 FIND v(dout1_74) AT=480.025n

.meas tran vdout1_75ck950 FIND v(dout1_75) AT=480.025n

.meas tran vdout1_76ck950 FIND v(dout1_76) AT=480.025n

.meas tran vdout1_77ck950 FIND v(dout1_77) AT=480.025n

.meas tran vdout1_78ck950 FIND v(dout1_78) AT=480.025n

.meas tran vdout1_79ck950 FIND v(dout1_79) AT=480.025n

.meas tran vdout1_80ck950 FIND v(dout1_80) AT=480.025n

.meas tran vdout1_81ck950 FIND v(dout1_81) AT=480.025n

.meas tran vdout1_82ck950 FIND v(dout1_82) AT=480.025n

.meas tran vdout1_83ck950 FIND v(dout1_83) AT=480.025n

.meas tran vdout1_84ck950 FIND v(dout1_84) AT=480.025n

.meas tran vdout1_85ck950 FIND v(dout1_85) AT=480.025n

.meas tran vdout1_86ck950 FIND v(dout1_86) AT=480.025n

.meas tran vdout1_87ck950 FIND v(dout1_87) AT=480.025n

.meas tran vdout1_88ck950 FIND v(dout1_88) AT=480.025n

.meas tran vdout1_89ck950 FIND v(dout1_89) AT=480.025n

.meas tran vdout1_90ck950 FIND v(dout1_90) AT=480.025n

.meas tran vdout1_91ck950 FIND v(dout1_91) AT=480.025n

.meas tran vdout1_92ck950 FIND v(dout1_92) AT=480.025n

.meas tran vdout1_93ck950 FIND v(dout1_93) AT=480.025n

.meas tran vdout1_94ck950 FIND v(dout1_94) AT=480.025n

.meas tran vdout1_95ck950 FIND v(dout1_95) AT=480.025n

.meas tran vdout1_96ck950 FIND v(dout1_96) AT=480.025n

.meas tran vdout1_97ck950 FIND v(dout1_97) AT=480.025n

.meas tran vdout1_98ck950 FIND v(dout1_98) AT=480.025n

.meas tran vdout1_99ck950 FIND v(dout1_99) AT=480.025n

.meas tran vdout1_100ck950 FIND v(dout1_100) AT=480.025n

.meas tran vdout1_101ck950 FIND v(dout1_101) AT=480.025n

.meas tran vdout1_102ck950 FIND v(dout1_102) AT=480.025n

.meas tran vdout1_103ck950 FIND v(dout1_103) AT=480.025n

.meas tran vdout1_104ck950 FIND v(dout1_104) AT=480.025n

.meas tran vdout1_105ck950 FIND v(dout1_105) AT=480.025n

.meas tran vdout1_106ck950 FIND v(dout1_106) AT=480.025n

.meas tran vdout1_107ck950 FIND v(dout1_107) AT=480.025n

.meas tran vdout1_108ck950 FIND v(dout1_108) AT=480.025n

.meas tran vdout1_109ck950 FIND v(dout1_109) AT=480.025n

.meas tran vdout1_110ck950 FIND v(dout1_110) AT=480.025n

.meas tran vdout1_111ck950 FIND v(dout1_111) AT=480.025n

.meas tran vdout1_112ck950 FIND v(dout1_112) AT=480.025n

.meas tran vdout1_113ck950 FIND v(dout1_113) AT=480.025n

.meas tran vdout1_114ck950 FIND v(dout1_114) AT=480.025n

.meas tran vdout1_115ck950 FIND v(dout1_115) AT=480.025n

.meas tran vdout1_116ck950 FIND v(dout1_116) AT=480.025n

.meas tran vdout1_117ck950 FIND v(dout1_117) AT=480.025n

.meas tran vdout1_118ck950 FIND v(dout1_118) AT=480.025n

.meas tran vdout1_119ck950 FIND v(dout1_119) AT=480.025n

.meas tran vdout1_120ck950 FIND v(dout1_120) AT=480.025n

.meas tran vdout1_121ck950 FIND v(dout1_121) AT=480.025n

.meas tran vdout1_122ck950 FIND v(dout1_122) AT=480.025n

.meas tran vdout1_123ck950 FIND v(dout1_123) AT=480.025n

.meas tran vdout1_124ck950 FIND v(dout1_124) AT=480.025n

.meas tran vdout1_125ck950 FIND v(dout1_125) AT=480.025n

.meas tran vdout1_126ck950 FIND v(dout1_126) AT=480.025n

.meas tran vdout1_127ck950 FIND v(dout1_127) AT=480.025n

.meas tran vdout1_0ck960 FIND v(dout1_0) AT=485.025n

.meas tran vdout1_1ck960 FIND v(dout1_1) AT=485.025n

.meas tran vdout1_2ck960 FIND v(dout1_2) AT=485.025n

.meas tran vdout1_3ck960 FIND v(dout1_3) AT=485.025n

.meas tran vdout1_4ck960 FIND v(dout1_4) AT=485.025n

.meas tran vdout1_5ck960 FIND v(dout1_5) AT=485.025n

.meas tran vdout1_6ck960 FIND v(dout1_6) AT=485.025n

.meas tran vdout1_7ck960 FIND v(dout1_7) AT=485.025n

.meas tran vdout1_8ck960 FIND v(dout1_8) AT=485.025n

.meas tran vdout1_9ck960 FIND v(dout1_9) AT=485.025n

.meas tran vdout1_10ck960 FIND v(dout1_10) AT=485.025n

.meas tran vdout1_11ck960 FIND v(dout1_11) AT=485.025n

.meas tran vdout1_12ck960 FIND v(dout1_12) AT=485.025n

.meas tran vdout1_13ck960 FIND v(dout1_13) AT=485.025n

.meas tran vdout1_14ck960 FIND v(dout1_14) AT=485.025n

.meas tran vdout1_15ck960 FIND v(dout1_15) AT=485.025n

.meas tran vdout1_16ck960 FIND v(dout1_16) AT=485.025n

.meas tran vdout1_17ck960 FIND v(dout1_17) AT=485.025n

.meas tran vdout1_18ck960 FIND v(dout1_18) AT=485.025n

.meas tran vdout1_19ck960 FIND v(dout1_19) AT=485.025n

.meas tran vdout1_20ck960 FIND v(dout1_20) AT=485.025n

.meas tran vdout1_21ck960 FIND v(dout1_21) AT=485.025n

.meas tran vdout1_22ck960 FIND v(dout1_22) AT=485.025n

.meas tran vdout1_23ck960 FIND v(dout1_23) AT=485.025n

.meas tran vdout1_24ck960 FIND v(dout1_24) AT=485.025n

.meas tran vdout1_25ck960 FIND v(dout1_25) AT=485.025n

.meas tran vdout1_26ck960 FIND v(dout1_26) AT=485.025n

.meas tran vdout1_27ck960 FIND v(dout1_27) AT=485.025n

.meas tran vdout1_28ck960 FIND v(dout1_28) AT=485.025n

.meas tran vdout1_29ck960 FIND v(dout1_29) AT=485.025n

.meas tran vdout1_30ck960 FIND v(dout1_30) AT=485.025n

.meas tran vdout1_31ck960 FIND v(dout1_31) AT=485.025n

.meas tran vdout1_32ck960 FIND v(dout1_32) AT=485.025n

.meas tran vdout1_33ck960 FIND v(dout1_33) AT=485.025n

.meas tran vdout1_34ck960 FIND v(dout1_34) AT=485.025n

.meas tran vdout1_35ck960 FIND v(dout1_35) AT=485.025n

.meas tran vdout1_36ck960 FIND v(dout1_36) AT=485.025n

.meas tran vdout1_37ck960 FIND v(dout1_37) AT=485.025n

.meas tran vdout1_38ck960 FIND v(dout1_38) AT=485.025n

.meas tran vdout1_39ck960 FIND v(dout1_39) AT=485.025n

.meas tran vdout1_40ck960 FIND v(dout1_40) AT=485.025n

.meas tran vdout1_41ck960 FIND v(dout1_41) AT=485.025n

.meas tran vdout1_42ck960 FIND v(dout1_42) AT=485.025n

.meas tran vdout1_43ck960 FIND v(dout1_43) AT=485.025n

.meas tran vdout1_44ck960 FIND v(dout1_44) AT=485.025n

.meas tran vdout1_45ck960 FIND v(dout1_45) AT=485.025n

.meas tran vdout1_46ck960 FIND v(dout1_46) AT=485.025n

.meas tran vdout1_47ck960 FIND v(dout1_47) AT=485.025n

.meas tran vdout1_48ck960 FIND v(dout1_48) AT=485.025n

.meas tran vdout1_49ck960 FIND v(dout1_49) AT=485.025n

.meas tran vdout1_50ck960 FIND v(dout1_50) AT=485.025n

.meas tran vdout1_51ck960 FIND v(dout1_51) AT=485.025n

.meas tran vdout1_52ck960 FIND v(dout1_52) AT=485.025n

.meas tran vdout1_53ck960 FIND v(dout1_53) AT=485.025n

.meas tran vdout1_54ck960 FIND v(dout1_54) AT=485.025n

.meas tran vdout1_55ck960 FIND v(dout1_55) AT=485.025n

.meas tran vdout1_56ck960 FIND v(dout1_56) AT=485.025n

.meas tran vdout1_57ck960 FIND v(dout1_57) AT=485.025n

.meas tran vdout1_58ck960 FIND v(dout1_58) AT=485.025n

.meas tran vdout1_59ck960 FIND v(dout1_59) AT=485.025n

.meas tran vdout1_60ck960 FIND v(dout1_60) AT=485.025n

.meas tran vdout1_61ck960 FIND v(dout1_61) AT=485.025n

.meas tran vdout1_62ck960 FIND v(dout1_62) AT=485.025n

.meas tran vdout1_63ck960 FIND v(dout1_63) AT=485.025n

.meas tran vdout1_64ck960 FIND v(dout1_64) AT=485.025n

.meas tran vdout1_65ck960 FIND v(dout1_65) AT=485.025n

.meas tran vdout1_66ck960 FIND v(dout1_66) AT=485.025n

.meas tran vdout1_67ck960 FIND v(dout1_67) AT=485.025n

.meas tran vdout1_68ck960 FIND v(dout1_68) AT=485.025n

.meas tran vdout1_69ck960 FIND v(dout1_69) AT=485.025n

.meas tran vdout1_70ck960 FIND v(dout1_70) AT=485.025n

.meas tran vdout1_71ck960 FIND v(dout1_71) AT=485.025n

.meas tran vdout1_72ck960 FIND v(dout1_72) AT=485.025n

.meas tran vdout1_73ck960 FIND v(dout1_73) AT=485.025n

.meas tran vdout1_74ck960 FIND v(dout1_74) AT=485.025n

.meas tran vdout1_75ck960 FIND v(dout1_75) AT=485.025n

.meas tran vdout1_76ck960 FIND v(dout1_76) AT=485.025n

.meas tran vdout1_77ck960 FIND v(dout1_77) AT=485.025n

.meas tran vdout1_78ck960 FIND v(dout1_78) AT=485.025n

.meas tran vdout1_79ck960 FIND v(dout1_79) AT=485.025n

.meas tran vdout1_80ck960 FIND v(dout1_80) AT=485.025n

.meas tran vdout1_81ck960 FIND v(dout1_81) AT=485.025n

.meas tran vdout1_82ck960 FIND v(dout1_82) AT=485.025n

.meas tran vdout1_83ck960 FIND v(dout1_83) AT=485.025n

.meas tran vdout1_84ck960 FIND v(dout1_84) AT=485.025n

.meas tran vdout1_85ck960 FIND v(dout1_85) AT=485.025n

.meas tran vdout1_86ck960 FIND v(dout1_86) AT=485.025n

.meas tran vdout1_87ck960 FIND v(dout1_87) AT=485.025n

.meas tran vdout1_88ck960 FIND v(dout1_88) AT=485.025n

.meas tran vdout1_89ck960 FIND v(dout1_89) AT=485.025n

.meas tran vdout1_90ck960 FIND v(dout1_90) AT=485.025n

.meas tran vdout1_91ck960 FIND v(dout1_91) AT=485.025n

.meas tran vdout1_92ck960 FIND v(dout1_92) AT=485.025n

.meas tran vdout1_93ck960 FIND v(dout1_93) AT=485.025n

.meas tran vdout1_94ck960 FIND v(dout1_94) AT=485.025n

.meas tran vdout1_95ck960 FIND v(dout1_95) AT=485.025n

.meas tran vdout1_96ck960 FIND v(dout1_96) AT=485.025n

.meas tran vdout1_97ck960 FIND v(dout1_97) AT=485.025n

.meas tran vdout1_98ck960 FIND v(dout1_98) AT=485.025n

.meas tran vdout1_99ck960 FIND v(dout1_99) AT=485.025n

.meas tran vdout1_100ck960 FIND v(dout1_100) AT=485.025n

.meas tran vdout1_101ck960 FIND v(dout1_101) AT=485.025n

.meas tran vdout1_102ck960 FIND v(dout1_102) AT=485.025n

.meas tran vdout1_103ck960 FIND v(dout1_103) AT=485.025n

.meas tran vdout1_104ck960 FIND v(dout1_104) AT=485.025n

.meas tran vdout1_105ck960 FIND v(dout1_105) AT=485.025n

.meas tran vdout1_106ck960 FIND v(dout1_106) AT=485.025n

.meas tran vdout1_107ck960 FIND v(dout1_107) AT=485.025n

.meas tran vdout1_108ck960 FIND v(dout1_108) AT=485.025n

.meas tran vdout1_109ck960 FIND v(dout1_109) AT=485.025n

.meas tran vdout1_110ck960 FIND v(dout1_110) AT=485.025n

.meas tran vdout1_111ck960 FIND v(dout1_111) AT=485.025n

.meas tran vdout1_112ck960 FIND v(dout1_112) AT=485.025n

.meas tran vdout1_113ck960 FIND v(dout1_113) AT=485.025n

.meas tran vdout1_114ck960 FIND v(dout1_114) AT=485.025n

.meas tran vdout1_115ck960 FIND v(dout1_115) AT=485.025n

.meas tran vdout1_116ck960 FIND v(dout1_116) AT=485.025n

.meas tran vdout1_117ck960 FIND v(dout1_117) AT=485.025n

.meas tran vdout1_118ck960 FIND v(dout1_118) AT=485.025n

.meas tran vdout1_119ck960 FIND v(dout1_119) AT=485.025n

.meas tran vdout1_120ck960 FIND v(dout1_120) AT=485.025n

.meas tran vdout1_121ck960 FIND v(dout1_121) AT=485.025n

.meas tran vdout1_122ck960 FIND v(dout1_122) AT=485.025n

.meas tran vdout1_123ck960 FIND v(dout1_123) AT=485.025n

.meas tran vdout1_124ck960 FIND v(dout1_124) AT=485.025n

.meas tran vdout1_125ck960 FIND v(dout1_125) AT=485.025n

.meas tran vdout1_126ck960 FIND v(dout1_126) AT=485.025n

.meas tran vdout1_127ck960 FIND v(dout1_127) AT=485.025n

.meas tran vdout1_0ck990 FIND v(dout1_0) AT=500.025n

.meas tran vdout1_1ck990 FIND v(dout1_1) AT=500.025n

.meas tran vdout1_2ck990 FIND v(dout1_2) AT=500.025n

.meas tran vdout1_3ck990 FIND v(dout1_3) AT=500.025n

.meas tran vdout1_4ck990 FIND v(dout1_4) AT=500.025n

.meas tran vdout1_5ck990 FIND v(dout1_5) AT=500.025n

.meas tran vdout1_6ck990 FIND v(dout1_6) AT=500.025n

.meas tran vdout1_7ck990 FIND v(dout1_7) AT=500.025n

.meas tran vdout1_8ck990 FIND v(dout1_8) AT=500.025n

.meas tran vdout1_9ck990 FIND v(dout1_9) AT=500.025n

.meas tran vdout1_10ck990 FIND v(dout1_10) AT=500.025n

.meas tran vdout1_11ck990 FIND v(dout1_11) AT=500.025n

.meas tran vdout1_12ck990 FIND v(dout1_12) AT=500.025n

.meas tran vdout1_13ck990 FIND v(dout1_13) AT=500.025n

.meas tran vdout1_14ck990 FIND v(dout1_14) AT=500.025n

.meas tran vdout1_15ck990 FIND v(dout1_15) AT=500.025n

.meas tran vdout1_16ck990 FIND v(dout1_16) AT=500.025n

.meas tran vdout1_17ck990 FIND v(dout1_17) AT=500.025n

.meas tran vdout1_18ck990 FIND v(dout1_18) AT=500.025n

.meas tran vdout1_19ck990 FIND v(dout1_19) AT=500.025n

.meas tran vdout1_20ck990 FIND v(dout1_20) AT=500.025n

.meas tran vdout1_21ck990 FIND v(dout1_21) AT=500.025n

.meas tran vdout1_22ck990 FIND v(dout1_22) AT=500.025n

.meas tran vdout1_23ck990 FIND v(dout1_23) AT=500.025n

.meas tran vdout1_24ck990 FIND v(dout1_24) AT=500.025n

.meas tran vdout1_25ck990 FIND v(dout1_25) AT=500.025n

.meas tran vdout1_26ck990 FIND v(dout1_26) AT=500.025n

.meas tran vdout1_27ck990 FIND v(dout1_27) AT=500.025n

.meas tran vdout1_28ck990 FIND v(dout1_28) AT=500.025n

.meas tran vdout1_29ck990 FIND v(dout1_29) AT=500.025n

.meas tran vdout1_30ck990 FIND v(dout1_30) AT=500.025n

.meas tran vdout1_31ck990 FIND v(dout1_31) AT=500.025n

.meas tran vdout1_32ck990 FIND v(dout1_32) AT=500.025n

.meas tran vdout1_33ck990 FIND v(dout1_33) AT=500.025n

.meas tran vdout1_34ck990 FIND v(dout1_34) AT=500.025n

.meas tran vdout1_35ck990 FIND v(dout1_35) AT=500.025n

.meas tran vdout1_36ck990 FIND v(dout1_36) AT=500.025n

.meas tran vdout1_37ck990 FIND v(dout1_37) AT=500.025n

.meas tran vdout1_38ck990 FIND v(dout1_38) AT=500.025n

.meas tran vdout1_39ck990 FIND v(dout1_39) AT=500.025n

.meas tran vdout1_40ck990 FIND v(dout1_40) AT=500.025n

.meas tran vdout1_41ck990 FIND v(dout1_41) AT=500.025n

.meas tran vdout1_42ck990 FIND v(dout1_42) AT=500.025n

.meas tran vdout1_43ck990 FIND v(dout1_43) AT=500.025n

.meas tran vdout1_44ck990 FIND v(dout1_44) AT=500.025n

.meas tran vdout1_45ck990 FIND v(dout1_45) AT=500.025n

.meas tran vdout1_46ck990 FIND v(dout1_46) AT=500.025n

.meas tran vdout1_47ck990 FIND v(dout1_47) AT=500.025n

.meas tran vdout1_48ck990 FIND v(dout1_48) AT=500.025n

.meas tran vdout1_49ck990 FIND v(dout1_49) AT=500.025n

.meas tran vdout1_50ck990 FIND v(dout1_50) AT=500.025n

.meas tran vdout1_51ck990 FIND v(dout1_51) AT=500.025n

.meas tran vdout1_52ck990 FIND v(dout1_52) AT=500.025n

.meas tran vdout1_53ck990 FIND v(dout1_53) AT=500.025n

.meas tran vdout1_54ck990 FIND v(dout1_54) AT=500.025n

.meas tran vdout1_55ck990 FIND v(dout1_55) AT=500.025n

.meas tran vdout1_56ck990 FIND v(dout1_56) AT=500.025n

.meas tran vdout1_57ck990 FIND v(dout1_57) AT=500.025n

.meas tran vdout1_58ck990 FIND v(dout1_58) AT=500.025n

.meas tran vdout1_59ck990 FIND v(dout1_59) AT=500.025n

.meas tran vdout1_60ck990 FIND v(dout1_60) AT=500.025n

.meas tran vdout1_61ck990 FIND v(dout1_61) AT=500.025n

.meas tran vdout1_62ck990 FIND v(dout1_62) AT=500.025n

.meas tran vdout1_63ck990 FIND v(dout1_63) AT=500.025n

.meas tran vdout1_64ck990 FIND v(dout1_64) AT=500.025n

.meas tran vdout1_65ck990 FIND v(dout1_65) AT=500.025n

.meas tran vdout1_66ck990 FIND v(dout1_66) AT=500.025n

.meas tran vdout1_67ck990 FIND v(dout1_67) AT=500.025n

.meas tran vdout1_68ck990 FIND v(dout1_68) AT=500.025n

.meas tran vdout1_69ck990 FIND v(dout1_69) AT=500.025n

.meas tran vdout1_70ck990 FIND v(dout1_70) AT=500.025n

.meas tran vdout1_71ck990 FIND v(dout1_71) AT=500.025n

.meas tran vdout1_72ck990 FIND v(dout1_72) AT=500.025n

.meas tran vdout1_73ck990 FIND v(dout1_73) AT=500.025n

.meas tran vdout1_74ck990 FIND v(dout1_74) AT=500.025n

.meas tran vdout1_75ck990 FIND v(dout1_75) AT=500.025n

.meas tran vdout1_76ck990 FIND v(dout1_76) AT=500.025n

.meas tran vdout1_77ck990 FIND v(dout1_77) AT=500.025n

.meas tran vdout1_78ck990 FIND v(dout1_78) AT=500.025n

.meas tran vdout1_79ck990 FIND v(dout1_79) AT=500.025n

.meas tran vdout1_80ck990 FIND v(dout1_80) AT=500.025n

.meas tran vdout1_81ck990 FIND v(dout1_81) AT=500.025n

.meas tran vdout1_82ck990 FIND v(dout1_82) AT=500.025n

.meas tran vdout1_83ck990 FIND v(dout1_83) AT=500.025n

.meas tran vdout1_84ck990 FIND v(dout1_84) AT=500.025n

.meas tran vdout1_85ck990 FIND v(dout1_85) AT=500.025n

.meas tran vdout1_86ck990 FIND v(dout1_86) AT=500.025n

.meas tran vdout1_87ck990 FIND v(dout1_87) AT=500.025n

.meas tran vdout1_88ck990 FIND v(dout1_88) AT=500.025n

.meas tran vdout1_89ck990 FIND v(dout1_89) AT=500.025n

.meas tran vdout1_90ck990 FIND v(dout1_90) AT=500.025n

.meas tran vdout1_91ck990 FIND v(dout1_91) AT=500.025n

.meas tran vdout1_92ck990 FIND v(dout1_92) AT=500.025n

.meas tran vdout1_93ck990 FIND v(dout1_93) AT=500.025n

.meas tran vdout1_94ck990 FIND v(dout1_94) AT=500.025n

.meas tran vdout1_95ck990 FIND v(dout1_95) AT=500.025n

.meas tran vdout1_96ck990 FIND v(dout1_96) AT=500.025n

.meas tran vdout1_97ck990 FIND v(dout1_97) AT=500.025n

.meas tran vdout1_98ck990 FIND v(dout1_98) AT=500.025n

.meas tran vdout1_99ck990 FIND v(dout1_99) AT=500.025n

.meas tran vdout1_100ck990 FIND v(dout1_100) AT=500.025n

.meas tran vdout1_101ck990 FIND v(dout1_101) AT=500.025n

.meas tran vdout1_102ck990 FIND v(dout1_102) AT=500.025n

.meas tran vdout1_103ck990 FIND v(dout1_103) AT=500.025n

.meas tran vdout1_104ck990 FIND v(dout1_104) AT=500.025n

.meas tran vdout1_105ck990 FIND v(dout1_105) AT=500.025n

.meas tran vdout1_106ck990 FIND v(dout1_106) AT=500.025n

.meas tran vdout1_107ck990 FIND v(dout1_107) AT=500.025n

.meas tran vdout1_108ck990 FIND v(dout1_108) AT=500.025n

.meas tran vdout1_109ck990 FIND v(dout1_109) AT=500.025n

.meas tran vdout1_110ck990 FIND v(dout1_110) AT=500.025n

.meas tran vdout1_111ck990 FIND v(dout1_111) AT=500.025n

.meas tran vdout1_112ck990 FIND v(dout1_112) AT=500.025n

.meas tran vdout1_113ck990 FIND v(dout1_113) AT=500.025n

.meas tran vdout1_114ck990 FIND v(dout1_114) AT=500.025n

.meas tran vdout1_115ck990 FIND v(dout1_115) AT=500.025n

.meas tran vdout1_116ck990 FIND v(dout1_116) AT=500.025n

.meas tran vdout1_117ck990 FIND v(dout1_117) AT=500.025n

.meas tran vdout1_118ck990 FIND v(dout1_118) AT=500.025n

.meas tran vdout1_119ck990 FIND v(dout1_119) AT=500.025n

.meas tran vdout1_120ck990 FIND v(dout1_120) AT=500.025n

.meas tran vdout1_121ck990 FIND v(dout1_121) AT=500.025n

.meas tran vdout1_122ck990 FIND v(dout1_122) AT=500.025n

.meas tran vdout1_123ck990 FIND v(dout1_123) AT=500.025n

.meas tran vdout1_124ck990 FIND v(dout1_124) AT=500.025n

.meas tran vdout1_125ck990 FIND v(dout1_125) AT=500.025n

.meas tran vdout1_126ck990 FIND v(dout1_126) AT=500.025n

.meas tran vdout1_127ck990 FIND v(dout1_127) AT=500.025n

.meas tran vdout1_0ck1050 FIND v(dout1_0) AT=530.025n

.meas tran vdout1_1ck1050 FIND v(dout1_1) AT=530.025n

.meas tran vdout1_2ck1050 FIND v(dout1_2) AT=530.025n

.meas tran vdout1_3ck1050 FIND v(dout1_3) AT=530.025n

.meas tran vdout1_4ck1050 FIND v(dout1_4) AT=530.025n

.meas tran vdout1_5ck1050 FIND v(dout1_5) AT=530.025n

.meas tran vdout1_6ck1050 FIND v(dout1_6) AT=530.025n

.meas tran vdout1_7ck1050 FIND v(dout1_7) AT=530.025n

.meas tran vdout1_8ck1050 FIND v(dout1_8) AT=530.025n

.meas tran vdout1_9ck1050 FIND v(dout1_9) AT=530.025n

.meas tran vdout1_10ck1050 FIND v(dout1_10) AT=530.025n

.meas tran vdout1_11ck1050 FIND v(dout1_11) AT=530.025n

.meas tran vdout1_12ck1050 FIND v(dout1_12) AT=530.025n

.meas tran vdout1_13ck1050 FIND v(dout1_13) AT=530.025n

.meas tran vdout1_14ck1050 FIND v(dout1_14) AT=530.025n

.meas tran vdout1_15ck1050 FIND v(dout1_15) AT=530.025n

.meas tran vdout1_16ck1050 FIND v(dout1_16) AT=530.025n

.meas tran vdout1_17ck1050 FIND v(dout1_17) AT=530.025n

.meas tran vdout1_18ck1050 FIND v(dout1_18) AT=530.025n

.meas tran vdout1_19ck1050 FIND v(dout1_19) AT=530.025n

.meas tran vdout1_20ck1050 FIND v(dout1_20) AT=530.025n

.meas tran vdout1_21ck1050 FIND v(dout1_21) AT=530.025n

.meas tran vdout1_22ck1050 FIND v(dout1_22) AT=530.025n

.meas tran vdout1_23ck1050 FIND v(dout1_23) AT=530.025n

.meas tran vdout1_24ck1050 FIND v(dout1_24) AT=530.025n

.meas tran vdout1_25ck1050 FIND v(dout1_25) AT=530.025n

.meas tran vdout1_26ck1050 FIND v(dout1_26) AT=530.025n

.meas tran vdout1_27ck1050 FIND v(dout1_27) AT=530.025n

.meas tran vdout1_28ck1050 FIND v(dout1_28) AT=530.025n

.meas tran vdout1_29ck1050 FIND v(dout1_29) AT=530.025n

.meas tran vdout1_30ck1050 FIND v(dout1_30) AT=530.025n

.meas tran vdout1_31ck1050 FIND v(dout1_31) AT=530.025n

.meas tran vdout1_32ck1050 FIND v(dout1_32) AT=530.025n

.meas tran vdout1_33ck1050 FIND v(dout1_33) AT=530.025n

.meas tran vdout1_34ck1050 FIND v(dout1_34) AT=530.025n

.meas tran vdout1_35ck1050 FIND v(dout1_35) AT=530.025n

.meas tran vdout1_36ck1050 FIND v(dout1_36) AT=530.025n

.meas tran vdout1_37ck1050 FIND v(dout1_37) AT=530.025n

.meas tran vdout1_38ck1050 FIND v(dout1_38) AT=530.025n

.meas tran vdout1_39ck1050 FIND v(dout1_39) AT=530.025n

.meas tran vdout1_40ck1050 FIND v(dout1_40) AT=530.025n

.meas tran vdout1_41ck1050 FIND v(dout1_41) AT=530.025n

.meas tran vdout1_42ck1050 FIND v(dout1_42) AT=530.025n

.meas tran vdout1_43ck1050 FIND v(dout1_43) AT=530.025n

.meas tran vdout1_44ck1050 FIND v(dout1_44) AT=530.025n

.meas tran vdout1_45ck1050 FIND v(dout1_45) AT=530.025n

.meas tran vdout1_46ck1050 FIND v(dout1_46) AT=530.025n

.meas tran vdout1_47ck1050 FIND v(dout1_47) AT=530.025n

.meas tran vdout1_48ck1050 FIND v(dout1_48) AT=530.025n

.meas tran vdout1_49ck1050 FIND v(dout1_49) AT=530.025n

.meas tran vdout1_50ck1050 FIND v(dout1_50) AT=530.025n

.meas tran vdout1_51ck1050 FIND v(dout1_51) AT=530.025n

.meas tran vdout1_52ck1050 FIND v(dout1_52) AT=530.025n

.meas tran vdout1_53ck1050 FIND v(dout1_53) AT=530.025n

.meas tran vdout1_54ck1050 FIND v(dout1_54) AT=530.025n

.meas tran vdout1_55ck1050 FIND v(dout1_55) AT=530.025n

.meas tran vdout1_56ck1050 FIND v(dout1_56) AT=530.025n

.meas tran vdout1_57ck1050 FIND v(dout1_57) AT=530.025n

.meas tran vdout1_58ck1050 FIND v(dout1_58) AT=530.025n

.meas tran vdout1_59ck1050 FIND v(dout1_59) AT=530.025n

.meas tran vdout1_60ck1050 FIND v(dout1_60) AT=530.025n

.meas tran vdout1_61ck1050 FIND v(dout1_61) AT=530.025n

.meas tran vdout1_62ck1050 FIND v(dout1_62) AT=530.025n

.meas tran vdout1_63ck1050 FIND v(dout1_63) AT=530.025n

.meas tran vdout1_64ck1050 FIND v(dout1_64) AT=530.025n

.meas tran vdout1_65ck1050 FIND v(dout1_65) AT=530.025n

.meas tran vdout1_66ck1050 FIND v(dout1_66) AT=530.025n

.meas tran vdout1_67ck1050 FIND v(dout1_67) AT=530.025n

.meas tran vdout1_68ck1050 FIND v(dout1_68) AT=530.025n

.meas tran vdout1_69ck1050 FIND v(dout1_69) AT=530.025n

.meas tran vdout1_70ck1050 FIND v(dout1_70) AT=530.025n

.meas tran vdout1_71ck1050 FIND v(dout1_71) AT=530.025n

.meas tran vdout1_72ck1050 FIND v(dout1_72) AT=530.025n

.meas tran vdout1_73ck1050 FIND v(dout1_73) AT=530.025n

.meas tran vdout1_74ck1050 FIND v(dout1_74) AT=530.025n

.meas tran vdout1_75ck1050 FIND v(dout1_75) AT=530.025n

.meas tran vdout1_76ck1050 FIND v(dout1_76) AT=530.025n

.meas tran vdout1_77ck1050 FIND v(dout1_77) AT=530.025n

.meas tran vdout1_78ck1050 FIND v(dout1_78) AT=530.025n

.meas tran vdout1_79ck1050 FIND v(dout1_79) AT=530.025n

.meas tran vdout1_80ck1050 FIND v(dout1_80) AT=530.025n

.meas tran vdout1_81ck1050 FIND v(dout1_81) AT=530.025n

.meas tran vdout1_82ck1050 FIND v(dout1_82) AT=530.025n

.meas tran vdout1_83ck1050 FIND v(dout1_83) AT=530.025n

.meas tran vdout1_84ck1050 FIND v(dout1_84) AT=530.025n

.meas tran vdout1_85ck1050 FIND v(dout1_85) AT=530.025n

.meas tran vdout1_86ck1050 FIND v(dout1_86) AT=530.025n

.meas tran vdout1_87ck1050 FIND v(dout1_87) AT=530.025n

.meas tran vdout1_88ck1050 FIND v(dout1_88) AT=530.025n

.meas tran vdout1_89ck1050 FIND v(dout1_89) AT=530.025n

.meas tran vdout1_90ck1050 FIND v(dout1_90) AT=530.025n

.meas tran vdout1_91ck1050 FIND v(dout1_91) AT=530.025n

.meas tran vdout1_92ck1050 FIND v(dout1_92) AT=530.025n

.meas tran vdout1_93ck1050 FIND v(dout1_93) AT=530.025n

.meas tran vdout1_94ck1050 FIND v(dout1_94) AT=530.025n

.meas tran vdout1_95ck1050 FIND v(dout1_95) AT=530.025n

.meas tran vdout1_96ck1050 FIND v(dout1_96) AT=530.025n

.meas tran vdout1_97ck1050 FIND v(dout1_97) AT=530.025n

.meas tran vdout1_98ck1050 FIND v(dout1_98) AT=530.025n

.meas tran vdout1_99ck1050 FIND v(dout1_99) AT=530.025n

.meas tran vdout1_100ck1050 FIND v(dout1_100) AT=530.025n

.meas tran vdout1_101ck1050 FIND v(dout1_101) AT=530.025n

.meas tran vdout1_102ck1050 FIND v(dout1_102) AT=530.025n

.meas tran vdout1_103ck1050 FIND v(dout1_103) AT=530.025n

.meas tran vdout1_104ck1050 FIND v(dout1_104) AT=530.025n

.meas tran vdout1_105ck1050 FIND v(dout1_105) AT=530.025n

.meas tran vdout1_106ck1050 FIND v(dout1_106) AT=530.025n

.meas tran vdout1_107ck1050 FIND v(dout1_107) AT=530.025n

.meas tran vdout1_108ck1050 FIND v(dout1_108) AT=530.025n

.meas tran vdout1_109ck1050 FIND v(dout1_109) AT=530.025n

.meas tran vdout1_110ck1050 FIND v(dout1_110) AT=530.025n

.meas tran vdout1_111ck1050 FIND v(dout1_111) AT=530.025n

.meas tran vdout1_112ck1050 FIND v(dout1_112) AT=530.025n

.meas tran vdout1_113ck1050 FIND v(dout1_113) AT=530.025n

.meas tran vdout1_114ck1050 FIND v(dout1_114) AT=530.025n

.meas tran vdout1_115ck1050 FIND v(dout1_115) AT=530.025n

.meas tran vdout1_116ck1050 FIND v(dout1_116) AT=530.025n

.meas tran vdout1_117ck1050 FIND v(dout1_117) AT=530.025n

.meas tran vdout1_118ck1050 FIND v(dout1_118) AT=530.025n

.meas tran vdout1_119ck1050 FIND v(dout1_119) AT=530.025n

.meas tran vdout1_120ck1050 FIND v(dout1_120) AT=530.025n

.meas tran vdout1_121ck1050 FIND v(dout1_121) AT=530.025n

.meas tran vdout1_122ck1050 FIND v(dout1_122) AT=530.025n

.meas tran vdout1_123ck1050 FIND v(dout1_123) AT=530.025n

.meas tran vdout1_124ck1050 FIND v(dout1_124) AT=530.025n

.meas tran vdout1_125ck1050 FIND v(dout1_125) AT=530.025n

.meas tran vdout1_126ck1050 FIND v(dout1_126) AT=530.025n

.meas tran vdout1_127ck1050 FIND v(dout1_127) AT=530.025n

.meas tran vdout1_0ck1090 FIND v(dout1_0) AT=550.025n

.meas tran vdout1_1ck1090 FIND v(dout1_1) AT=550.025n

.meas tran vdout1_2ck1090 FIND v(dout1_2) AT=550.025n

.meas tran vdout1_3ck1090 FIND v(dout1_3) AT=550.025n

.meas tran vdout1_4ck1090 FIND v(dout1_4) AT=550.025n

.meas tran vdout1_5ck1090 FIND v(dout1_5) AT=550.025n

.meas tran vdout1_6ck1090 FIND v(dout1_6) AT=550.025n

.meas tran vdout1_7ck1090 FIND v(dout1_7) AT=550.025n

.meas tran vdout1_8ck1090 FIND v(dout1_8) AT=550.025n

.meas tran vdout1_9ck1090 FIND v(dout1_9) AT=550.025n

.meas tran vdout1_10ck1090 FIND v(dout1_10) AT=550.025n

.meas tran vdout1_11ck1090 FIND v(dout1_11) AT=550.025n

.meas tran vdout1_12ck1090 FIND v(dout1_12) AT=550.025n

.meas tran vdout1_13ck1090 FIND v(dout1_13) AT=550.025n

.meas tran vdout1_14ck1090 FIND v(dout1_14) AT=550.025n

.meas tran vdout1_15ck1090 FIND v(dout1_15) AT=550.025n

.meas tran vdout1_16ck1090 FIND v(dout1_16) AT=550.025n

.meas tran vdout1_17ck1090 FIND v(dout1_17) AT=550.025n

.meas tran vdout1_18ck1090 FIND v(dout1_18) AT=550.025n

.meas tran vdout1_19ck1090 FIND v(dout1_19) AT=550.025n

.meas tran vdout1_20ck1090 FIND v(dout1_20) AT=550.025n

.meas tran vdout1_21ck1090 FIND v(dout1_21) AT=550.025n

.meas tran vdout1_22ck1090 FIND v(dout1_22) AT=550.025n

.meas tran vdout1_23ck1090 FIND v(dout1_23) AT=550.025n

.meas tran vdout1_24ck1090 FIND v(dout1_24) AT=550.025n

.meas tran vdout1_25ck1090 FIND v(dout1_25) AT=550.025n

.meas tran vdout1_26ck1090 FIND v(dout1_26) AT=550.025n

.meas tran vdout1_27ck1090 FIND v(dout1_27) AT=550.025n

.meas tran vdout1_28ck1090 FIND v(dout1_28) AT=550.025n

.meas tran vdout1_29ck1090 FIND v(dout1_29) AT=550.025n

.meas tran vdout1_30ck1090 FIND v(dout1_30) AT=550.025n

.meas tran vdout1_31ck1090 FIND v(dout1_31) AT=550.025n

.meas tran vdout1_32ck1090 FIND v(dout1_32) AT=550.025n

.meas tran vdout1_33ck1090 FIND v(dout1_33) AT=550.025n

.meas tran vdout1_34ck1090 FIND v(dout1_34) AT=550.025n

.meas tran vdout1_35ck1090 FIND v(dout1_35) AT=550.025n

.meas tran vdout1_36ck1090 FIND v(dout1_36) AT=550.025n

.meas tran vdout1_37ck1090 FIND v(dout1_37) AT=550.025n

.meas tran vdout1_38ck1090 FIND v(dout1_38) AT=550.025n

.meas tran vdout1_39ck1090 FIND v(dout1_39) AT=550.025n

.meas tran vdout1_40ck1090 FIND v(dout1_40) AT=550.025n

.meas tran vdout1_41ck1090 FIND v(dout1_41) AT=550.025n

.meas tran vdout1_42ck1090 FIND v(dout1_42) AT=550.025n

.meas tran vdout1_43ck1090 FIND v(dout1_43) AT=550.025n

.meas tran vdout1_44ck1090 FIND v(dout1_44) AT=550.025n

.meas tran vdout1_45ck1090 FIND v(dout1_45) AT=550.025n

.meas tran vdout1_46ck1090 FIND v(dout1_46) AT=550.025n

.meas tran vdout1_47ck1090 FIND v(dout1_47) AT=550.025n

.meas tran vdout1_48ck1090 FIND v(dout1_48) AT=550.025n

.meas tran vdout1_49ck1090 FIND v(dout1_49) AT=550.025n

.meas tran vdout1_50ck1090 FIND v(dout1_50) AT=550.025n

.meas tran vdout1_51ck1090 FIND v(dout1_51) AT=550.025n

.meas tran vdout1_52ck1090 FIND v(dout1_52) AT=550.025n

.meas tran vdout1_53ck1090 FIND v(dout1_53) AT=550.025n

.meas tran vdout1_54ck1090 FIND v(dout1_54) AT=550.025n

.meas tran vdout1_55ck1090 FIND v(dout1_55) AT=550.025n

.meas tran vdout1_56ck1090 FIND v(dout1_56) AT=550.025n

.meas tran vdout1_57ck1090 FIND v(dout1_57) AT=550.025n

.meas tran vdout1_58ck1090 FIND v(dout1_58) AT=550.025n

.meas tran vdout1_59ck1090 FIND v(dout1_59) AT=550.025n

.meas tran vdout1_60ck1090 FIND v(dout1_60) AT=550.025n

.meas tran vdout1_61ck1090 FIND v(dout1_61) AT=550.025n

.meas tran vdout1_62ck1090 FIND v(dout1_62) AT=550.025n

.meas tran vdout1_63ck1090 FIND v(dout1_63) AT=550.025n

.meas tran vdout1_64ck1090 FIND v(dout1_64) AT=550.025n

.meas tran vdout1_65ck1090 FIND v(dout1_65) AT=550.025n

.meas tran vdout1_66ck1090 FIND v(dout1_66) AT=550.025n

.meas tran vdout1_67ck1090 FIND v(dout1_67) AT=550.025n

.meas tran vdout1_68ck1090 FIND v(dout1_68) AT=550.025n

.meas tran vdout1_69ck1090 FIND v(dout1_69) AT=550.025n

.meas tran vdout1_70ck1090 FIND v(dout1_70) AT=550.025n

.meas tran vdout1_71ck1090 FIND v(dout1_71) AT=550.025n

.meas tran vdout1_72ck1090 FIND v(dout1_72) AT=550.025n

.meas tran vdout1_73ck1090 FIND v(dout1_73) AT=550.025n

.meas tran vdout1_74ck1090 FIND v(dout1_74) AT=550.025n

.meas tran vdout1_75ck1090 FIND v(dout1_75) AT=550.025n

.meas tran vdout1_76ck1090 FIND v(dout1_76) AT=550.025n

.meas tran vdout1_77ck1090 FIND v(dout1_77) AT=550.025n

.meas tran vdout1_78ck1090 FIND v(dout1_78) AT=550.025n

.meas tran vdout1_79ck1090 FIND v(dout1_79) AT=550.025n

.meas tran vdout1_80ck1090 FIND v(dout1_80) AT=550.025n

.meas tran vdout1_81ck1090 FIND v(dout1_81) AT=550.025n

.meas tran vdout1_82ck1090 FIND v(dout1_82) AT=550.025n

.meas tran vdout1_83ck1090 FIND v(dout1_83) AT=550.025n

.meas tran vdout1_84ck1090 FIND v(dout1_84) AT=550.025n

.meas tran vdout1_85ck1090 FIND v(dout1_85) AT=550.025n

.meas tran vdout1_86ck1090 FIND v(dout1_86) AT=550.025n

.meas tran vdout1_87ck1090 FIND v(dout1_87) AT=550.025n

.meas tran vdout1_88ck1090 FIND v(dout1_88) AT=550.025n

.meas tran vdout1_89ck1090 FIND v(dout1_89) AT=550.025n

.meas tran vdout1_90ck1090 FIND v(dout1_90) AT=550.025n

.meas tran vdout1_91ck1090 FIND v(dout1_91) AT=550.025n

.meas tran vdout1_92ck1090 FIND v(dout1_92) AT=550.025n

.meas tran vdout1_93ck1090 FIND v(dout1_93) AT=550.025n

.meas tran vdout1_94ck1090 FIND v(dout1_94) AT=550.025n

.meas tran vdout1_95ck1090 FIND v(dout1_95) AT=550.025n

.meas tran vdout1_96ck1090 FIND v(dout1_96) AT=550.025n

.meas tran vdout1_97ck1090 FIND v(dout1_97) AT=550.025n

.meas tran vdout1_98ck1090 FIND v(dout1_98) AT=550.025n

.meas tran vdout1_99ck1090 FIND v(dout1_99) AT=550.025n

.meas tran vdout1_100ck1090 FIND v(dout1_100) AT=550.025n

.meas tran vdout1_101ck1090 FIND v(dout1_101) AT=550.025n

.meas tran vdout1_102ck1090 FIND v(dout1_102) AT=550.025n

.meas tran vdout1_103ck1090 FIND v(dout1_103) AT=550.025n

.meas tran vdout1_104ck1090 FIND v(dout1_104) AT=550.025n

.meas tran vdout1_105ck1090 FIND v(dout1_105) AT=550.025n

.meas tran vdout1_106ck1090 FIND v(dout1_106) AT=550.025n

.meas tran vdout1_107ck1090 FIND v(dout1_107) AT=550.025n

.meas tran vdout1_108ck1090 FIND v(dout1_108) AT=550.025n

.meas tran vdout1_109ck1090 FIND v(dout1_109) AT=550.025n

.meas tran vdout1_110ck1090 FIND v(dout1_110) AT=550.025n

.meas tran vdout1_111ck1090 FIND v(dout1_111) AT=550.025n

.meas tran vdout1_112ck1090 FIND v(dout1_112) AT=550.025n

.meas tran vdout1_113ck1090 FIND v(dout1_113) AT=550.025n

.meas tran vdout1_114ck1090 FIND v(dout1_114) AT=550.025n

.meas tran vdout1_115ck1090 FIND v(dout1_115) AT=550.025n

.meas tran vdout1_116ck1090 FIND v(dout1_116) AT=550.025n

.meas tran vdout1_117ck1090 FIND v(dout1_117) AT=550.025n

.meas tran vdout1_118ck1090 FIND v(dout1_118) AT=550.025n

.meas tran vdout1_119ck1090 FIND v(dout1_119) AT=550.025n

.meas tran vdout1_120ck1090 FIND v(dout1_120) AT=550.025n

.meas tran vdout1_121ck1090 FIND v(dout1_121) AT=550.025n

.meas tran vdout1_122ck1090 FIND v(dout1_122) AT=550.025n

.meas tran vdout1_123ck1090 FIND v(dout1_123) AT=550.025n

.meas tran vdout1_124ck1090 FIND v(dout1_124) AT=550.025n

.meas tran vdout1_125ck1090 FIND v(dout1_125) AT=550.025n

.meas tran vdout1_126ck1090 FIND v(dout1_126) AT=550.025n

.meas tran vdout1_127ck1090 FIND v(dout1_127) AT=550.025n

.meas tran vdout1_0ck1120 FIND v(dout1_0) AT=565.025n

.meas tran vdout1_1ck1120 FIND v(dout1_1) AT=565.025n

.meas tran vdout1_2ck1120 FIND v(dout1_2) AT=565.025n

.meas tran vdout1_3ck1120 FIND v(dout1_3) AT=565.025n

.meas tran vdout1_4ck1120 FIND v(dout1_4) AT=565.025n

.meas tran vdout1_5ck1120 FIND v(dout1_5) AT=565.025n

.meas tran vdout1_6ck1120 FIND v(dout1_6) AT=565.025n

.meas tran vdout1_7ck1120 FIND v(dout1_7) AT=565.025n

.meas tran vdout1_8ck1120 FIND v(dout1_8) AT=565.025n

.meas tran vdout1_9ck1120 FIND v(dout1_9) AT=565.025n

.meas tran vdout1_10ck1120 FIND v(dout1_10) AT=565.025n

.meas tran vdout1_11ck1120 FIND v(dout1_11) AT=565.025n

.meas tran vdout1_12ck1120 FIND v(dout1_12) AT=565.025n

.meas tran vdout1_13ck1120 FIND v(dout1_13) AT=565.025n

.meas tran vdout1_14ck1120 FIND v(dout1_14) AT=565.025n

.meas tran vdout1_15ck1120 FIND v(dout1_15) AT=565.025n

.meas tran vdout1_16ck1120 FIND v(dout1_16) AT=565.025n

.meas tran vdout1_17ck1120 FIND v(dout1_17) AT=565.025n

.meas tran vdout1_18ck1120 FIND v(dout1_18) AT=565.025n

.meas tran vdout1_19ck1120 FIND v(dout1_19) AT=565.025n

.meas tran vdout1_20ck1120 FIND v(dout1_20) AT=565.025n

.meas tran vdout1_21ck1120 FIND v(dout1_21) AT=565.025n

.meas tran vdout1_22ck1120 FIND v(dout1_22) AT=565.025n

.meas tran vdout1_23ck1120 FIND v(dout1_23) AT=565.025n

.meas tran vdout1_24ck1120 FIND v(dout1_24) AT=565.025n

.meas tran vdout1_25ck1120 FIND v(dout1_25) AT=565.025n

.meas tran vdout1_26ck1120 FIND v(dout1_26) AT=565.025n

.meas tran vdout1_27ck1120 FIND v(dout1_27) AT=565.025n

.meas tran vdout1_28ck1120 FIND v(dout1_28) AT=565.025n

.meas tran vdout1_29ck1120 FIND v(dout1_29) AT=565.025n

.meas tran vdout1_30ck1120 FIND v(dout1_30) AT=565.025n

.meas tran vdout1_31ck1120 FIND v(dout1_31) AT=565.025n

.meas tran vdout1_32ck1120 FIND v(dout1_32) AT=565.025n

.meas tran vdout1_33ck1120 FIND v(dout1_33) AT=565.025n

.meas tran vdout1_34ck1120 FIND v(dout1_34) AT=565.025n

.meas tran vdout1_35ck1120 FIND v(dout1_35) AT=565.025n

.meas tran vdout1_36ck1120 FIND v(dout1_36) AT=565.025n

.meas tran vdout1_37ck1120 FIND v(dout1_37) AT=565.025n

.meas tran vdout1_38ck1120 FIND v(dout1_38) AT=565.025n

.meas tran vdout1_39ck1120 FIND v(dout1_39) AT=565.025n

.meas tran vdout1_40ck1120 FIND v(dout1_40) AT=565.025n

.meas tran vdout1_41ck1120 FIND v(dout1_41) AT=565.025n

.meas tran vdout1_42ck1120 FIND v(dout1_42) AT=565.025n

.meas tran vdout1_43ck1120 FIND v(dout1_43) AT=565.025n

.meas tran vdout1_44ck1120 FIND v(dout1_44) AT=565.025n

.meas tran vdout1_45ck1120 FIND v(dout1_45) AT=565.025n

.meas tran vdout1_46ck1120 FIND v(dout1_46) AT=565.025n

.meas tran vdout1_47ck1120 FIND v(dout1_47) AT=565.025n

.meas tran vdout1_48ck1120 FIND v(dout1_48) AT=565.025n

.meas tran vdout1_49ck1120 FIND v(dout1_49) AT=565.025n

.meas tran vdout1_50ck1120 FIND v(dout1_50) AT=565.025n

.meas tran vdout1_51ck1120 FIND v(dout1_51) AT=565.025n

.meas tran vdout1_52ck1120 FIND v(dout1_52) AT=565.025n

.meas tran vdout1_53ck1120 FIND v(dout1_53) AT=565.025n

.meas tran vdout1_54ck1120 FIND v(dout1_54) AT=565.025n

.meas tran vdout1_55ck1120 FIND v(dout1_55) AT=565.025n

.meas tran vdout1_56ck1120 FIND v(dout1_56) AT=565.025n

.meas tran vdout1_57ck1120 FIND v(dout1_57) AT=565.025n

.meas tran vdout1_58ck1120 FIND v(dout1_58) AT=565.025n

.meas tran vdout1_59ck1120 FIND v(dout1_59) AT=565.025n

.meas tran vdout1_60ck1120 FIND v(dout1_60) AT=565.025n

.meas tran vdout1_61ck1120 FIND v(dout1_61) AT=565.025n

.meas tran vdout1_62ck1120 FIND v(dout1_62) AT=565.025n

.meas tran vdout1_63ck1120 FIND v(dout1_63) AT=565.025n

.meas tran vdout1_64ck1120 FIND v(dout1_64) AT=565.025n

.meas tran vdout1_65ck1120 FIND v(dout1_65) AT=565.025n

.meas tran vdout1_66ck1120 FIND v(dout1_66) AT=565.025n

.meas tran vdout1_67ck1120 FIND v(dout1_67) AT=565.025n

.meas tran vdout1_68ck1120 FIND v(dout1_68) AT=565.025n

.meas tran vdout1_69ck1120 FIND v(dout1_69) AT=565.025n

.meas tran vdout1_70ck1120 FIND v(dout1_70) AT=565.025n

.meas tran vdout1_71ck1120 FIND v(dout1_71) AT=565.025n

.meas tran vdout1_72ck1120 FIND v(dout1_72) AT=565.025n

.meas tran vdout1_73ck1120 FIND v(dout1_73) AT=565.025n

.meas tran vdout1_74ck1120 FIND v(dout1_74) AT=565.025n

.meas tran vdout1_75ck1120 FIND v(dout1_75) AT=565.025n

.meas tran vdout1_76ck1120 FIND v(dout1_76) AT=565.025n

.meas tran vdout1_77ck1120 FIND v(dout1_77) AT=565.025n

.meas tran vdout1_78ck1120 FIND v(dout1_78) AT=565.025n

.meas tran vdout1_79ck1120 FIND v(dout1_79) AT=565.025n

.meas tran vdout1_80ck1120 FIND v(dout1_80) AT=565.025n

.meas tran vdout1_81ck1120 FIND v(dout1_81) AT=565.025n

.meas tran vdout1_82ck1120 FIND v(dout1_82) AT=565.025n

.meas tran vdout1_83ck1120 FIND v(dout1_83) AT=565.025n

.meas tran vdout1_84ck1120 FIND v(dout1_84) AT=565.025n

.meas tran vdout1_85ck1120 FIND v(dout1_85) AT=565.025n

.meas tran vdout1_86ck1120 FIND v(dout1_86) AT=565.025n

.meas tran vdout1_87ck1120 FIND v(dout1_87) AT=565.025n

.meas tran vdout1_88ck1120 FIND v(dout1_88) AT=565.025n

.meas tran vdout1_89ck1120 FIND v(dout1_89) AT=565.025n

.meas tran vdout1_90ck1120 FIND v(dout1_90) AT=565.025n

.meas tran vdout1_91ck1120 FIND v(dout1_91) AT=565.025n

.meas tran vdout1_92ck1120 FIND v(dout1_92) AT=565.025n

.meas tran vdout1_93ck1120 FIND v(dout1_93) AT=565.025n

.meas tran vdout1_94ck1120 FIND v(dout1_94) AT=565.025n

.meas tran vdout1_95ck1120 FIND v(dout1_95) AT=565.025n

.meas tran vdout1_96ck1120 FIND v(dout1_96) AT=565.025n

.meas tran vdout1_97ck1120 FIND v(dout1_97) AT=565.025n

.meas tran vdout1_98ck1120 FIND v(dout1_98) AT=565.025n

.meas tran vdout1_99ck1120 FIND v(dout1_99) AT=565.025n

.meas tran vdout1_100ck1120 FIND v(dout1_100) AT=565.025n

.meas tran vdout1_101ck1120 FIND v(dout1_101) AT=565.025n

.meas tran vdout1_102ck1120 FIND v(dout1_102) AT=565.025n

.meas tran vdout1_103ck1120 FIND v(dout1_103) AT=565.025n

.meas tran vdout1_104ck1120 FIND v(dout1_104) AT=565.025n

.meas tran vdout1_105ck1120 FIND v(dout1_105) AT=565.025n

.meas tran vdout1_106ck1120 FIND v(dout1_106) AT=565.025n

.meas tran vdout1_107ck1120 FIND v(dout1_107) AT=565.025n

.meas tran vdout1_108ck1120 FIND v(dout1_108) AT=565.025n

.meas tran vdout1_109ck1120 FIND v(dout1_109) AT=565.025n

.meas tran vdout1_110ck1120 FIND v(dout1_110) AT=565.025n

.meas tran vdout1_111ck1120 FIND v(dout1_111) AT=565.025n

.meas tran vdout1_112ck1120 FIND v(dout1_112) AT=565.025n

.meas tran vdout1_113ck1120 FIND v(dout1_113) AT=565.025n

.meas tran vdout1_114ck1120 FIND v(dout1_114) AT=565.025n

.meas tran vdout1_115ck1120 FIND v(dout1_115) AT=565.025n

.meas tran vdout1_116ck1120 FIND v(dout1_116) AT=565.025n

.meas tran vdout1_117ck1120 FIND v(dout1_117) AT=565.025n

.meas tran vdout1_118ck1120 FIND v(dout1_118) AT=565.025n

.meas tran vdout1_119ck1120 FIND v(dout1_119) AT=565.025n

.meas tran vdout1_120ck1120 FIND v(dout1_120) AT=565.025n

.meas tran vdout1_121ck1120 FIND v(dout1_121) AT=565.025n

.meas tran vdout1_122ck1120 FIND v(dout1_122) AT=565.025n

.meas tran vdout1_123ck1120 FIND v(dout1_123) AT=565.025n

.meas tran vdout1_124ck1120 FIND v(dout1_124) AT=565.025n

.meas tran vdout1_125ck1120 FIND v(dout1_125) AT=565.025n

.meas tran vdout1_126ck1120 FIND v(dout1_126) AT=565.025n

.meas tran vdout1_127ck1120 FIND v(dout1_127) AT=565.025n

.meas tran vdout1_0ck1200 FIND v(dout1_0) AT=605.025n

.meas tran vdout1_1ck1200 FIND v(dout1_1) AT=605.025n

.meas tran vdout1_2ck1200 FIND v(dout1_2) AT=605.025n

.meas tran vdout1_3ck1200 FIND v(dout1_3) AT=605.025n

.meas tran vdout1_4ck1200 FIND v(dout1_4) AT=605.025n

.meas tran vdout1_5ck1200 FIND v(dout1_5) AT=605.025n

.meas tran vdout1_6ck1200 FIND v(dout1_6) AT=605.025n

.meas tran vdout1_7ck1200 FIND v(dout1_7) AT=605.025n

.meas tran vdout1_8ck1200 FIND v(dout1_8) AT=605.025n

.meas tran vdout1_9ck1200 FIND v(dout1_9) AT=605.025n

.meas tran vdout1_10ck1200 FIND v(dout1_10) AT=605.025n

.meas tran vdout1_11ck1200 FIND v(dout1_11) AT=605.025n

.meas tran vdout1_12ck1200 FIND v(dout1_12) AT=605.025n

.meas tran vdout1_13ck1200 FIND v(dout1_13) AT=605.025n

.meas tran vdout1_14ck1200 FIND v(dout1_14) AT=605.025n

.meas tran vdout1_15ck1200 FIND v(dout1_15) AT=605.025n

.meas tran vdout1_16ck1200 FIND v(dout1_16) AT=605.025n

.meas tran vdout1_17ck1200 FIND v(dout1_17) AT=605.025n

.meas tran vdout1_18ck1200 FIND v(dout1_18) AT=605.025n

.meas tran vdout1_19ck1200 FIND v(dout1_19) AT=605.025n

.meas tran vdout1_20ck1200 FIND v(dout1_20) AT=605.025n

.meas tran vdout1_21ck1200 FIND v(dout1_21) AT=605.025n

.meas tran vdout1_22ck1200 FIND v(dout1_22) AT=605.025n

.meas tran vdout1_23ck1200 FIND v(dout1_23) AT=605.025n

.meas tran vdout1_24ck1200 FIND v(dout1_24) AT=605.025n

.meas tran vdout1_25ck1200 FIND v(dout1_25) AT=605.025n

.meas tran vdout1_26ck1200 FIND v(dout1_26) AT=605.025n

.meas tran vdout1_27ck1200 FIND v(dout1_27) AT=605.025n

.meas tran vdout1_28ck1200 FIND v(dout1_28) AT=605.025n

.meas tran vdout1_29ck1200 FIND v(dout1_29) AT=605.025n

.meas tran vdout1_30ck1200 FIND v(dout1_30) AT=605.025n

.meas tran vdout1_31ck1200 FIND v(dout1_31) AT=605.025n

.meas tran vdout1_32ck1200 FIND v(dout1_32) AT=605.025n

.meas tran vdout1_33ck1200 FIND v(dout1_33) AT=605.025n

.meas tran vdout1_34ck1200 FIND v(dout1_34) AT=605.025n

.meas tran vdout1_35ck1200 FIND v(dout1_35) AT=605.025n

.meas tran vdout1_36ck1200 FIND v(dout1_36) AT=605.025n

.meas tran vdout1_37ck1200 FIND v(dout1_37) AT=605.025n

.meas tran vdout1_38ck1200 FIND v(dout1_38) AT=605.025n

.meas tran vdout1_39ck1200 FIND v(dout1_39) AT=605.025n

.meas tran vdout1_40ck1200 FIND v(dout1_40) AT=605.025n

.meas tran vdout1_41ck1200 FIND v(dout1_41) AT=605.025n

.meas tran vdout1_42ck1200 FIND v(dout1_42) AT=605.025n

.meas tran vdout1_43ck1200 FIND v(dout1_43) AT=605.025n

.meas tran vdout1_44ck1200 FIND v(dout1_44) AT=605.025n

.meas tran vdout1_45ck1200 FIND v(dout1_45) AT=605.025n

.meas tran vdout1_46ck1200 FIND v(dout1_46) AT=605.025n

.meas tran vdout1_47ck1200 FIND v(dout1_47) AT=605.025n

.meas tran vdout1_48ck1200 FIND v(dout1_48) AT=605.025n

.meas tran vdout1_49ck1200 FIND v(dout1_49) AT=605.025n

.meas tran vdout1_50ck1200 FIND v(dout1_50) AT=605.025n

.meas tran vdout1_51ck1200 FIND v(dout1_51) AT=605.025n

.meas tran vdout1_52ck1200 FIND v(dout1_52) AT=605.025n

.meas tran vdout1_53ck1200 FIND v(dout1_53) AT=605.025n

.meas tran vdout1_54ck1200 FIND v(dout1_54) AT=605.025n

.meas tran vdout1_55ck1200 FIND v(dout1_55) AT=605.025n

.meas tran vdout1_56ck1200 FIND v(dout1_56) AT=605.025n

.meas tran vdout1_57ck1200 FIND v(dout1_57) AT=605.025n

.meas tran vdout1_58ck1200 FIND v(dout1_58) AT=605.025n

.meas tran vdout1_59ck1200 FIND v(dout1_59) AT=605.025n

.meas tran vdout1_60ck1200 FIND v(dout1_60) AT=605.025n

.meas tran vdout1_61ck1200 FIND v(dout1_61) AT=605.025n

.meas tran vdout1_62ck1200 FIND v(dout1_62) AT=605.025n

.meas tran vdout1_63ck1200 FIND v(dout1_63) AT=605.025n

.meas tran vdout1_64ck1200 FIND v(dout1_64) AT=605.025n

.meas tran vdout1_65ck1200 FIND v(dout1_65) AT=605.025n

.meas tran vdout1_66ck1200 FIND v(dout1_66) AT=605.025n

.meas tran vdout1_67ck1200 FIND v(dout1_67) AT=605.025n

.meas tran vdout1_68ck1200 FIND v(dout1_68) AT=605.025n

.meas tran vdout1_69ck1200 FIND v(dout1_69) AT=605.025n

.meas tran vdout1_70ck1200 FIND v(dout1_70) AT=605.025n

.meas tran vdout1_71ck1200 FIND v(dout1_71) AT=605.025n

.meas tran vdout1_72ck1200 FIND v(dout1_72) AT=605.025n

.meas tran vdout1_73ck1200 FIND v(dout1_73) AT=605.025n

.meas tran vdout1_74ck1200 FIND v(dout1_74) AT=605.025n

.meas tran vdout1_75ck1200 FIND v(dout1_75) AT=605.025n

.meas tran vdout1_76ck1200 FIND v(dout1_76) AT=605.025n

.meas tran vdout1_77ck1200 FIND v(dout1_77) AT=605.025n

.meas tran vdout1_78ck1200 FIND v(dout1_78) AT=605.025n

.meas tran vdout1_79ck1200 FIND v(dout1_79) AT=605.025n

.meas tran vdout1_80ck1200 FIND v(dout1_80) AT=605.025n

.meas tran vdout1_81ck1200 FIND v(dout1_81) AT=605.025n

.meas tran vdout1_82ck1200 FIND v(dout1_82) AT=605.025n

.meas tran vdout1_83ck1200 FIND v(dout1_83) AT=605.025n

.meas tran vdout1_84ck1200 FIND v(dout1_84) AT=605.025n

.meas tran vdout1_85ck1200 FIND v(dout1_85) AT=605.025n

.meas tran vdout1_86ck1200 FIND v(dout1_86) AT=605.025n

.meas tran vdout1_87ck1200 FIND v(dout1_87) AT=605.025n

.meas tran vdout1_88ck1200 FIND v(dout1_88) AT=605.025n

.meas tran vdout1_89ck1200 FIND v(dout1_89) AT=605.025n

.meas tran vdout1_90ck1200 FIND v(dout1_90) AT=605.025n

.meas tran vdout1_91ck1200 FIND v(dout1_91) AT=605.025n

.meas tran vdout1_92ck1200 FIND v(dout1_92) AT=605.025n

.meas tran vdout1_93ck1200 FIND v(dout1_93) AT=605.025n

.meas tran vdout1_94ck1200 FIND v(dout1_94) AT=605.025n

.meas tran vdout1_95ck1200 FIND v(dout1_95) AT=605.025n

.meas tran vdout1_96ck1200 FIND v(dout1_96) AT=605.025n

.meas tran vdout1_97ck1200 FIND v(dout1_97) AT=605.025n

.meas tran vdout1_98ck1200 FIND v(dout1_98) AT=605.025n

.meas tran vdout1_99ck1200 FIND v(dout1_99) AT=605.025n

.meas tran vdout1_100ck1200 FIND v(dout1_100) AT=605.025n

.meas tran vdout1_101ck1200 FIND v(dout1_101) AT=605.025n

.meas tran vdout1_102ck1200 FIND v(dout1_102) AT=605.025n

.meas tran vdout1_103ck1200 FIND v(dout1_103) AT=605.025n

.meas tran vdout1_104ck1200 FIND v(dout1_104) AT=605.025n

.meas tran vdout1_105ck1200 FIND v(dout1_105) AT=605.025n

.meas tran vdout1_106ck1200 FIND v(dout1_106) AT=605.025n

.meas tran vdout1_107ck1200 FIND v(dout1_107) AT=605.025n

.meas tran vdout1_108ck1200 FIND v(dout1_108) AT=605.025n

.meas tran vdout1_109ck1200 FIND v(dout1_109) AT=605.025n

.meas tran vdout1_110ck1200 FIND v(dout1_110) AT=605.025n

.meas tran vdout1_111ck1200 FIND v(dout1_111) AT=605.025n

.meas tran vdout1_112ck1200 FIND v(dout1_112) AT=605.025n

.meas tran vdout1_113ck1200 FIND v(dout1_113) AT=605.025n

.meas tran vdout1_114ck1200 FIND v(dout1_114) AT=605.025n

.meas tran vdout1_115ck1200 FIND v(dout1_115) AT=605.025n

.meas tran vdout1_116ck1200 FIND v(dout1_116) AT=605.025n

.meas tran vdout1_117ck1200 FIND v(dout1_117) AT=605.025n

.meas tran vdout1_118ck1200 FIND v(dout1_118) AT=605.025n

.meas tran vdout1_119ck1200 FIND v(dout1_119) AT=605.025n

.meas tran vdout1_120ck1200 FIND v(dout1_120) AT=605.025n

.meas tran vdout1_121ck1200 FIND v(dout1_121) AT=605.025n

.meas tran vdout1_122ck1200 FIND v(dout1_122) AT=605.025n

.meas tran vdout1_123ck1200 FIND v(dout1_123) AT=605.025n

.meas tran vdout1_124ck1200 FIND v(dout1_124) AT=605.025n

.meas tran vdout1_125ck1200 FIND v(dout1_125) AT=605.025n

.meas tran vdout1_126ck1200 FIND v(dout1_126) AT=605.025n

.meas tran vdout1_127ck1200 FIND v(dout1_127) AT=605.025n

.meas tran vdout1_0ck1210 FIND v(dout1_0) AT=610.025n

.meas tran vdout1_1ck1210 FIND v(dout1_1) AT=610.025n

.meas tran vdout1_2ck1210 FIND v(dout1_2) AT=610.025n

.meas tran vdout1_3ck1210 FIND v(dout1_3) AT=610.025n

.meas tran vdout1_4ck1210 FIND v(dout1_4) AT=610.025n

.meas tran vdout1_5ck1210 FIND v(dout1_5) AT=610.025n

.meas tran vdout1_6ck1210 FIND v(dout1_6) AT=610.025n

.meas tran vdout1_7ck1210 FIND v(dout1_7) AT=610.025n

.meas tran vdout1_8ck1210 FIND v(dout1_8) AT=610.025n

.meas tran vdout1_9ck1210 FIND v(dout1_9) AT=610.025n

.meas tran vdout1_10ck1210 FIND v(dout1_10) AT=610.025n

.meas tran vdout1_11ck1210 FIND v(dout1_11) AT=610.025n

.meas tran vdout1_12ck1210 FIND v(dout1_12) AT=610.025n

.meas tran vdout1_13ck1210 FIND v(dout1_13) AT=610.025n

.meas tran vdout1_14ck1210 FIND v(dout1_14) AT=610.025n

.meas tran vdout1_15ck1210 FIND v(dout1_15) AT=610.025n

.meas tran vdout1_16ck1210 FIND v(dout1_16) AT=610.025n

.meas tran vdout1_17ck1210 FIND v(dout1_17) AT=610.025n

.meas tran vdout1_18ck1210 FIND v(dout1_18) AT=610.025n

.meas tran vdout1_19ck1210 FIND v(dout1_19) AT=610.025n

.meas tran vdout1_20ck1210 FIND v(dout1_20) AT=610.025n

.meas tran vdout1_21ck1210 FIND v(dout1_21) AT=610.025n

.meas tran vdout1_22ck1210 FIND v(dout1_22) AT=610.025n

.meas tran vdout1_23ck1210 FIND v(dout1_23) AT=610.025n

.meas tran vdout1_24ck1210 FIND v(dout1_24) AT=610.025n

.meas tran vdout1_25ck1210 FIND v(dout1_25) AT=610.025n

.meas tran vdout1_26ck1210 FIND v(dout1_26) AT=610.025n

.meas tran vdout1_27ck1210 FIND v(dout1_27) AT=610.025n

.meas tran vdout1_28ck1210 FIND v(dout1_28) AT=610.025n

.meas tran vdout1_29ck1210 FIND v(dout1_29) AT=610.025n

.meas tran vdout1_30ck1210 FIND v(dout1_30) AT=610.025n

.meas tran vdout1_31ck1210 FIND v(dout1_31) AT=610.025n

.meas tran vdout1_32ck1210 FIND v(dout1_32) AT=610.025n

.meas tran vdout1_33ck1210 FIND v(dout1_33) AT=610.025n

.meas tran vdout1_34ck1210 FIND v(dout1_34) AT=610.025n

.meas tran vdout1_35ck1210 FIND v(dout1_35) AT=610.025n

.meas tran vdout1_36ck1210 FIND v(dout1_36) AT=610.025n

.meas tran vdout1_37ck1210 FIND v(dout1_37) AT=610.025n

.meas tran vdout1_38ck1210 FIND v(dout1_38) AT=610.025n

.meas tran vdout1_39ck1210 FIND v(dout1_39) AT=610.025n

.meas tran vdout1_40ck1210 FIND v(dout1_40) AT=610.025n

.meas tran vdout1_41ck1210 FIND v(dout1_41) AT=610.025n

.meas tran vdout1_42ck1210 FIND v(dout1_42) AT=610.025n

.meas tran vdout1_43ck1210 FIND v(dout1_43) AT=610.025n

.meas tran vdout1_44ck1210 FIND v(dout1_44) AT=610.025n

.meas tran vdout1_45ck1210 FIND v(dout1_45) AT=610.025n

.meas tran vdout1_46ck1210 FIND v(dout1_46) AT=610.025n

.meas tran vdout1_47ck1210 FIND v(dout1_47) AT=610.025n

.meas tran vdout1_48ck1210 FIND v(dout1_48) AT=610.025n

.meas tran vdout1_49ck1210 FIND v(dout1_49) AT=610.025n

.meas tran vdout1_50ck1210 FIND v(dout1_50) AT=610.025n

.meas tran vdout1_51ck1210 FIND v(dout1_51) AT=610.025n

.meas tran vdout1_52ck1210 FIND v(dout1_52) AT=610.025n

.meas tran vdout1_53ck1210 FIND v(dout1_53) AT=610.025n

.meas tran vdout1_54ck1210 FIND v(dout1_54) AT=610.025n

.meas tran vdout1_55ck1210 FIND v(dout1_55) AT=610.025n

.meas tran vdout1_56ck1210 FIND v(dout1_56) AT=610.025n

.meas tran vdout1_57ck1210 FIND v(dout1_57) AT=610.025n

.meas tran vdout1_58ck1210 FIND v(dout1_58) AT=610.025n

.meas tran vdout1_59ck1210 FIND v(dout1_59) AT=610.025n

.meas tran vdout1_60ck1210 FIND v(dout1_60) AT=610.025n

.meas tran vdout1_61ck1210 FIND v(dout1_61) AT=610.025n

.meas tran vdout1_62ck1210 FIND v(dout1_62) AT=610.025n

.meas tran vdout1_63ck1210 FIND v(dout1_63) AT=610.025n

.meas tran vdout1_64ck1210 FIND v(dout1_64) AT=610.025n

.meas tran vdout1_65ck1210 FIND v(dout1_65) AT=610.025n

.meas tran vdout1_66ck1210 FIND v(dout1_66) AT=610.025n

.meas tran vdout1_67ck1210 FIND v(dout1_67) AT=610.025n

.meas tran vdout1_68ck1210 FIND v(dout1_68) AT=610.025n

.meas tran vdout1_69ck1210 FIND v(dout1_69) AT=610.025n

.meas tran vdout1_70ck1210 FIND v(dout1_70) AT=610.025n

.meas tran vdout1_71ck1210 FIND v(dout1_71) AT=610.025n

.meas tran vdout1_72ck1210 FIND v(dout1_72) AT=610.025n

.meas tran vdout1_73ck1210 FIND v(dout1_73) AT=610.025n

.meas tran vdout1_74ck1210 FIND v(dout1_74) AT=610.025n

.meas tran vdout1_75ck1210 FIND v(dout1_75) AT=610.025n

.meas tran vdout1_76ck1210 FIND v(dout1_76) AT=610.025n

.meas tran vdout1_77ck1210 FIND v(dout1_77) AT=610.025n

.meas tran vdout1_78ck1210 FIND v(dout1_78) AT=610.025n

.meas tran vdout1_79ck1210 FIND v(dout1_79) AT=610.025n

.meas tran vdout1_80ck1210 FIND v(dout1_80) AT=610.025n

.meas tran vdout1_81ck1210 FIND v(dout1_81) AT=610.025n

.meas tran vdout1_82ck1210 FIND v(dout1_82) AT=610.025n

.meas tran vdout1_83ck1210 FIND v(dout1_83) AT=610.025n

.meas tran vdout1_84ck1210 FIND v(dout1_84) AT=610.025n

.meas tran vdout1_85ck1210 FIND v(dout1_85) AT=610.025n

.meas tran vdout1_86ck1210 FIND v(dout1_86) AT=610.025n

.meas tran vdout1_87ck1210 FIND v(dout1_87) AT=610.025n

.meas tran vdout1_88ck1210 FIND v(dout1_88) AT=610.025n

.meas tran vdout1_89ck1210 FIND v(dout1_89) AT=610.025n

.meas tran vdout1_90ck1210 FIND v(dout1_90) AT=610.025n

.meas tran vdout1_91ck1210 FIND v(dout1_91) AT=610.025n

.meas tran vdout1_92ck1210 FIND v(dout1_92) AT=610.025n

.meas tran vdout1_93ck1210 FIND v(dout1_93) AT=610.025n

.meas tran vdout1_94ck1210 FIND v(dout1_94) AT=610.025n

.meas tran vdout1_95ck1210 FIND v(dout1_95) AT=610.025n

.meas tran vdout1_96ck1210 FIND v(dout1_96) AT=610.025n

.meas tran vdout1_97ck1210 FIND v(dout1_97) AT=610.025n

.meas tran vdout1_98ck1210 FIND v(dout1_98) AT=610.025n

.meas tran vdout1_99ck1210 FIND v(dout1_99) AT=610.025n

.meas tran vdout1_100ck1210 FIND v(dout1_100) AT=610.025n

.meas tran vdout1_101ck1210 FIND v(dout1_101) AT=610.025n

.meas tran vdout1_102ck1210 FIND v(dout1_102) AT=610.025n

.meas tran vdout1_103ck1210 FIND v(dout1_103) AT=610.025n

.meas tran vdout1_104ck1210 FIND v(dout1_104) AT=610.025n

.meas tran vdout1_105ck1210 FIND v(dout1_105) AT=610.025n

.meas tran vdout1_106ck1210 FIND v(dout1_106) AT=610.025n

.meas tran vdout1_107ck1210 FIND v(dout1_107) AT=610.025n

.meas tran vdout1_108ck1210 FIND v(dout1_108) AT=610.025n

.meas tran vdout1_109ck1210 FIND v(dout1_109) AT=610.025n

.meas tran vdout1_110ck1210 FIND v(dout1_110) AT=610.025n

.meas tran vdout1_111ck1210 FIND v(dout1_111) AT=610.025n

.meas tran vdout1_112ck1210 FIND v(dout1_112) AT=610.025n

.meas tran vdout1_113ck1210 FIND v(dout1_113) AT=610.025n

.meas tran vdout1_114ck1210 FIND v(dout1_114) AT=610.025n

.meas tran vdout1_115ck1210 FIND v(dout1_115) AT=610.025n

.meas tran vdout1_116ck1210 FIND v(dout1_116) AT=610.025n

.meas tran vdout1_117ck1210 FIND v(dout1_117) AT=610.025n

.meas tran vdout1_118ck1210 FIND v(dout1_118) AT=610.025n

.meas tran vdout1_119ck1210 FIND v(dout1_119) AT=610.025n

.meas tran vdout1_120ck1210 FIND v(dout1_120) AT=610.025n

.meas tran vdout1_121ck1210 FIND v(dout1_121) AT=610.025n

.meas tran vdout1_122ck1210 FIND v(dout1_122) AT=610.025n

.meas tran vdout1_123ck1210 FIND v(dout1_123) AT=610.025n

.meas tran vdout1_124ck1210 FIND v(dout1_124) AT=610.025n

.meas tran vdout1_125ck1210 FIND v(dout1_125) AT=610.025n

.meas tran vdout1_126ck1210 FIND v(dout1_126) AT=610.025n

.meas tran vdout1_127ck1210 FIND v(dout1_127) AT=610.025n

.meas tran vdout1_0ck1220 FIND v(dout1_0) AT=615.025n

.meas tran vdout1_1ck1220 FIND v(dout1_1) AT=615.025n

.meas tran vdout1_2ck1220 FIND v(dout1_2) AT=615.025n

.meas tran vdout1_3ck1220 FIND v(dout1_3) AT=615.025n

.meas tran vdout1_4ck1220 FIND v(dout1_4) AT=615.025n

.meas tran vdout1_5ck1220 FIND v(dout1_5) AT=615.025n

.meas tran vdout1_6ck1220 FIND v(dout1_6) AT=615.025n

.meas tran vdout1_7ck1220 FIND v(dout1_7) AT=615.025n

.meas tran vdout1_8ck1220 FIND v(dout1_8) AT=615.025n

.meas tran vdout1_9ck1220 FIND v(dout1_9) AT=615.025n

.meas tran vdout1_10ck1220 FIND v(dout1_10) AT=615.025n

.meas tran vdout1_11ck1220 FIND v(dout1_11) AT=615.025n

.meas tran vdout1_12ck1220 FIND v(dout1_12) AT=615.025n

.meas tran vdout1_13ck1220 FIND v(dout1_13) AT=615.025n

.meas tran vdout1_14ck1220 FIND v(dout1_14) AT=615.025n

.meas tran vdout1_15ck1220 FIND v(dout1_15) AT=615.025n

.meas tran vdout1_16ck1220 FIND v(dout1_16) AT=615.025n

.meas tran vdout1_17ck1220 FIND v(dout1_17) AT=615.025n

.meas tran vdout1_18ck1220 FIND v(dout1_18) AT=615.025n

.meas tran vdout1_19ck1220 FIND v(dout1_19) AT=615.025n

.meas tran vdout1_20ck1220 FIND v(dout1_20) AT=615.025n

.meas tran vdout1_21ck1220 FIND v(dout1_21) AT=615.025n

.meas tran vdout1_22ck1220 FIND v(dout1_22) AT=615.025n

.meas tran vdout1_23ck1220 FIND v(dout1_23) AT=615.025n

.meas tran vdout1_24ck1220 FIND v(dout1_24) AT=615.025n

.meas tran vdout1_25ck1220 FIND v(dout1_25) AT=615.025n

.meas tran vdout1_26ck1220 FIND v(dout1_26) AT=615.025n

.meas tran vdout1_27ck1220 FIND v(dout1_27) AT=615.025n

.meas tran vdout1_28ck1220 FIND v(dout1_28) AT=615.025n

.meas tran vdout1_29ck1220 FIND v(dout1_29) AT=615.025n

.meas tran vdout1_30ck1220 FIND v(dout1_30) AT=615.025n

.meas tran vdout1_31ck1220 FIND v(dout1_31) AT=615.025n

.meas tran vdout1_32ck1220 FIND v(dout1_32) AT=615.025n

.meas tran vdout1_33ck1220 FIND v(dout1_33) AT=615.025n

.meas tran vdout1_34ck1220 FIND v(dout1_34) AT=615.025n

.meas tran vdout1_35ck1220 FIND v(dout1_35) AT=615.025n

.meas tran vdout1_36ck1220 FIND v(dout1_36) AT=615.025n

.meas tran vdout1_37ck1220 FIND v(dout1_37) AT=615.025n

.meas tran vdout1_38ck1220 FIND v(dout1_38) AT=615.025n

.meas tran vdout1_39ck1220 FIND v(dout1_39) AT=615.025n

.meas tran vdout1_40ck1220 FIND v(dout1_40) AT=615.025n

.meas tran vdout1_41ck1220 FIND v(dout1_41) AT=615.025n

.meas tran vdout1_42ck1220 FIND v(dout1_42) AT=615.025n

.meas tran vdout1_43ck1220 FIND v(dout1_43) AT=615.025n

.meas tran vdout1_44ck1220 FIND v(dout1_44) AT=615.025n

.meas tran vdout1_45ck1220 FIND v(dout1_45) AT=615.025n

.meas tran vdout1_46ck1220 FIND v(dout1_46) AT=615.025n

.meas tran vdout1_47ck1220 FIND v(dout1_47) AT=615.025n

.meas tran vdout1_48ck1220 FIND v(dout1_48) AT=615.025n

.meas tran vdout1_49ck1220 FIND v(dout1_49) AT=615.025n

.meas tran vdout1_50ck1220 FIND v(dout1_50) AT=615.025n

.meas tran vdout1_51ck1220 FIND v(dout1_51) AT=615.025n

.meas tran vdout1_52ck1220 FIND v(dout1_52) AT=615.025n

.meas tran vdout1_53ck1220 FIND v(dout1_53) AT=615.025n

.meas tran vdout1_54ck1220 FIND v(dout1_54) AT=615.025n

.meas tran vdout1_55ck1220 FIND v(dout1_55) AT=615.025n

.meas tran vdout1_56ck1220 FIND v(dout1_56) AT=615.025n

.meas tran vdout1_57ck1220 FIND v(dout1_57) AT=615.025n

.meas tran vdout1_58ck1220 FIND v(dout1_58) AT=615.025n

.meas tran vdout1_59ck1220 FIND v(dout1_59) AT=615.025n

.meas tran vdout1_60ck1220 FIND v(dout1_60) AT=615.025n

.meas tran vdout1_61ck1220 FIND v(dout1_61) AT=615.025n

.meas tran vdout1_62ck1220 FIND v(dout1_62) AT=615.025n

.meas tran vdout1_63ck1220 FIND v(dout1_63) AT=615.025n

.meas tran vdout1_64ck1220 FIND v(dout1_64) AT=615.025n

.meas tran vdout1_65ck1220 FIND v(dout1_65) AT=615.025n

.meas tran vdout1_66ck1220 FIND v(dout1_66) AT=615.025n

.meas tran vdout1_67ck1220 FIND v(dout1_67) AT=615.025n

.meas tran vdout1_68ck1220 FIND v(dout1_68) AT=615.025n

.meas tran vdout1_69ck1220 FIND v(dout1_69) AT=615.025n

.meas tran vdout1_70ck1220 FIND v(dout1_70) AT=615.025n

.meas tran vdout1_71ck1220 FIND v(dout1_71) AT=615.025n

.meas tran vdout1_72ck1220 FIND v(dout1_72) AT=615.025n

.meas tran vdout1_73ck1220 FIND v(dout1_73) AT=615.025n

.meas tran vdout1_74ck1220 FIND v(dout1_74) AT=615.025n

.meas tran vdout1_75ck1220 FIND v(dout1_75) AT=615.025n

.meas tran vdout1_76ck1220 FIND v(dout1_76) AT=615.025n

.meas tran vdout1_77ck1220 FIND v(dout1_77) AT=615.025n

.meas tran vdout1_78ck1220 FIND v(dout1_78) AT=615.025n

.meas tran vdout1_79ck1220 FIND v(dout1_79) AT=615.025n

.meas tran vdout1_80ck1220 FIND v(dout1_80) AT=615.025n

.meas tran vdout1_81ck1220 FIND v(dout1_81) AT=615.025n

.meas tran vdout1_82ck1220 FIND v(dout1_82) AT=615.025n

.meas tran vdout1_83ck1220 FIND v(dout1_83) AT=615.025n

.meas tran vdout1_84ck1220 FIND v(dout1_84) AT=615.025n

.meas tran vdout1_85ck1220 FIND v(dout1_85) AT=615.025n

.meas tran vdout1_86ck1220 FIND v(dout1_86) AT=615.025n

.meas tran vdout1_87ck1220 FIND v(dout1_87) AT=615.025n

.meas tran vdout1_88ck1220 FIND v(dout1_88) AT=615.025n

.meas tran vdout1_89ck1220 FIND v(dout1_89) AT=615.025n

.meas tran vdout1_90ck1220 FIND v(dout1_90) AT=615.025n

.meas tran vdout1_91ck1220 FIND v(dout1_91) AT=615.025n

.meas tran vdout1_92ck1220 FIND v(dout1_92) AT=615.025n

.meas tran vdout1_93ck1220 FIND v(dout1_93) AT=615.025n

.meas tran vdout1_94ck1220 FIND v(dout1_94) AT=615.025n

.meas tran vdout1_95ck1220 FIND v(dout1_95) AT=615.025n

.meas tran vdout1_96ck1220 FIND v(dout1_96) AT=615.025n

.meas tran vdout1_97ck1220 FIND v(dout1_97) AT=615.025n

.meas tran vdout1_98ck1220 FIND v(dout1_98) AT=615.025n

.meas tran vdout1_99ck1220 FIND v(dout1_99) AT=615.025n

.meas tran vdout1_100ck1220 FIND v(dout1_100) AT=615.025n

.meas tran vdout1_101ck1220 FIND v(dout1_101) AT=615.025n

.meas tran vdout1_102ck1220 FIND v(dout1_102) AT=615.025n

.meas tran vdout1_103ck1220 FIND v(dout1_103) AT=615.025n

.meas tran vdout1_104ck1220 FIND v(dout1_104) AT=615.025n

.meas tran vdout1_105ck1220 FIND v(dout1_105) AT=615.025n

.meas tran vdout1_106ck1220 FIND v(dout1_106) AT=615.025n

.meas tran vdout1_107ck1220 FIND v(dout1_107) AT=615.025n

.meas tran vdout1_108ck1220 FIND v(dout1_108) AT=615.025n

.meas tran vdout1_109ck1220 FIND v(dout1_109) AT=615.025n

.meas tran vdout1_110ck1220 FIND v(dout1_110) AT=615.025n

.meas tran vdout1_111ck1220 FIND v(dout1_111) AT=615.025n

.meas tran vdout1_112ck1220 FIND v(dout1_112) AT=615.025n

.meas tran vdout1_113ck1220 FIND v(dout1_113) AT=615.025n

.meas tran vdout1_114ck1220 FIND v(dout1_114) AT=615.025n

.meas tran vdout1_115ck1220 FIND v(dout1_115) AT=615.025n

.meas tran vdout1_116ck1220 FIND v(dout1_116) AT=615.025n

.meas tran vdout1_117ck1220 FIND v(dout1_117) AT=615.025n

.meas tran vdout1_118ck1220 FIND v(dout1_118) AT=615.025n

.meas tran vdout1_119ck1220 FIND v(dout1_119) AT=615.025n

.meas tran vdout1_120ck1220 FIND v(dout1_120) AT=615.025n

.meas tran vdout1_121ck1220 FIND v(dout1_121) AT=615.025n

.meas tran vdout1_122ck1220 FIND v(dout1_122) AT=615.025n

.meas tran vdout1_123ck1220 FIND v(dout1_123) AT=615.025n

.meas tran vdout1_124ck1220 FIND v(dout1_124) AT=615.025n

.meas tran vdout1_125ck1220 FIND v(dout1_125) AT=615.025n

.meas tran vdout1_126ck1220 FIND v(dout1_126) AT=615.025n

.meas tran vdout1_127ck1220 FIND v(dout1_127) AT=615.025n

.meas tran vdout1_0ck1230 FIND v(dout1_0) AT=620.025n

.meas tran vdout1_1ck1230 FIND v(dout1_1) AT=620.025n

.meas tran vdout1_2ck1230 FIND v(dout1_2) AT=620.025n

.meas tran vdout1_3ck1230 FIND v(dout1_3) AT=620.025n

.meas tran vdout1_4ck1230 FIND v(dout1_4) AT=620.025n

.meas tran vdout1_5ck1230 FIND v(dout1_5) AT=620.025n

.meas tran vdout1_6ck1230 FIND v(dout1_6) AT=620.025n

.meas tran vdout1_7ck1230 FIND v(dout1_7) AT=620.025n

.meas tran vdout1_8ck1230 FIND v(dout1_8) AT=620.025n

.meas tran vdout1_9ck1230 FIND v(dout1_9) AT=620.025n

.meas tran vdout1_10ck1230 FIND v(dout1_10) AT=620.025n

.meas tran vdout1_11ck1230 FIND v(dout1_11) AT=620.025n

.meas tran vdout1_12ck1230 FIND v(dout1_12) AT=620.025n

.meas tran vdout1_13ck1230 FIND v(dout1_13) AT=620.025n

.meas tran vdout1_14ck1230 FIND v(dout1_14) AT=620.025n

.meas tran vdout1_15ck1230 FIND v(dout1_15) AT=620.025n

.meas tran vdout1_16ck1230 FIND v(dout1_16) AT=620.025n

.meas tran vdout1_17ck1230 FIND v(dout1_17) AT=620.025n

.meas tran vdout1_18ck1230 FIND v(dout1_18) AT=620.025n

.meas tran vdout1_19ck1230 FIND v(dout1_19) AT=620.025n

.meas tran vdout1_20ck1230 FIND v(dout1_20) AT=620.025n

.meas tran vdout1_21ck1230 FIND v(dout1_21) AT=620.025n

.meas tran vdout1_22ck1230 FIND v(dout1_22) AT=620.025n

.meas tran vdout1_23ck1230 FIND v(dout1_23) AT=620.025n

.meas tran vdout1_24ck1230 FIND v(dout1_24) AT=620.025n

.meas tran vdout1_25ck1230 FIND v(dout1_25) AT=620.025n

.meas tran vdout1_26ck1230 FIND v(dout1_26) AT=620.025n

.meas tran vdout1_27ck1230 FIND v(dout1_27) AT=620.025n

.meas tran vdout1_28ck1230 FIND v(dout1_28) AT=620.025n

.meas tran vdout1_29ck1230 FIND v(dout1_29) AT=620.025n

.meas tran vdout1_30ck1230 FIND v(dout1_30) AT=620.025n

.meas tran vdout1_31ck1230 FIND v(dout1_31) AT=620.025n

.meas tran vdout1_32ck1230 FIND v(dout1_32) AT=620.025n

.meas tran vdout1_33ck1230 FIND v(dout1_33) AT=620.025n

.meas tran vdout1_34ck1230 FIND v(dout1_34) AT=620.025n

.meas tran vdout1_35ck1230 FIND v(dout1_35) AT=620.025n

.meas tran vdout1_36ck1230 FIND v(dout1_36) AT=620.025n

.meas tran vdout1_37ck1230 FIND v(dout1_37) AT=620.025n

.meas tran vdout1_38ck1230 FIND v(dout1_38) AT=620.025n

.meas tran vdout1_39ck1230 FIND v(dout1_39) AT=620.025n

.meas tran vdout1_40ck1230 FIND v(dout1_40) AT=620.025n

.meas tran vdout1_41ck1230 FIND v(dout1_41) AT=620.025n

.meas tran vdout1_42ck1230 FIND v(dout1_42) AT=620.025n

.meas tran vdout1_43ck1230 FIND v(dout1_43) AT=620.025n

.meas tran vdout1_44ck1230 FIND v(dout1_44) AT=620.025n

.meas tran vdout1_45ck1230 FIND v(dout1_45) AT=620.025n

.meas tran vdout1_46ck1230 FIND v(dout1_46) AT=620.025n

.meas tran vdout1_47ck1230 FIND v(dout1_47) AT=620.025n

.meas tran vdout1_48ck1230 FIND v(dout1_48) AT=620.025n

.meas tran vdout1_49ck1230 FIND v(dout1_49) AT=620.025n

.meas tran vdout1_50ck1230 FIND v(dout1_50) AT=620.025n

.meas tran vdout1_51ck1230 FIND v(dout1_51) AT=620.025n

.meas tran vdout1_52ck1230 FIND v(dout1_52) AT=620.025n

.meas tran vdout1_53ck1230 FIND v(dout1_53) AT=620.025n

.meas tran vdout1_54ck1230 FIND v(dout1_54) AT=620.025n

.meas tran vdout1_55ck1230 FIND v(dout1_55) AT=620.025n

.meas tran vdout1_56ck1230 FIND v(dout1_56) AT=620.025n

.meas tran vdout1_57ck1230 FIND v(dout1_57) AT=620.025n

.meas tran vdout1_58ck1230 FIND v(dout1_58) AT=620.025n

.meas tran vdout1_59ck1230 FIND v(dout1_59) AT=620.025n

.meas tran vdout1_60ck1230 FIND v(dout1_60) AT=620.025n

.meas tran vdout1_61ck1230 FIND v(dout1_61) AT=620.025n

.meas tran vdout1_62ck1230 FIND v(dout1_62) AT=620.025n

.meas tran vdout1_63ck1230 FIND v(dout1_63) AT=620.025n

.meas tran vdout1_64ck1230 FIND v(dout1_64) AT=620.025n

.meas tran vdout1_65ck1230 FIND v(dout1_65) AT=620.025n

.meas tran vdout1_66ck1230 FIND v(dout1_66) AT=620.025n

.meas tran vdout1_67ck1230 FIND v(dout1_67) AT=620.025n

.meas tran vdout1_68ck1230 FIND v(dout1_68) AT=620.025n

.meas tran vdout1_69ck1230 FIND v(dout1_69) AT=620.025n

.meas tran vdout1_70ck1230 FIND v(dout1_70) AT=620.025n

.meas tran vdout1_71ck1230 FIND v(dout1_71) AT=620.025n

.meas tran vdout1_72ck1230 FIND v(dout1_72) AT=620.025n

.meas tran vdout1_73ck1230 FIND v(dout1_73) AT=620.025n

.meas tran vdout1_74ck1230 FIND v(dout1_74) AT=620.025n

.meas tran vdout1_75ck1230 FIND v(dout1_75) AT=620.025n

.meas tran vdout1_76ck1230 FIND v(dout1_76) AT=620.025n

.meas tran vdout1_77ck1230 FIND v(dout1_77) AT=620.025n

.meas tran vdout1_78ck1230 FIND v(dout1_78) AT=620.025n

.meas tran vdout1_79ck1230 FIND v(dout1_79) AT=620.025n

.meas tran vdout1_80ck1230 FIND v(dout1_80) AT=620.025n

.meas tran vdout1_81ck1230 FIND v(dout1_81) AT=620.025n

.meas tran vdout1_82ck1230 FIND v(dout1_82) AT=620.025n

.meas tran vdout1_83ck1230 FIND v(dout1_83) AT=620.025n

.meas tran vdout1_84ck1230 FIND v(dout1_84) AT=620.025n

.meas tran vdout1_85ck1230 FIND v(dout1_85) AT=620.025n

.meas tran vdout1_86ck1230 FIND v(dout1_86) AT=620.025n

.meas tran vdout1_87ck1230 FIND v(dout1_87) AT=620.025n

.meas tran vdout1_88ck1230 FIND v(dout1_88) AT=620.025n

.meas tran vdout1_89ck1230 FIND v(dout1_89) AT=620.025n

.meas tran vdout1_90ck1230 FIND v(dout1_90) AT=620.025n

.meas tran vdout1_91ck1230 FIND v(dout1_91) AT=620.025n

.meas tran vdout1_92ck1230 FIND v(dout1_92) AT=620.025n

.meas tran vdout1_93ck1230 FIND v(dout1_93) AT=620.025n

.meas tran vdout1_94ck1230 FIND v(dout1_94) AT=620.025n

.meas tran vdout1_95ck1230 FIND v(dout1_95) AT=620.025n

.meas tran vdout1_96ck1230 FIND v(dout1_96) AT=620.025n

.meas tran vdout1_97ck1230 FIND v(dout1_97) AT=620.025n

.meas tran vdout1_98ck1230 FIND v(dout1_98) AT=620.025n

.meas tran vdout1_99ck1230 FIND v(dout1_99) AT=620.025n

.meas tran vdout1_100ck1230 FIND v(dout1_100) AT=620.025n

.meas tran vdout1_101ck1230 FIND v(dout1_101) AT=620.025n

.meas tran vdout1_102ck1230 FIND v(dout1_102) AT=620.025n

.meas tran vdout1_103ck1230 FIND v(dout1_103) AT=620.025n

.meas tran vdout1_104ck1230 FIND v(dout1_104) AT=620.025n

.meas tran vdout1_105ck1230 FIND v(dout1_105) AT=620.025n

.meas tran vdout1_106ck1230 FIND v(dout1_106) AT=620.025n

.meas tran vdout1_107ck1230 FIND v(dout1_107) AT=620.025n

.meas tran vdout1_108ck1230 FIND v(dout1_108) AT=620.025n

.meas tran vdout1_109ck1230 FIND v(dout1_109) AT=620.025n

.meas tran vdout1_110ck1230 FIND v(dout1_110) AT=620.025n

.meas tran vdout1_111ck1230 FIND v(dout1_111) AT=620.025n

.meas tran vdout1_112ck1230 FIND v(dout1_112) AT=620.025n

.meas tran vdout1_113ck1230 FIND v(dout1_113) AT=620.025n

.meas tran vdout1_114ck1230 FIND v(dout1_114) AT=620.025n

.meas tran vdout1_115ck1230 FIND v(dout1_115) AT=620.025n

.meas tran vdout1_116ck1230 FIND v(dout1_116) AT=620.025n

.meas tran vdout1_117ck1230 FIND v(dout1_117) AT=620.025n

.meas tran vdout1_118ck1230 FIND v(dout1_118) AT=620.025n

.meas tran vdout1_119ck1230 FIND v(dout1_119) AT=620.025n

.meas tran vdout1_120ck1230 FIND v(dout1_120) AT=620.025n

.meas tran vdout1_121ck1230 FIND v(dout1_121) AT=620.025n

.meas tran vdout1_122ck1230 FIND v(dout1_122) AT=620.025n

.meas tran vdout1_123ck1230 FIND v(dout1_123) AT=620.025n

.meas tran vdout1_124ck1230 FIND v(dout1_124) AT=620.025n

.meas tran vdout1_125ck1230 FIND v(dout1_125) AT=620.025n

.meas tran vdout1_126ck1230 FIND v(dout1_126) AT=620.025n

.meas tran vdout1_127ck1230 FIND v(dout1_127) AT=620.025n

.meas tran vdout1_0ck1240 FIND v(dout1_0) AT=625.025n

.meas tran vdout1_1ck1240 FIND v(dout1_1) AT=625.025n

.meas tran vdout1_2ck1240 FIND v(dout1_2) AT=625.025n

.meas tran vdout1_3ck1240 FIND v(dout1_3) AT=625.025n

.meas tran vdout1_4ck1240 FIND v(dout1_4) AT=625.025n

.meas tran vdout1_5ck1240 FIND v(dout1_5) AT=625.025n

.meas tran vdout1_6ck1240 FIND v(dout1_6) AT=625.025n

.meas tran vdout1_7ck1240 FIND v(dout1_7) AT=625.025n

.meas tran vdout1_8ck1240 FIND v(dout1_8) AT=625.025n

.meas tran vdout1_9ck1240 FIND v(dout1_9) AT=625.025n

.meas tran vdout1_10ck1240 FIND v(dout1_10) AT=625.025n

.meas tran vdout1_11ck1240 FIND v(dout1_11) AT=625.025n

.meas tran vdout1_12ck1240 FIND v(dout1_12) AT=625.025n

.meas tran vdout1_13ck1240 FIND v(dout1_13) AT=625.025n

.meas tran vdout1_14ck1240 FIND v(dout1_14) AT=625.025n

.meas tran vdout1_15ck1240 FIND v(dout1_15) AT=625.025n

.meas tran vdout1_16ck1240 FIND v(dout1_16) AT=625.025n

.meas tran vdout1_17ck1240 FIND v(dout1_17) AT=625.025n

.meas tran vdout1_18ck1240 FIND v(dout1_18) AT=625.025n

.meas tran vdout1_19ck1240 FIND v(dout1_19) AT=625.025n

.meas tran vdout1_20ck1240 FIND v(dout1_20) AT=625.025n

.meas tran vdout1_21ck1240 FIND v(dout1_21) AT=625.025n

.meas tran vdout1_22ck1240 FIND v(dout1_22) AT=625.025n

.meas tran vdout1_23ck1240 FIND v(dout1_23) AT=625.025n

.meas tran vdout1_24ck1240 FIND v(dout1_24) AT=625.025n

.meas tran vdout1_25ck1240 FIND v(dout1_25) AT=625.025n

.meas tran vdout1_26ck1240 FIND v(dout1_26) AT=625.025n

.meas tran vdout1_27ck1240 FIND v(dout1_27) AT=625.025n

.meas tran vdout1_28ck1240 FIND v(dout1_28) AT=625.025n

.meas tran vdout1_29ck1240 FIND v(dout1_29) AT=625.025n

.meas tran vdout1_30ck1240 FIND v(dout1_30) AT=625.025n

.meas tran vdout1_31ck1240 FIND v(dout1_31) AT=625.025n

.meas tran vdout1_32ck1240 FIND v(dout1_32) AT=625.025n

.meas tran vdout1_33ck1240 FIND v(dout1_33) AT=625.025n

.meas tran vdout1_34ck1240 FIND v(dout1_34) AT=625.025n

.meas tran vdout1_35ck1240 FIND v(dout1_35) AT=625.025n

.meas tran vdout1_36ck1240 FIND v(dout1_36) AT=625.025n

.meas tran vdout1_37ck1240 FIND v(dout1_37) AT=625.025n

.meas tran vdout1_38ck1240 FIND v(dout1_38) AT=625.025n

.meas tran vdout1_39ck1240 FIND v(dout1_39) AT=625.025n

.meas tran vdout1_40ck1240 FIND v(dout1_40) AT=625.025n

.meas tran vdout1_41ck1240 FIND v(dout1_41) AT=625.025n

.meas tran vdout1_42ck1240 FIND v(dout1_42) AT=625.025n

.meas tran vdout1_43ck1240 FIND v(dout1_43) AT=625.025n

.meas tran vdout1_44ck1240 FIND v(dout1_44) AT=625.025n

.meas tran vdout1_45ck1240 FIND v(dout1_45) AT=625.025n

.meas tran vdout1_46ck1240 FIND v(dout1_46) AT=625.025n

.meas tran vdout1_47ck1240 FIND v(dout1_47) AT=625.025n

.meas tran vdout1_48ck1240 FIND v(dout1_48) AT=625.025n

.meas tran vdout1_49ck1240 FIND v(dout1_49) AT=625.025n

.meas tran vdout1_50ck1240 FIND v(dout1_50) AT=625.025n

.meas tran vdout1_51ck1240 FIND v(dout1_51) AT=625.025n

.meas tran vdout1_52ck1240 FIND v(dout1_52) AT=625.025n

.meas tran vdout1_53ck1240 FIND v(dout1_53) AT=625.025n

.meas tran vdout1_54ck1240 FIND v(dout1_54) AT=625.025n

.meas tran vdout1_55ck1240 FIND v(dout1_55) AT=625.025n

.meas tran vdout1_56ck1240 FIND v(dout1_56) AT=625.025n

.meas tran vdout1_57ck1240 FIND v(dout1_57) AT=625.025n

.meas tran vdout1_58ck1240 FIND v(dout1_58) AT=625.025n

.meas tran vdout1_59ck1240 FIND v(dout1_59) AT=625.025n

.meas tran vdout1_60ck1240 FIND v(dout1_60) AT=625.025n

.meas tran vdout1_61ck1240 FIND v(dout1_61) AT=625.025n

.meas tran vdout1_62ck1240 FIND v(dout1_62) AT=625.025n

.meas tran vdout1_63ck1240 FIND v(dout1_63) AT=625.025n

.meas tran vdout1_64ck1240 FIND v(dout1_64) AT=625.025n

.meas tran vdout1_65ck1240 FIND v(dout1_65) AT=625.025n

.meas tran vdout1_66ck1240 FIND v(dout1_66) AT=625.025n

.meas tran vdout1_67ck1240 FIND v(dout1_67) AT=625.025n

.meas tran vdout1_68ck1240 FIND v(dout1_68) AT=625.025n

.meas tran vdout1_69ck1240 FIND v(dout1_69) AT=625.025n

.meas tran vdout1_70ck1240 FIND v(dout1_70) AT=625.025n

.meas tran vdout1_71ck1240 FIND v(dout1_71) AT=625.025n

.meas tran vdout1_72ck1240 FIND v(dout1_72) AT=625.025n

.meas tran vdout1_73ck1240 FIND v(dout1_73) AT=625.025n

.meas tran vdout1_74ck1240 FIND v(dout1_74) AT=625.025n

.meas tran vdout1_75ck1240 FIND v(dout1_75) AT=625.025n

.meas tran vdout1_76ck1240 FIND v(dout1_76) AT=625.025n

.meas tran vdout1_77ck1240 FIND v(dout1_77) AT=625.025n

.meas tran vdout1_78ck1240 FIND v(dout1_78) AT=625.025n

.meas tran vdout1_79ck1240 FIND v(dout1_79) AT=625.025n

.meas tran vdout1_80ck1240 FIND v(dout1_80) AT=625.025n

.meas tran vdout1_81ck1240 FIND v(dout1_81) AT=625.025n

.meas tran vdout1_82ck1240 FIND v(dout1_82) AT=625.025n

.meas tran vdout1_83ck1240 FIND v(dout1_83) AT=625.025n

.meas tran vdout1_84ck1240 FIND v(dout1_84) AT=625.025n

.meas tran vdout1_85ck1240 FIND v(dout1_85) AT=625.025n

.meas tran vdout1_86ck1240 FIND v(dout1_86) AT=625.025n

.meas tran vdout1_87ck1240 FIND v(dout1_87) AT=625.025n

.meas tran vdout1_88ck1240 FIND v(dout1_88) AT=625.025n

.meas tran vdout1_89ck1240 FIND v(dout1_89) AT=625.025n

.meas tran vdout1_90ck1240 FIND v(dout1_90) AT=625.025n

.meas tran vdout1_91ck1240 FIND v(dout1_91) AT=625.025n

.meas tran vdout1_92ck1240 FIND v(dout1_92) AT=625.025n

.meas tran vdout1_93ck1240 FIND v(dout1_93) AT=625.025n

.meas tran vdout1_94ck1240 FIND v(dout1_94) AT=625.025n

.meas tran vdout1_95ck1240 FIND v(dout1_95) AT=625.025n

.meas tran vdout1_96ck1240 FIND v(dout1_96) AT=625.025n

.meas tran vdout1_97ck1240 FIND v(dout1_97) AT=625.025n

.meas tran vdout1_98ck1240 FIND v(dout1_98) AT=625.025n

.meas tran vdout1_99ck1240 FIND v(dout1_99) AT=625.025n

.meas tran vdout1_100ck1240 FIND v(dout1_100) AT=625.025n

.meas tran vdout1_101ck1240 FIND v(dout1_101) AT=625.025n

.meas tran vdout1_102ck1240 FIND v(dout1_102) AT=625.025n

.meas tran vdout1_103ck1240 FIND v(dout1_103) AT=625.025n

.meas tran vdout1_104ck1240 FIND v(dout1_104) AT=625.025n

.meas tran vdout1_105ck1240 FIND v(dout1_105) AT=625.025n

.meas tran vdout1_106ck1240 FIND v(dout1_106) AT=625.025n

.meas tran vdout1_107ck1240 FIND v(dout1_107) AT=625.025n

.meas tran vdout1_108ck1240 FIND v(dout1_108) AT=625.025n

.meas tran vdout1_109ck1240 FIND v(dout1_109) AT=625.025n

.meas tran vdout1_110ck1240 FIND v(dout1_110) AT=625.025n

.meas tran vdout1_111ck1240 FIND v(dout1_111) AT=625.025n

.meas tran vdout1_112ck1240 FIND v(dout1_112) AT=625.025n

.meas tran vdout1_113ck1240 FIND v(dout1_113) AT=625.025n

.meas tran vdout1_114ck1240 FIND v(dout1_114) AT=625.025n

.meas tran vdout1_115ck1240 FIND v(dout1_115) AT=625.025n

.meas tran vdout1_116ck1240 FIND v(dout1_116) AT=625.025n

.meas tran vdout1_117ck1240 FIND v(dout1_117) AT=625.025n

.meas tran vdout1_118ck1240 FIND v(dout1_118) AT=625.025n

.meas tran vdout1_119ck1240 FIND v(dout1_119) AT=625.025n

.meas tran vdout1_120ck1240 FIND v(dout1_120) AT=625.025n

.meas tran vdout1_121ck1240 FIND v(dout1_121) AT=625.025n

.meas tran vdout1_122ck1240 FIND v(dout1_122) AT=625.025n

.meas tran vdout1_123ck1240 FIND v(dout1_123) AT=625.025n

.meas tran vdout1_124ck1240 FIND v(dout1_124) AT=625.025n

.meas tran vdout1_125ck1240 FIND v(dout1_125) AT=625.025n

.meas tran vdout1_126ck1240 FIND v(dout1_126) AT=625.025n

.meas tran vdout1_127ck1240 FIND v(dout1_127) AT=625.025n

.meas tran vdout1_0ck1290 FIND v(dout1_0) AT=650.025n

.meas tran vdout1_1ck1290 FIND v(dout1_1) AT=650.025n

.meas tran vdout1_2ck1290 FIND v(dout1_2) AT=650.025n

.meas tran vdout1_3ck1290 FIND v(dout1_3) AT=650.025n

.meas tran vdout1_4ck1290 FIND v(dout1_4) AT=650.025n

.meas tran vdout1_5ck1290 FIND v(dout1_5) AT=650.025n

.meas tran vdout1_6ck1290 FIND v(dout1_6) AT=650.025n

.meas tran vdout1_7ck1290 FIND v(dout1_7) AT=650.025n

.meas tran vdout1_8ck1290 FIND v(dout1_8) AT=650.025n

.meas tran vdout1_9ck1290 FIND v(dout1_9) AT=650.025n

.meas tran vdout1_10ck1290 FIND v(dout1_10) AT=650.025n

.meas tran vdout1_11ck1290 FIND v(dout1_11) AT=650.025n

.meas tran vdout1_12ck1290 FIND v(dout1_12) AT=650.025n

.meas tran vdout1_13ck1290 FIND v(dout1_13) AT=650.025n

.meas tran vdout1_14ck1290 FIND v(dout1_14) AT=650.025n

.meas tran vdout1_15ck1290 FIND v(dout1_15) AT=650.025n

.meas tran vdout1_16ck1290 FIND v(dout1_16) AT=650.025n

.meas tran vdout1_17ck1290 FIND v(dout1_17) AT=650.025n

.meas tran vdout1_18ck1290 FIND v(dout1_18) AT=650.025n

.meas tran vdout1_19ck1290 FIND v(dout1_19) AT=650.025n

.meas tran vdout1_20ck1290 FIND v(dout1_20) AT=650.025n

.meas tran vdout1_21ck1290 FIND v(dout1_21) AT=650.025n

.meas tran vdout1_22ck1290 FIND v(dout1_22) AT=650.025n

.meas tran vdout1_23ck1290 FIND v(dout1_23) AT=650.025n

.meas tran vdout1_24ck1290 FIND v(dout1_24) AT=650.025n

.meas tran vdout1_25ck1290 FIND v(dout1_25) AT=650.025n

.meas tran vdout1_26ck1290 FIND v(dout1_26) AT=650.025n

.meas tran vdout1_27ck1290 FIND v(dout1_27) AT=650.025n

.meas tran vdout1_28ck1290 FIND v(dout1_28) AT=650.025n

.meas tran vdout1_29ck1290 FIND v(dout1_29) AT=650.025n

.meas tran vdout1_30ck1290 FIND v(dout1_30) AT=650.025n

.meas tran vdout1_31ck1290 FIND v(dout1_31) AT=650.025n

.meas tran vdout1_32ck1290 FIND v(dout1_32) AT=650.025n

.meas tran vdout1_33ck1290 FIND v(dout1_33) AT=650.025n

.meas tran vdout1_34ck1290 FIND v(dout1_34) AT=650.025n

.meas tran vdout1_35ck1290 FIND v(dout1_35) AT=650.025n

.meas tran vdout1_36ck1290 FIND v(dout1_36) AT=650.025n

.meas tran vdout1_37ck1290 FIND v(dout1_37) AT=650.025n

.meas tran vdout1_38ck1290 FIND v(dout1_38) AT=650.025n

.meas tran vdout1_39ck1290 FIND v(dout1_39) AT=650.025n

.meas tran vdout1_40ck1290 FIND v(dout1_40) AT=650.025n

.meas tran vdout1_41ck1290 FIND v(dout1_41) AT=650.025n

.meas tran vdout1_42ck1290 FIND v(dout1_42) AT=650.025n

.meas tran vdout1_43ck1290 FIND v(dout1_43) AT=650.025n

.meas tran vdout1_44ck1290 FIND v(dout1_44) AT=650.025n

.meas tran vdout1_45ck1290 FIND v(dout1_45) AT=650.025n

.meas tran vdout1_46ck1290 FIND v(dout1_46) AT=650.025n

.meas tran vdout1_47ck1290 FIND v(dout1_47) AT=650.025n

.meas tran vdout1_48ck1290 FIND v(dout1_48) AT=650.025n

.meas tran vdout1_49ck1290 FIND v(dout1_49) AT=650.025n

.meas tran vdout1_50ck1290 FIND v(dout1_50) AT=650.025n

.meas tran vdout1_51ck1290 FIND v(dout1_51) AT=650.025n

.meas tran vdout1_52ck1290 FIND v(dout1_52) AT=650.025n

.meas tran vdout1_53ck1290 FIND v(dout1_53) AT=650.025n

.meas tran vdout1_54ck1290 FIND v(dout1_54) AT=650.025n

.meas tran vdout1_55ck1290 FIND v(dout1_55) AT=650.025n

.meas tran vdout1_56ck1290 FIND v(dout1_56) AT=650.025n

.meas tran vdout1_57ck1290 FIND v(dout1_57) AT=650.025n

.meas tran vdout1_58ck1290 FIND v(dout1_58) AT=650.025n

.meas tran vdout1_59ck1290 FIND v(dout1_59) AT=650.025n

.meas tran vdout1_60ck1290 FIND v(dout1_60) AT=650.025n

.meas tran vdout1_61ck1290 FIND v(dout1_61) AT=650.025n

.meas tran vdout1_62ck1290 FIND v(dout1_62) AT=650.025n

.meas tran vdout1_63ck1290 FIND v(dout1_63) AT=650.025n

.meas tran vdout1_64ck1290 FIND v(dout1_64) AT=650.025n

.meas tran vdout1_65ck1290 FIND v(dout1_65) AT=650.025n

.meas tran vdout1_66ck1290 FIND v(dout1_66) AT=650.025n

.meas tran vdout1_67ck1290 FIND v(dout1_67) AT=650.025n

.meas tran vdout1_68ck1290 FIND v(dout1_68) AT=650.025n

.meas tran vdout1_69ck1290 FIND v(dout1_69) AT=650.025n

.meas tran vdout1_70ck1290 FIND v(dout1_70) AT=650.025n

.meas tran vdout1_71ck1290 FIND v(dout1_71) AT=650.025n

.meas tran vdout1_72ck1290 FIND v(dout1_72) AT=650.025n

.meas tran vdout1_73ck1290 FIND v(dout1_73) AT=650.025n

.meas tran vdout1_74ck1290 FIND v(dout1_74) AT=650.025n

.meas tran vdout1_75ck1290 FIND v(dout1_75) AT=650.025n

.meas tran vdout1_76ck1290 FIND v(dout1_76) AT=650.025n

.meas tran vdout1_77ck1290 FIND v(dout1_77) AT=650.025n

.meas tran vdout1_78ck1290 FIND v(dout1_78) AT=650.025n

.meas tran vdout1_79ck1290 FIND v(dout1_79) AT=650.025n

.meas tran vdout1_80ck1290 FIND v(dout1_80) AT=650.025n

.meas tran vdout1_81ck1290 FIND v(dout1_81) AT=650.025n

.meas tran vdout1_82ck1290 FIND v(dout1_82) AT=650.025n

.meas tran vdout1_83ck1290 FIND v(dout1_83) AT=650.025n

.meas tran vdout1_84ck1290 FIND v(dout1_84) AT=650.025n

.meas tran vdout1_85ck1290 FIND v(dout1_85) AT=650.025n

.meas tran vdout1_86ck1290 FIND v(dout1_86) AT=650.025n

.meas tran vdout1_87ck1290 FIND v(dout1_87) AT=650.025n

.meas tran vdout1_88ck1290 FIND v(dout1_88) AT=650.025n

.meas tran vdout1_89ck1290 FIND v(dout1_89) AT=650.025n

.meas tran vdout1_90ck1290 FIND v(dout1_90) AT=650.025n

.meas tran vdout1_91ck1290 FIND v(dout1_91) AT=650.025n

.meas tran vdout1_92ck1290 FIND v(dout1_92) AT=650.025n

.meas tran vdout1_93ck1290 FIND v(dout1_93) AT=650.025n

.meas tran vdout1_94ck1290 FIND v(dout1_94) AT=650.025n

.meas tran vdout1_95ck1290 FIND v(dout1_95) AT=650.025n

.meas tran vdout1_96ck1290 FIND v(dout1_96) AT=650.025n

.meas tran vdout1_97ck1290 FIND v(dout1_97) AT=650.025n

.meas tran vdout1_98ck1290 FIND v(dout1_98) AT=650.025n

.meas tran vdout1_99ck1290 FIND v(dout1_99) AT=650.025n

.meas tran vdout1_100ck1290 FIND v(dout1_100) AT=650.025n

.meas tran vdout1_101ck1290 FIND v(dout1_101) AT=650.025n

.meas tran vdout1_102ck1290 FIND v(dout1_102) AT=650.025n

.meas tran vdout1_103ck1290 FIND v(dout1_103) AT=650.025n

.meas tran vdout1_104ck1290 FIND v(dout1_104) AT=650.025n

.meas tran vdout1_105ck1290 FIND v(dout1_105) AT=650.025n

.meas tran vdout1_106ck1290 FIND v(dout1_106) AT=650.025n

.meas tran vdout1_107ck1290 FIND v(dout1_107) AT=650.025n

.meas tran vdout1_108ck1290 FIND v(dout1_108) AT=650.025n

.meas tran vdout1_109ck1290 FIND v(dout1_109) AT=650.025n

.meas tran vdout1_110ck1290 FIND v(dout1_110) AT=650.025n

.meas tran vdout1_111ck1290 FIND v(dout1_111) AT=650.025n

.meas tran vdout1_112ck1290 FIND v(dout1_112) AT=650.025n

.meas tran vdout1_113ck1290 FIND v(dout1_113) AT=650.025n

.meas tran vdout1_114ck1290 FIND v(dout1_114) AT=650.025n

.meas tran vdout1_115ck1290 FIND v(dout1_115) AT=650.025n

.meas tran vdout1_116ck1290 FIND v(dout1_116) AT=650.025n

.meas tran vdout1_117ck1290 FIND v(dout1_117) AT=650.025n

.meas tran vdout1_118ck1290 FIND v(dout1_118) AT=650.025n

.meas tran vdout1_119ck1290 FIND v(dout1_119) AT=650.025n

.meas tran vdout1_120ck1290 FIND v(dout1_120) AT=650.025n

.meas tran vdout1_121ck1290 FIND v(dout1_121) AT=650.025n

.meas tran vdout1_122ck1290 FIND v(dout1_122) AT=650.025n

.meas tran vdout1_123ck1290 FIND v(dout1_123) AT=650.025n

.meas tran vdout1_124ck1290 FIND v(dout1_124) AT=650.025n

.meas tran vdout1_125ck1290 FIND v(dout1_125) AT=650.025n

.meas tran vdout1_126ck1290 FIND v(dout1_126) AT=650.025n

.meas tran vdout1_127ck1290 FIND v(dout1_127) AT=650.025n

.meas tran vdout1_0ck1320 FIND v(dout1_0) AT=665.025n

.meas tran vdout1_1ck1320 FIND v(dout1_1) AT=665.025n

.meas tran vdout1_2ck1320 FIND v(dout1_2) AT=665.025n

.meas tran vdout1_3ck1320 FIND v(dout1_3) AT=665.025n

.meas tran vdout1_4ck1320 FIND v(dout1_4) AT=665.025n

.meas tran vdout1_5ck1320 FIND v(dout1_5) AT=665.025n

.meas tran vdout1_6ck1320 FIND v(dout1_6) AT=665.025n

.meas tran vdout1_7ck1320 FIND v(dout1_7) AT=665.025n

.meas tran vdout1_8ck1320 FIND v(dout1_8) AT=665.025n

.meas tran vdout1_9ck1320 FIND v(dout1_9) AT=665.025n

.meas tran vdout1_10ck1320 FIND v(dout1_10) AT=665.025n

.meas tran vdout1_11ck1320 FIND v(dout1_11) AT=665.025n

.meas tran vdout1_12ck1320 FIND v(dout1_12) AT=665.025n

.meas tran vdout1_13ck1320 FIND v(dout1_13) AT=665.025n

.meas tran vdout1_14ck1320 FIND v(dout1_14) AT=665.025n

.meas tran vdout1_15ck1320 FIND v(dout1_15) AT=665.025n

.meas tran vdout1_16ck1320 FIND v(dout1_16) AT=665.025n

.meas tran vdout1_17ck1320 FIND v(dout1_17) AT=665.025n

.meas tran vdout1_18ck1320 FIND v(dout1_18) AT=665.025n

.meas tran vdout1_19ck1320 FIND v(dout1_19) AT=665.025n

.meas tran vdout1_20ck1320 FIND v(dout1_20) AT=665.025n

.meas tran vdout1_21ck1320 FIND v(dout1_21) AT=665.025n

.meas tran vdout1_22ck1320 FIND v(dout1_22) AT=665.025n

.meas tran vdout1_23ck1320 FIND v(dout1_23) AT=665.025n

.meas tran vdout1_24ck1320 FIND v(dout1_24) AT=665.025n

.meas tran vdout1_25ck1320 FIND v(dout1_25) AT=665.025n

.meas tran vdout1_26ck1320 FIND v(dout1_26) AT=665.025n

.meas tran vdout1_27ck1320 FIND v(dout1_27) AT=665.025n

.meas tran vdout1_28ck1320 FIND v(dout1_28) AT=665.025n

.meas tran vdout1_29ck1320 FIND v(dout1_29) AT=665.025n

.meas tran vdout1_30ck1320 FIND v(dout1_30) AT=665.025n

.meas tran vdout1_31ck1320 FIND v(dout1_31) AT=665.025n

.meas tran vdout1_32ck1320 FIND v(dout1_32) AT=665.025n

.meas tran vdout1_33ck1320 FIND v(dout1_33) AT=665.025n

.meas tran vdout1_34ck1320 FIND v(dout1_34) AT=665.025n

.meas tran vdout1_35ck1320 FIND v(dout1_35) AT=665.025n

.meas tran vdout1_36ck1320 FIND v(dout1_36) AT=665.025n

.meas tran vdout1_37ck1320 FIND v(dout1_37) AT=665.025n

.meas tran vdout1_38ck1320 FIND v(dout1_38) AT=665.025n

.meas tran vdout1_39ck1320 FIND v(dout1_39) AT=665.025n

.meas tran vdout1_40ck1320 FIND v(dout1_40) AT=665.025n

.meas tran vdout1_41ck1320 FIND v(dout1_41) AT=665.025n

.meas tran vdout1_42ck1320 FIND v(dout1_42) AT=665.025n

.meas tran vdout1_43ck1320 FIND v(dout1_43) AT=665.025n

.meas tran vdout1_44ck1320 FIND v(dout1_44) AT=665.025n

.meas tran vdout1_45ck1320 FIND v(dout1_45) AT=665.025n

.meas tran vdout1_46ck1320 FIND v(dout1_46) AT=665.025n

.meas tran vdout1_47ck1320 FIND v(dout1_47) AT=665.025n

.meas tran vdout1_48ck1320 FIND v(dout1_48) AT=665.025n

.meas tran vdout1_49ck1320 FIND v(dout1_49) AT=665.025n

.meas tran vdout1_50ck1320 FIND v(dout1_50) AT=665.025n

.meas tran vdout1_51ck1320 FIND v(dout1_51) AT=665.025n

.meas tran vdout1_52ck1320 FIND v(dout1_52) AT=665.025n

.meas tran vdout1_53ck1320 FIND v(dout1_53) AT=665.025n

.meas tran vdout1_54ck1320 FIND v(dout1_54) AT=665.025n

.meas tran vdout1_55ck1320 FIND v(dout1_55) AT=665.025n

.meas tran vdout1_56ck1320 FIND v(dout1_56) AT=665.025n

.meas tran vdout1_57ck1320 FIND v(dout1_57) AT=665.025n

.meas tran vdout1_58ck1320 FIND v(dout1_58) AT=665.025n

.meas tran vdout1_59ck1320 FIND v(dout1_59) AT=665.025n

.meas tran vdout1_60ck1320 FIND v(dout1_60) AT=665.025n

.meas tran vdout1_61ck1320 FIND v(dout1_61) AT=665.025n

.meas tran vdout1_62ck1320 FIND v(dout1_62) AT=665.025n

.meas tran vdout1_63ck1320 FIND v(dout1_63) AT=665.025n

.meas tran vdout1_64ck1320 FIND v(dout1_64) AT=665.025n

.meas tran vdout1_65ck1320 FIND v(dout1_65) AT=665.025n

.meas tran vdout1_66ck1320 FIND v(dout1_66) AT=665.025n

.meas tran vdout1_67ck1320 FIND v(dout1_67) AT=665.025n

.meas tran vdout1_68ck1320 FIND v(dout1_68) AT=665.025n

.meas tran vdout1_69ck1320 FIND v(dout1_69) AT=665.025n

.meas tran vdout1_70ck1320 FIND v(dout1_70) AT=665.025n

.meas tran vdout1_71ck1320 FIND v(dout1_71) AT=665.025n

.meas tran vdout1_72ck1320 FIND v(dout1_72) AT=665.025n

.meas tran vdout1_73ck1320 FIND v(dout1_73) AT=665.025n

.meas tran vdout1_74ck1320 FIND v(dout1_74) AT=665.025n

.meas tran vdout1_75ck1320 FIND v(dout1_75) AT=665.025n

.meas tran vdout1_76ck1320 FIND v(dout1_76) AT=665.025n

.meas tran vdout1_77ck1320 FIND v(dout1_77) AT=665.025n

.meas tran vdout1_78ck1320 FIND v(dout1_78) AT=665.025n

.meas tran vdout1_79ck1320 FIND v(dout1_79) AT=665.025n

.meas tran vdout1_80ck1320 FIND v(dout1_80) AT=665.025n

.meas tran vdout1_81ck1320 FIND v(dout1_81) AT=665.025n

.meas tran vdout1_82ck1320 FIND v(dout1_82) AT=665.025n

.meas tran vdout1_83ck1320 FIND v(dout1_83) AT=665.025n

.meas tran vdout1_84ck1320 FIND v(dout1_84) AT=665.025n

.meas tran vdout1_85ck1320 FIND v(dout1_85) AT=665.025n

.meas tran vdout1_86ck1320 FIND v(dout1_86) AT=665.025n

.meas tran vdout1_87ck1320 FIND v(dout1_87) AT=665.025n

.meas tran vdout1_88ck1320 FIND v(dout1_88) AT=665.025n

.meas tran vdout1_89ck1320 FIND v(dout1_89) AT=665.025n

.meas tran vdout1_90ck1320 FIND v(dout1_90) AT=665.025n

.meas tran vdout1_91ck1320 FIND v(dout1_91) AT=665.025n

.meas tran vdout1_92ck1320 FIND v(dout1_92) AT=665.025n

.meas tran vdout1_93ck1320 FIND v(dout1_93) AT=665.025n

.meas tran vdout1_94ck1320 FIND v(dout1_94) AT=665.025n

.meas tran vdout1_95ck1320 FIND v(dout1_95) AT=665.025n

.meas tran vdout1_96ck1320 FIND v(dout1_96) AT=665.025n

.meas tran vdout1_97ck1320 FIND v(dout1_97) AT=665.025n

.meas tran vdout1_98ck1320 FIND v(dout1_98) AT=665.025n

.meas tran vdout1_99ck1320 FIND v(dout1_99) AT=665.025n

.meas tran vdout1_100ck1320 FIND v(dout1_100) AT=665.025n

.meas tran vdout1_101ck1320 FIND v(dout1_101) AT=665.025n

.meas tran vdout1_102ck1320 FIND v(dout1_102) AT=665.025n

.meas tran vdout1_103ck1320 FIND v(dout1_103) AT=665.025n

.meas tran vdout1_104ck1320 FIND v(dout1_104) AT=665.025n

.meas tran vdout1_105ck1320 FIND v(dout1_105) AT=665.025n

.meas tran vdout1_106ck1320 FIND v(dout1_106) AT=665.025n

.meas tran vdout1_107ck1320 FIND v(dout1_107) AT=665.025n

.meas tran vdout1_108ck1320 FIND v(dout1_108) AT=665.025n

.meas tran vdout1_109ck1320 FIND v(dout1_109) AT=665.025n

.meas tran vdout1_110ck1320 FIND v(dout1_110) AT=665.025n

.meas tran vdout1_111ck1320 FIND v(dout1_111) AT=665.025n

.meas tran vdout1_112ck1320 FIND v(dout1_112) AT=665.025n

.meas tran vdout1_113ck1320 FIND v(dout1_113) AT=665.025n

.meas tran vdout1_114ck1320 FIND v(dout1_114) AT=665.025n

.meas tran vdout1_115ck1320 FIND v(dout1_115) AT=665.025n

.meas tran vdout1_116ck1320 FIND v(dout1_116) AT=665.025n

.meas tran vdout1_117ck1320 FIND v(dout1_117) AT=665.025n

.meas tran vdout1_118ck1320 FIND v(dout1_118) AT=665.025n

.meas tran vdout1_119ck1320 FIND v(dout1_119) AT=665.025n

.meas tran vdout1_120ck1320 FIND v(dout1_120) AT=665.025n

.meas tran vdout1_121ck1320 FIND v(dout1_121) AT=665.025n

.meas tran vdout1_122ck1320 FIND v(dout1_122) AT=665.025n

.meas tran vdout1_123ck1320 FIND v(dout1_123) AT=665.025n

.meas tran vdout1_124ck1320 FIND v(dout1_124) AT=665.025n

.meas tran vdout1_125ck1320 FIND v(dout1_125) AT=665.025n

.meas tran vdout1_126ck1320 FIND v(dout1_126) AT=665.025n

.meas tran vdout1_127ck1320 FIND v(dout1_127) AT=665.025n

.meas tran vdout1_0ck1360 FIND v(dout1_0) AT=685.025n

.meas tran vdout1_1ck1360 FIND v(dout1_1) AT=685.025n

.meas tran vdout1_2ck1360 FIND v(dout1_2) AT=685.025n

.meas tran vdout1_3ck1360 FIND v(dout1_3) AT=685.025n

.meas tran vdout1_4ck1360 FIND v(dout1_4) AT=685.025n

.meas tran vdout1_5ck1360 FIND v(dout1_5) AT=685.025n

.meas tran vdout1_6ck1360 FIND v(dout1_6) AT=685.025n

.meas tran vdout1_7ck1360 FIND v(dout1_7) AT=685.025n

.meas tran vdout1_8ck1360 FIND v(dout1_8) AT=685.025n

.meas tran vdout1_9ck1360 FIND v(dout1_9) AT=685.025n

.meas tran vdout1_10ck1360 FIND v(dout1_10) AT=685.025n

.meas tran vdout1_11ck1360 FIND v(dout1_11) AT=685.025n

.meas tran vdout1_12ck1360 FIND v(dout1_12) AT=685.025n

.meas tran vdout1_13ck1360 FIND v(dout1_13) AT=685.025n

.meas tran vdout1_14ck1360 FIND v(dout1_14) AT=685.025n

.meas tran vdout1_15ck1360 FIND v(dout1_15) AT=685.025n

.meas tran vdout1_16ck1360 FIND v(dout1_16) AT=685.025n

.meas tran vdout1_17ck1360 FIND v(dout1_17) AT=685.025n

.meas tran vdout1_18ck1360 FIND v(dout1_18) AT=685.025n

.meas tran vdout1_19ck1360 FIND v(dout1_19) AT=685.025n

.meas tran vdout1_20ck1360 FIND v(dout1_20) AT=685.025n

.meas tran vdout1_21ck1360 FIND v(dout1_21) AT=685.025n

.meas tran vdout1_22ck1360 FIND v(dout1_22) AT=685.025n

.meas tran vdout1_23ck1360 FIND v(dout1_23) AT=685.025n

.meas tran vdout1_24ck1360 FIND v(dout1_24) AT=685.025n

.meas tran vdout1_25ck1360 FIND v(dout1_25) AT=685.025n

.meas tran vdout1_26ck1360 FIND v(dout1_26) AT=685.025n

.meas tran vdout1_27ck1360 FIND v(dout1_27) AT=685.025n

.meas tran vdout1_28ck1360 FIND v(dout1_28) AT=685.025n

.meas tran vdout1_29ck1360 FIND v(dout1_29) AT=685.025n

.meas tran vdout1_30ck1360 FIND v(dout1_30) AT=685.025n

.meas tran vdout1_31ck1360 FIND v(dout1_31) AT=685.025n

.meas tran vdout1_32ck1360 FIND v(dout1_32) AT=685.025n

.meas tran vdout1_33ck1360 FIND v(dout1_33) AT=685.025n

.meas tran vdout1_34ck1360 FIND v(dout1_34) AT=685.025n

.meas tran vdout1_35ck1360 FIND v(dout1_35) AT=685.025n

.meas tran vdout1_36ck1360 FIND v(dout1_36) AT=685.025n

.meas tran vdout1_37ck1360 FIND v(dout1_37) AT=685.025n

.meas tran vdout1_38ck1360 FIND v(dout1_38) AT=685.025n

.meas tran vdout1_39ck1360 FIND v(dout1_39) AT=685.025n

.meas tran vdout1_40ck1360 FIND v(dout1_40) AT=685.025n

.meas tran vdout1_41ck1360 FIND v(dout1_41) AT=685.025n

.meas tran vdout1_42ck1360 FIND v(dout1_42) AT=685.025n

.meas tran vdout1_43ck1360 FIND v(dout1_43) AT=685.025n

.meas tran vdout1_44ck1360 FIND v(dout1_44) AT=685.025n

.meas tran vdout1_45ck1360 FIND v(dout1_45) AT=685.025n

.meas tran vdout1_46ck1360 FIND v(dout1_46) AT=685.025n

.meas tran vdout1_47ck1360 FIND v(dout1_47) AT=685.025n

.meas tran vdout1_48ck1360 FIND v(dout1_48) AT=685.025n

.meas tran vdout1_49ck1360 FIND v(dout1_49) AT=685.025n

.meas tran vdout1_50ck1360 FIND v(dout1_50) AT=685.025n

.meas tran vdout1_51ck1360 FIND v(dout1_51) AT=685.025n

.meas tran vdout1_52ck1360 FIND v(dout1_52) AT=685.025n

.meas tran vdout1_53ck1360 FIND v(dout1_53) AT=685.025n

.meas tran vdout1_54ck1360 FIND v(dout1_54) AT=685.025n

.meas tran vdout1_55ck1360 FIND v(dout1_55) AT=685.025n

.meas tran vdout1_56ck1360 FIND v(dout1_56) AT=685.025n

.meas tran vdout1_57ck1360 FIND v(dout1_57) AT=685.025n

.meas tran vdout1_58ck1360 FIND v(dout1_58) AT=685.025n

.meas tran vdout1_59ck1360 FIND v(dout1_59) AT=685.025n

.meas tran vdout1_60ck1360 FIND v(dout1_60) AT=685.025n

.meas tran vdout1_61ck1360 FIND v(dout1_61) AT=685.025n

.meas tran vdout1_62ck1360 FIND v(dout1_62) AT=685.025n

.meas tran vdout1_63ck1360 FIND v(dout1_63) AT=685.025n

.meas tran vdout1_64ck1360 FIND v(dout1_64) AT=685.025n

.meas tran vdout1_65ck1360 FIND v(dout1_65) AT=685.025n

.meas tran vdout1_66ck1360 FIND v(dout1_66) AT=685.025n

.meas tran vdout1_67ck1360 FIND v(dout1_67) AT=685.025n

.meas tran vdout1_68ck1360 FIND v(dout1_68) AT=685.025n

.meas tran vdout1_69ck1360 FIND v(dout1_69) AT=685.025n

.meas tran vdout1_70ck1360 FIND v(dout1_70) AT=685.025n

.meas tran vdout1_71ck1360 FIND v(dout1_71) AT=685.025n

.meas tran vdout1_72ck1360 FIND v(dout1_72) AT=685.025n

.meas tran vdout1_73ck1360 FIND v(dout1_73) AT=685.025n

.meas tran vdout1_74ck1360 FIND v(dout1_74) AT=685.025n

.meas tran vdout1_75ck1360 FIND v(dout1_75) AT=685.025n

.meas tran vdout1_76ck1360 FIND v(dout1_76) AT=685.025n

.meas tran vdout1_77ck1360 FIND v(dout1_77) AT=685.025n

.meas tran vdout1_78ck1360 FIND v(dout1_78) AT=685.025n

.meas tran vdout1_79ck1360 FIND v(dout1_79) AT=685.025n

.meas tran vdout1_80ck1360 FIND v(dout1_80) AT=685.025n

.meas tran vdout1_81ck1360 FIND v(dout1_81) AT=685.025n

.meas tran vdout1_82ck1360 FIND v(dout1_82) AT=685.025n

.meas tran vdout1_83ck1360 FIND v(dout1_83) AT=685.025n

.meas tran vdout1_84ck1360 FIND v(dout1_84) AT=685.025n

.meas tran vdout1_85ck1360 FIND v(dout1_85) AT=685.025n

.meas tran vdout1_86ck1360 FIND v(dout1_86) AT=685.025n

.meas tran vdout1_87ck1360 FIND v(dout1_87) AT=685.025n

.meas tran vdout1_88ck1360 FIND v(dout1_88) AT=685.025n

.meas tran vdout1_89ck1360 FIND v(dout1_89) AT=685.025n

.meas tran vdout1_90ck1360 FIND v(dout1_90) AT=685.025n

.meas tran vdout1_91ck1360 FIND v(dout1_91) AT=685.025n

.meas tran vdout1_92ck1360 FIND v(dout1_92) AT=685.025n

.meas tran vdout1_93ck1360 FIND v(dout1_93) AT=685.025n

.meas tran vdout1_94ck1360 FIND v(dout1_94) AT=685.025n

.meas tran vdout1_95ck1360 FIND v(dout1_95) AT=685.025n

.meas tran vdout1_96ck1360 FIND v(dout1_96) AT=685.025n

.meas tran vdout1_97ck1360 FIND v(dout1_97) AT=685.025n

.meas tran vdout1_98ck1360 FIND v(dout1_98) AT=685.025n

.meas tran vdout1_99ck1360 FIND v(dout1_99) AT=685.025n

.meas tran vdout1_100ck1360 FIND v(dout1_100) AT=685.025n

.meas tran vdout1_101ck1360 FIND v(dout1_101) AT=685.025n

.meas tran vdout1_102ck1360 FIND v(dout1_102) AT=685.025n

.meas tran vdout1_103ck1360 FIND v(dout1_103) AT=685.025n

.meas tran vdout1_104ck1360 FIND v(dout1_104) AT=685.025n

.meas tran vdout1_105ck1360 FIND v(dout1_105) AT=685.025n

.meas tran vdout1_106ck1360 FIND v(dout1_106) AT=685.025n

.meas tran vdout1_107ck1360 FIND v(dout1_107) AT=685.025n

.meas tran vdout1_108ck1360 FIND v(dout1_108) AT=685.025n

.meas tran vdout1_109ck1360 FIND v(dout1_109) AT=685.025n

.meas tran vdout1_110ck1360 FIND v(dout1_110) AT=685.025n

.meas tran vdout1_111ck1360 FIND v(dout1_111) AT=685.025n

.meas tran vdout1_112ck1360 FIND v(dout1_112) AT=685.025n

.meas tran vdout1_113ck1360 FIND v(dout1_113) AT=685.025n

.meas tran vdout1_114ck1360 FIND v(dout1_114) AT=685.025n

.meas tran vdout1_115ck1360 FIND v(dout1_115) AT=685.025n

.meas tran vdout1_116ck1360 FIND v(dout1_116) AT=685.025n

.meas tran vdout1_117ck1360 FIND v(dout1_117) AT=685.025n

.meas tran vdout1_118ck1360 FIND v(dout1_118) AT=685.025n

.meas tran vdout1_119ck1360 FIND v(dout1_119) AT=685.025n

.meas tran vdout1_120ck1360 FIND v(dout1_120) AT=685.025n

.meas tran vdout1_121ck1360 FIND v(dout1_121) AT=685.025n

.meas tran vdout1_122ck1360 FIND v(dout1_122) AT=685.025n

.meas tran vdout1_123ck1360 FIND v(dout1_123) AT=685.025n

.meas tran vdout1_124ck1360 FIND v(dout1_124) AT=685.025n

.meas tran vdout1_125ck1360 FIND v(dout1_125) AT=685.025n

.meas tran vdout1_126ck1360 FIND v(dout1_126) AT=685.025n

.meas tran vdout1_127ck1360 FIND v(dout1_127) AT=685.025n

.meas tran vdout1_0ck1370 FIND v(dout1_0) AT=690.025n

.meas tran vdout1_1ck1370 FIND v(dout1_1) AT=690.025n

.meas tran vdout1_2ck1370 FIND v(dout1_2) AT=690.025n

.meas tran vdout1_3ck1370 FIND v(dout1_3) AT=690.025n

.meas tran vdout1_4ck1370 FIND v(dout1_4) AT=690.025n

.meas tran vdout1_5ck1370 FIND v(dout1_5) AT=690.025n

.meas tran vdout1_6ck1370 FIND v(dout1_6) AT=690.025n

.meas tran vdout1_7ck1370 FIND v(dout1_7) AT=690.025n

.meas tran vdout1_8ck1370 FIND v(dout1_8) AT=690.025n

.meas tran vdout1_9ck1370 FIND v(dout1_9) AT=690.025n

.meas tran vdout1_10ck1370 FIND v(dout1_10) AT=690.025n

.meas tran vdout1_11ck1370 FIND v(dout1_11) AT=690.025n

.meas tran vdout1_12ck1370 FIND v(dout1_12) AT=690.025n

.meas tran vdout1_13ck1370 FIND v(dout1_13) AT=690.025n

.meas tran vdout1_14ck1370 FIND v(dout1_14) AT=690.025n

.meas tran vdout1_15ck1370 FIND v(dout1_15) AT=690.025n

.meas tran vdout1_16ck1370 FIND v(dout1_16) AT=690.025n

.meas tran vdout1_17ck1370 FIND v(dout1_17) AT=690.025n

.meas tran vdout1_18ck1370 FIND v(dout1_18) AT=690.025n

.meas tran vdout1_19ck1370 FIND v(dout1_19) AT=690.025n

.meas tran vdout1_20ck1370 FIND v(dout1_20) AT=690.025n

.meas tran vdout1_21ck1370 FIND v(dout1_21) AT=690.025n

.meas tran vdout1_22ck1370 FIND v(dout1_22) AT=690.025n

.meas tran vdout1_23ck1370 FIND v(dout1_23) AT=690.025n

.meas tran vdout1_24ck1370 FIND v(dout1_24) AT=690.025n

.meas tran vdout1_25ck1370 FIND v(dout1_25) AT=690.025n

.meas tran vdout1_26ck1370 FIND v(dout1_26) AT=690.025n

.meas tran vdout1_27ck1370 FIND v(dout1_27) AT=690.025n

.meas tran vdout1_28ck1370 FIND v(dout1_28) AT=690.025n

.meas tran vdout1_29ck1370 FIND v(dout1_29) AT=690.025n

.meas tran vdout1_30ck1370 FIND v(dout1_30) AT=690.025n

.meas tran vdout1_31ck1370 FIND v(dout1_31) AT=690.025n

.meas tran vdout1_32ck1370 FIND v(dout1_32) AT=690.025n

.meas tran vdout1_33ck1370 FIND v(dout1_33) AT=690.025n

.meas tran vdout1_34ck1370 FIND v(dout1_34) AT=690.025n

.meas tran vdout1_35ck1370 FIND v(dout1_35) AT=690.025n

.meas tran vdout1_36ck1370 FIND v(dout1_36) AT=690.025n

.meas tran vdout1_37ck1370 FIND v(dout1_37) AT=690.025n

.meas tran vdout1_38ck1370 FIND v(dout1_38) AT=690.025n

.meas tran vdout1_39ck1370 FIND v(dout1_39) AT=690.025n

.meas tran vdout1_40ck1370 FIND v(dout1_40) AT=690.025n

.meas tran vdout1_41ck1370 FIND v(dout1_41) AT=690.025n

.meas tran vdout1_42ck1370 FIND v(dout1_42) AT=690.025n

.meas tran vdout1_43ck1370 FIND v(dout1_43) AT=690.025n

.meas tran vdout1_44ck1370 FIND v(dout1_44) AT=690.025n

.meas tran vdout1_45ck1370 FIND v(dout1_45) AT=690.025n

.meas tran vdout1_46ck1370 FIND v(dout1_46) AT=690.025n

.meas tran vdout1_47ck1370 FIND v(dout1_47) AT=690.025n

.meas tran vdout1_48ck1370 FIND v(dout1_48) AT=690.025n

.meas tran vdout1_49ck1370 FIND v(dout1_49) AT=690.025n

.meas tran vdout1_50ck1370 FIND v(dout1_50) AT=690.025n

.meas tran vdout1_51ck1370 FIND v(dout1_51) AT=690.025n

.meas tran vdout1_52ck1370 FIND v(dout1_52) AT=690.025n

.meas tran vdout1_53ck1370 FIND v(dout1_53) AT=690.025n

.meas tran vdout1_54ck1370 FIND v(dout1_54) AT=690.025n

.meas tran vdout1_55ck1370 FIND v(dout1_55) AT=690.025n

.meas tran vdout1_56ck1370 FIND v(dout1_56) AT=690.025n

.meas tran vdout1_57ck1370 FIND v(dout1_57) AT=690.025n

.meas tran vdout1_58ck1370 FIND v(dout1_58) AT=690.025n

.meas tran vdout1_59ck1370 FIND v(dout1_59) AT=690.025n

.meas tran vdout1_60ck1370 FIND v(dout1_60) AT=690.025n

.meas tran vdout1_61ck1370 FIND v(dout1_61) AT=690.025n

.meas tran vdout1_62ck1370 FIND v(dout1_62) AT=690.025n

.meas tran vdout1_63ck1370 FIND v(dout1_63) AT=690.025n

.meas tran vdout1_64ck1370 FIND v(dout1_64) AT=690.025n

.meas tran vdout1_65ck1370 FIND v(dout1_65) AT=690.025n

.meas tran vdout1_66ck1370 FIND v(dout1_66) AT=690.025n

.meas tran vdout1_67ck1370 FIND v(dout1_67) AT=690.025n

.meas tran vdout1_68ck1370 FIND v(dout1_68) AT=690.025n

.meas tran vdout1_69ck1370 FIND v(dout1_69) AT=690.025n

.meas tran vdout1_70ck1370 FIND v(dout1_70) AT=690.025n

.meas tran vdout1_71ck1370 FIND v(dout1_71) AT=690.025n

.meas tran vdout1_72ck1370 FIND v(dout1_72) AT=690.025n

.meas tran vdout1_73ck1370 FIND v(dout1_73) AT=690.025n

.meas tran vdout1_74ck1370 FIND v(dout1_74) AT=690.025n

.meas tran vdout1_75ck1370 FIND v(dout1_75) AT=690.025n

.meas tran vdout1_76ck1370 FIND v(dout1_76) AT=690.025n

.meas tran vdout1_77ck1370 FIND v(dout1_77) AT=690.025n

.meas tran vdout1_78ck1370 FIND v(dout1_78) AT=690.025n

.meas tran vdout1_79ck1370 FIND v(dout1_79) AT=690.025n

.meas tran vdout1_80ck1370 FIND v(dout1_80) AT=690.025n

.meas tran vdout1_81ck1370 FIND v(dout1_81) AT=690.025n

.meas tran vdout1_82ck1370 FIND v(dout1_82) AT=690.025n

.meas tran vdout1_83ck1370 FIND v(dout1_83) AT=690.025n

.meas tran vdout1_84ck1370 FIND v(dout1_84) AT=690.025n

.meas tran vdout1_85ck1370 FIND v(dout1_85) AT=690.025n

.meas tran vdout1_86ck1370 FIND v(dout1_86) AT=690.025n

.meas tran vdout1_87ck1370 FIND v(dout1_87) AT=690.025n

.meas tran vdout1_88ck1370 FIND v(dout1_88) AT=690.025n

.meas tran vdout1_89ck1370 FIND v(dout1_89) AT=690.025n

.meas tran vdout1_90ck1370 FIND v(dout1_90) AT=690.025n

.meas tran vdout1_91ck1370 FIND v(dout1_91) AT=690.025n

.meas tran vdout1_92ck1370 FIND v(dout1_92) AT=690.025n

.meas tran vdout1_93ck1370 FIND v(dout1_93) AT=690.025n

.meas tran vdout1_94ck1370 FIND v(dout1_94) AT=690.025n

.meas tran vdout1_95ck1370 FIND v(dout1_95) AT=690.025n

.meas tran vdout1_96ck1370 FIND v(dout1_96) AT=690.025n

.meas tran vdout1_97ck1370 FIND v(dout1_97) AT=690.025n

.meas tran vdout1_98ck1370 FIND v(dout1_98) AT=690.025n

.meas tran vdout1_99ck1370 FIND v(dout1_99) AT=690.025n

.meas tran vdout1_100ck1370 FIND v(dout1_100) AT=690.025n

.meas tran vdout1_101ck1370 FIND v(dout1_101) AT=690.025n

.meas tran vdout1_102ck1370 FIND v(dout1_102) AT=690.025n

.meas tran vdout1_103ck1370 FIND v(dout1_103) AT=690.025n

.meas tran vdout1_104ck1370 FIND v(dout1_104) AT=690.025n

.meas tran vdout1_105ck1370 FIND v(dout1_105) AT=690.025n

.meas tran vdout1_106ck1370 FIND v(dout1_106) AT=690.025n

.meas tran vdout1_107ck1370 FIND v(dout1_107) AT=690.025n

.meas tran vdout1_108ck1370 FIND v(dout1_108) AT=690.025n

.meas tran vdout1_109ck1370 FIND v(dout1_109) AT=690.025n

.meas tran vdout1_110ck1370 FIND v(dout1_110) AT=690.025n

.meas tran vdout1_111ck1370 FIND v(dout1_111) AT=690.025n

.meas tran vdout1_112ck1370 FIND v(dout1_112) AT=690.025n

.meas tran vdout1_113ck1370 FIND v(dout1_113) AT=690.025n

.meas tran vdout1_114ck1370 FIND v(dout1_114) AT=690.025n

.meas tran vdout1_115ck1370 FIND v(dout1_115) AT=690.025n

.meas tran vdout1_116ck1370 FIND v(dout1_116) AT=690.025n

.meas tran vdout1_117ck1370 FIND v(dout1_117) AT=690.025n

.meas tran vdout1_118ck1370 FIND v(dout1_118) AT=690.025n

.meas tran vdout1_119ck1370 FIND v(dout1_119) AT=690.025n

.meas tran vdout1_120ck1370 FIND v(dout1_120) AT=690.025n

.meas tran vdout1_121ck1370 FIND v(dout1_121) AT=690.025n

.meas tran vdout1_122ck1370 FIND v(dout1_122) AT=690.025n

.meas tran vdout1_123ck1370 FIND v(dout1_123) AT=690.025n

.meas tran vdout1_124ck1370 FIND v(dout1_124) AT=690.025n

.meas tran vdout1_125ck1370 FIND v(dout1_125) AT=690.025n

.meas tran vdout1_126ck1370 FIND v(dout1_126) AT=690.025n

.meas tran vdout1_127ck1370 FIND v(dout1_127) AT=690.025n

.meas tran vdout1_0ck1400 FIND v(dout1_0) AT=705.025n

.meas tran vdout1_1ck1400 FIND v(dout1_1) AT=705.025n

.meas tran vdout1_2ck1400 FIND v(dout1_2) AT=705.025n

.meas tran vdout1_3ck1400 FIND v(dout1_3) AT=705.025n

.meas tran vdout1_4ck1400 FIND v(dout1_4) AT=705.025n

.meas tran vdout1_5ck1400 FIND v(dout1_5) AT=705.025n

.meas tran vdout1_6ck1400 FIND v(dout1_6) AT=705.025n

.meas tran vdout1_7ck1400 FIND v(dout1_7) AT=705.025n

.meas tran vdout1_8ck1400 FIND v(dout1_8) AT=705.025n

.meas tran vdout1_9ck1400 FIND v(dout1_9) AT=705.025n

.meas tran vdout1_10ck1400 FIND v(dout1_10) AT=705.025n

.meas tran vdout1_11ck1400 FIND v(dout1_11) AT=705.025n

.meas tran vdout1_12ck1400 FIND v(dout1_12) AT=705.025n

.meas tran vdout1_13ck1400 FIND v(dout1_13) AT=705.025n

.meas tran vdout1_14ck1400 FIND v(dout1_14) AT=705.025n

.meas tran vdout1_15ck1400 FIND v(dout1_15) AT=705.025n

.meas tran vdout1_16ck1400 FIND v(dout1_16) AT=705.025n

.meas tran vdout1_17ck1400 FIND v(dout1_17) AT=705.025n

.meas tran vdout1_18ck1400 FIND v(dout1_18) AT=705.025n

.meas tran vdout1_19ck1400 FIND v(dout1_19) AT=705.025n

.meas tran vdout1_20ck1400 FIND v(dout1_20) AT=705.025n

.meas tran vdout1_21ck1400 FIND v(dout1_21) AT=705.025n

.meas tran vdout1_22ck1400 FIND v(dout1_22) AT=705.025n

.meas tran vdout1_23ck1400 FIND v(dout1_23) AT=705.025n

.meas tran vdout1_24ck1400 FIND v(dout1_24) AT=705.025n

.meas tran vdout1_25ck1400 FIND v(dout1_25) AT=705.025n

.meas tran vdout1_26ck1400 FIND v(dout1_26) AT=705.025n

.meas tran vdout1_27ck1400 FIND v(dout1_27) AT=705.025n

.meas tran vdout1_28ck1400 FIND v(dout1_28) AT=705.025n

.meas tran vdout1_29ck1400 FIND v(dout1_29) AT=705.025n

.meas tran vdout1_30ck1400 FIND v(dout1_30) AT=705.025n

.meas tran vdout1_31ck1400 FIND v(dout1_31) AT=705.025n

.meas tran vdout1_32ck1400 FIND v(dout1_32) AT=705.025n

.meas tran vdout1_33ck1400 FIND v(dout1_33) AT=705.025n

.meas tran vdout1_34ck1400 FIND v(dout1_34) AT=705.025n

.meas tran vdout1_35ck1400 FIND v(dout1_35) AT=705.025n

.meas tran vdout1_36ck1400 FIND v(dout1_36) AT=705.025n

.meas tran vdout1_37ck1400 FIND v(dout1_37) AT=705.025n

.meas tran vdout1_38ck1400 FIND v(dout1_38) AT=705.025n

.meas tran vdout1_39ck1400 FIND v(dout1_39) AT=705.025n

.meas tran vdout1_40ck1400 FIND v(dout1_40) AT=705.025n

.meas tran vdout1_41ck1400 FIND v(dout1_41) AT=705.025n

.meas tran vdout1_42ck1400 FIND v(dout1_42) AT=705.025n

.meas tran vdout1_43ck1400 FIND v(dout1_43) AT=705.025n

.meas tran vdout1_44ck1400 FIND v(dout1_44) AT=705.025n

.meas tran vdout1_45ck1400 FIND v(dout1_45) AT=705.025n

.meas tran vdout1_46ck1400 FIND v(dout1_46) AT=705.025n

.meas tran vdout1_47ck1400 FIND v(dout1_47) AT=705.025n

.meas tran vdout1_48ck1400 FIND v(dout1_48) AT=705.025n

.meas tran vdout1_49ck1400 FIND v(dout1_49) AT=705.025n

.meas tran vdout1_50ck1400 FIND v(dout1_50) AT=705.025n

.meas tran vdout1_51ck1400 FIND v(dout1_51) AT=705.025n

.meas tran vdout1_52ck1400 FIND v(dout1_52) AT=705.025n

.meas tran vdout1_53ck1400 FIND v(dout1_53) AT=705.025n

.meas tran vdout1_54ck1400 FIND v(dout1_54) AT=705.025n

.meas tran vdout1_55ck1400 FIND v(dout1_55) AT=705.025n

.meas tran vdout1_56ck1400 FIND v(dout1_56) AT=705.025n

.meas tran vdout1_57ck1400 FIND v(dout1_57) AT=705.025n

.meas tran vdout1_58ck1400 FIND v(dout1_58) AT=705.025n

.meas tran vdout1_59ck1400 FIND v(dout1_59) AT=705.025n

.meas tran vdout1_60ck1400 FIND v(dout1_60) AT=705.025n

.meas tran vdout1_61ck1400 FIND v(dout1_61) AT=705.025n

.meas tran vdout1_62ck1400 FIND v(dout1_62) AT=705.025n

.meas tran vdout1_63ck1400 FIND v(dout1_63) AT=705.025n

.meas tran vdout1_64ck1400 FIND v(dout1_64) AT=705.025n

.meas tran vdout1_65ck1400 FIND v(dout1_65) AT=705.025n

.meas tran vdout1_66ck1400 FIND v(dout1_66) AT=705.025n

.meas tran vdout1_67ck1400 FIND v(dout1_67) AT=705.025n

.meas tran vdout1_68ck1400 FIND v(dout1_68) AT=705.025n

.meas tran vdout1_69ck1400 FIND v(dout1_69) AT=705.025n

.meas tran vdout1_70ck1400 FIND v(dout1_70) AT=705.025n

.meas tran vdout1_71ck1400 FIND v(dout1_71) AT=705.025n

.meas tran vdout1_72ck1400 FIND v(dout1_72) AT=705.025n

.meas tran vdout1_73ck1400 FIND v(dout1_73) AT=705.025n

.meas tran vdout1_74ck1400 FIND v(dout1_74) AT=705.025n

.meas tran vdout1_75ck1400 FIND v(dout1_75) AT=705.025n

.meas tran vdout1_76ck1400 FIND v(dout1_76) AT=705.025n

.meas tran vdout1_77ck1400 FIND v(dout1_77) AT=705.025n

.meas tran vdout1_78ck1400 FIND v(dout1_78) AT=705.025n

.meas tran vdout1_79ck1400 FIND v(dout1_79) AT=705.025n

.meas tran vdout1_80ck1400 FIND v(dout1_80) AT=705.025n

.meas tran vdout1_81ck1400 FIND v(dout1_81) AT=705.025n

.meas tran vdout1_82ck1400 FIND v(dout1_82) AT=705.025n

.meas tran vdout1_83ck1400 FIND v(dout1_83) AT=705.025n

.meas tran vdout1_84ck1400 FIND v(dout1_84) AT=705.025n

.meas tran vdout1_85ck1400 FIND v(dout1_85) AT=705.025n

.meas tran vdout1_86ck1400 FIND v(dout1_86) AT=705.025n

.meas tran vdout1_87ck1400 FIND v(dout1_87) AT=705.025n

.meas tran vdout1_88ck1400 FIND v(dout1_88) AT=705.025n

.meas tran vdout1_89ck1400 FIND v(dout1_89) AT=705.025n

.meas tran vdout1_90ck1400 FIND v(dout1_90) AT=705.025n

.meas tran vdout1_91ck1400 FIND v(dout1_91) AT=705.025n

.meas tran vdout1_92ck1400 FIND v(dout1_92) AT=705.025n

.meas tran vdout1_93ck1400 FIND v(dout1_93) AT=705.025n

.meas tran vdout1_94ck1400 FIND v(dout1_94) AT=705.025n

.meas tran vdout1_95ck1400 FIND v(dout1_95) AT=705.025n

.meas tran vdout1_96ck1400 FIND v(dout1_96) AT=705.025n

.meas tran vdout1_97ck1400 FIND v(dout1_97) AT=705.025n

.meas tran vdout1_98ck1400 FIND v(dout1_98) AT=705.025n

.meas tran vdout1_99ck1400 FIND v(dout1_99) AT=705.025n

.meas tran vdout1_100ck1400 FIND v(dout1_100) AT=705.025n

.meas tran vdout1_101ck1400 FIND v(dout1_101) AT=705.025n

.meas tran vdout1_102ck1400 FIND v(dout1_102) AT=705.025n

.meas tran vdout1_103ck1400 FIND v(dout1_103) AT=705.025n

.meas tran vdout1_104ck1400 FIND v(dout1_104) AT=705.025n

.meas tran vdout1_105ck1400 FIND v(dout1_105) AT=705.025n

.meas tran vdout1_106ck1400 FIND v(dout1_106) AT=705.025n

.meas tran vdout1_107ck1400 FIND v(dout1_107) AT=705.025n

.meas tran vdout1_108ck1400 FIND v(dout1_108) AT=705.025n

.meas tran vdout1_109ck1400 FIND v(dout1_109) AT=705.025n

.meas tran vdout1_110ck1400 FIND v(dout1_110) AT=705.025n

.meas tran vdout1_111ck1400 FIND v(dout1_111) AT=705.025n

.meas tran vdout1_112ck1400 FIND v(dout1_112) AT=705.025n

.meas tran vdout1_113ck1400 FIND v(dout1_113) AT=705.025n

.meas tran vdout1_114ck1400 FIND v(dout1_114) AT=705.025n

.meas tran vdout1_115ck1400 FIND v(dout1_115) AT=705.025n

.meas tran vdout1_116ck1400 FIND v(dout1_116) AT=705.025n

.meas tran vdout1_117ck1400 FIND v(dout1_117) AT=705.025n

.meas tran vdout1_118ck1400 FIND v(dout1_118) AT=705.025n

.meas tran vdout1_119ck1400 FIND v(dout1_119) AT=705.025n

.meas tran vdout1_120ck1400 FIND v(dout1_120) AT=705.025n

.meas tran vdout1_121ck1400 FIND v(dout1_121) AT=705.025n

.meas tran vdout1_122ck1400 FIND v(dout1_122) AT=705.025n

.meas tran vdout1_123ck1400 FIND v(dout1_123) AT=705.025n

.meas tran vdout1_124ck1400 FIND v(dout1_124) AT=705.025n

.meas tran vdout1_125ck1400 FIND v(dout1_125) AT=705.025n

.meas tran vdout1_126ck1400 FIND v(dout1_126) AT=705.025n

.meas tran vdout1_127ck1400 FIND v(dout1_127) AT=705.025n

.meas tran vdout1_0ck1420 FIND v(dout1_0) AT=715.025n

.meas tran vdout1_1ck1420 FIND v(dout1_1) AT=715.025n

.meas tran vdout1_2ck1420 FIND v(dout1_2) AT=715.025n

.meas tran vdout1_3ck1420 FIND v(dout1_3) AT=715.025n

.meas tran vdout1_4ck1420 FIND v(dout1_4) AT=715.025n

.meas tran vdout1_5ck1420 FIND v(dout1_5) AT=715.025n

.meas tran vdout1_6ck1420 FIND v(dout1_6) AT=715.025n

.meas tran vdout1_7ck1420 FIND v(dout1_7) AT=715.025n

.meas tran vdout1_8ck1420 FIND v(dout1_8) AT=715.025n

.meas tran vdout1_9ck1420 FIND v(dout1_9) AT=715.025n

.meas tran vdout1_10ck1420 FIND v(dout1_10) AT=715.025n

.meas tran vdout1_11ck1420 FIND v(dout1_11) AT=715.025n

.meas tran vdout1_12ck1420 FIND v(dout1_12) AT=715.025n

.meas tran vdout1_13ck1420 FIND v(dout1_13) AT=715.025n

.meas tran vdout1_14ck1420 FIND v(dout1_14) AT=715.025n

.meas tran vdout1_15ck1420 FIND v(dout1_15) AT=715.025n

.meas tran vdout1_16ck1420 FIND v(dout1_16) AT=715.025n

.meas tran vdout1_17ck1420 FIND v(dout1_17) AT=715.025n

.meas tran vdout1_18ck1420 FIND v(dout1_18) AT=715.025n

.meas tran vdout1_19ck1420 FIND v(dout1_19) AT=715.025n

.meas tran vdout1_20ck1420 FIND v(dout1_20) AT=715.025n

.meas tran vdout1_21ck1420 FIND v(dout1_21) AT=715.025n

.meas tran vdout1_22ck1420 FIND v(dout1_22) AT=715.025n

.meas tran vdout1_23ck1420 FIND v(dout1_23) AT=715.025n

.meas tran vdout1_24ck1420 FIND v(dout1_24) AT=715.025n

.meas tran vdout1_25ck1420 FIND v(dout1_25) AT=715.025n

.meas tran vdout1_26ck1420 FIND v(dout1_26) AT=715.025n

.meas tran vdout1_27ck1420 FIND v(dout1_27) AT=715.025n

.meas tran vdout1_28ck1420 FIND v(dout1_28) AT=715.025n

.meas tran vdout1_29ck1420 FIND v(dout1_29) AT=715.025n

.meas tran vdout1_30ck1420 FIND v(dout1_30) AT=715.025n

.meas tran vdout1_31ck1420 FIND v(dout1_31) AT=715.025n

.meas tran vdout1_32ck1420 FIND v(dout1_32) AT=715.025n

.meas tran vdout1_33ck1420 FIND v(dout1_33) AT=715.025n

.meas tran vdout1_34ck1420 FIND v(dout1_34) AT=715.025n

.meas tran vdout1_35ck1420 FIND v(dout1_35) AT=715.025n

.meas tran vdout1_36ck1420 FIND v(dout1_36) AT=715.025n

.meas tran vdout1_37ck1420 FIND v(dout1_37) AT=715.025n

.meas tran vdout1_38ck1420 FIND v(dout1_38) AT=715.025n

.meas tran vdout1_39ck1420 FIND v(dout1_39) AT=715.025n

.meas tran vdout1_40ck1420 FIND v(dout1_40) AT=715.025n

.meas tran vdout1_41ck1420 FIND v(dout1_41) AT=715.025n

.meas tran vdout1_42ck1420 FIND v(dout1_42) AT=715.025n

.meas tran vdout1_43ck1420 FIND v(dout1_43) AT=715.025n

.meas tran vdout1_44ck1420 FIND v(dout1_44) AT=715.025n

.meas tran vdout1_45ck1420 FIND v(dout1_45) AT=715.025n

.meas tran vdout1_46ck1420 FIND v(dout1_46) AT=715.025n

.meas tran vdout1_47ck1420 FIND v(dout1_47) AT=715.025n

.meas tran vdout1_48ck1420 FIND v(dout1_48) AT=715.025n

.meas tran vdout1_49ck1420 FIND v(dout1_49) AT=715.025n

.meas tran vdout1_50ck1420 FIND v(dout1_50) AT=715.025n

.meas tran vdout1_51ck1420 FIND v(dout1_51) AT=715.025n

.meas tran vdout1_52ck1420 FIND v(dout1_52) AT=715.025n

.meas tran vdout1_53ck1420 FIND v(dout1_53) AT=715.025n

.meas tran vdout1_54ck1420 FIND v(dout1_54) AT=715.025n

.meas tran vdout1_55ck1420 FIND v(dout1_55) AT=715.025n

.meas tran vdout1_56ck1420 FIND v(dout1_56) AT=715.025n

.meas tran vdout1_57ck1420 FIND v(dout1_57) AT=715.025n

.meas tran vdout1_58ck1420 FIND v(dout1_58) AT=715.025n

.meas tran vdout1_59ck1420 FIND v(dout1_59) AT=715.025n

.meas tran vdout1_60ck1420 FIND v(dout1_60) AT=715.025n

.meas tran vdout1_61ck1420 FIND v(dout1_61) AT=715.025n

.meas tran vdout1_62ck1420 FIND v(dout1_62) AT=715.025n

.meas tran vdout1_63ck1420 FIND v(dout1_63) AT=715.025n

.meas tran vdout1_64ck1420 FIND v(dout1_64) AT=715.025n

.meas tran vdout1_65ck1420 FIND v(dout1_65) AT=715.025n

.meas tran vdout1_66ck1420 FIND v(dout1_66) AT=715.025n

.meas tran vdout1_67ck1420 FIND v(dout1_67) AT=715.025n

.meas tran vdout1_68ck1420 FIND v(dout1_68) AT=715.025n

.meas tran vdout1_69ck1420 FIND v(dout1_69) AT=715.025n

.meas tran vdout1_70ck1420 FIND v(dout1_70) AT=715.025n

.meas tran vdout1_71ck1420 FIND v(dout1_71) AT=715.025n

.meas tran vdout1_72ck1420 FIND v(dout1_72) AT=715.025n

.meas tran vdout1_73ck1420 FIND v(dout1_73) AT=715.025n

.meas tran vdout1_74ck1420 FIND v(dout1_74) AT=715.025n

.meas tran vdout1_75ck1420 FIND v(dout1_75) AT=715.025n

.meas tran vdout1_76ck1420 FIND v(dout1_76) AT=715.025n

.meas tran vdout1_77ck1420 FIND v(dout1_77) AT=715.025n

.meas tran vdout1_78ck1420 FIND v(dout1_78) AT=715.025n

.meas tran vdout1_79ck1420 FIND v(dout1_79) AT=715.025n

.meas tran vdout1_80ck1420 FIND v(dout1_80) AT=715.025n

.meas tran vdout1_81ck1420 FIND v(dout1_81) AT=715.025n

.meas tran vdout1_82ck1420 FIND v(dout1_82) AT=715.025n

.meas tran vdout1_83ck1420 FIND v(dout1_83) AT=715.025n

.meas tran vdout1_84ck1420 FIND v(dout1_84) AT=715.025n

.meas tran vdout1_85ck1420 FIND v(dout1_85) AT=715.025n

.meas tran vdout1_86ck1420 FIND v(dout1_86) AT=715.025n

.meas tran vdout1_87ck1420 FIND v(dout1_87) AT=715.025n

.meas tran vdout1_88ck1420 FIND v(dout1_88) AT=715.025n

.meas tran vdout1_89ck1420 FIND v(dout1_89) AT=715.025n

.meas tran vdout1_90ck1420 FIND v(dout1_90) AT=715.025n

.meas tran vdout1_91ck1420 FIND v(dout1_91) AT=715.025n

.meas tran vdout1_92ck1420 FIND v(dout1_92) AT=715.025n

.meas tran vdout1_93ck1420 FIND v(dout1_93) AT=715.025n

.meas tran vdout1_94ck1420 FIND v(dout1_94) AT=715.025n

.meas tran vdout1_95ck1420 FIND v(dout1_95) AT=715.025n

.meas tran vdout1_96ck1420 FIND v(dout1_96) AT=715.025n

.meas tran vdout1_97ck1420 FIND v(dout1_97) AT=715.025n

.meas tran vdout1_98ck1420 FIND v(dout1_98) AT=715.025n

.meas tran vdout1_99ck1420 FIND v(dout1_99) AT=715.025n

.meas tran vdout1_100ck1420 FIND v(dout1_100) AT=715.025n

.meas tran vdout1_101ck1420 FIND v(dout1_101) AT=715.025n

.meas tran vdout1_102ck1420 FIND v(dout1_102) AT=715.025n

.meas tran vdout1_103ck1420 FIND v(dout1_103) AT=715.025n

.meas tran vdout1_104ck1420 FIND v(dout1_104) AT=715.025n

.meas tran vdout1_105ck1420 FIND v(dout1_105) AT=715.025n

.meas tran vdout1_106ck1420 FIND v(dout1_106) AT=715.025n

.meas tran vdout1_107ck1420 FIND v(dout1_107) AT=715.025n

.meas tran vdout1_108ck1420 FIND v(dout1_108) AT=715.025n

.meas tran vdout1_109ck1420 FIND v(dout1_109) AT=715.025n

.meas tran vdout1_110ck1420 FIND v(dout1_110) AT=715.025n

.meas tran vdout1_111ck1420 FIND v(dout1_111) AT=715.025n

.meas tran vdout1_112ck1420 FIND v(dout1_112) AT=715.025n

.meas tran vdout1_113ck1420 FIND v(dout1_113) AT=715.025n

.meas tran vdout1_114ck1420 FIND v(dout1_114) AT=715.025n

.meas tran vdout1_115ck1420 FIND v(dout1_115) AT=715.025n

.meas tran vdout1_116ck1420 FIND v(dout1_116) AT=715.025n

.meas tran vdout1_117ck1420 FIND v(dout1_117) AT=715.025n

.meas tran vdout1_118ck1420 FIND v(dout1_118) AT=715.025n

.meas tran vdout1_119ck1420 FIND v(dout1_119) AT=715.025n

.meas tran vdout1_120ck1420 FIND v(dout1_120) AT=715.025n

.meas tran vdout1_121ck1420 FIND v(dout1_121) AT=715.025n

.meas tran vdout1_122ck1420 FIND v(dout1_122) AT=715.025n

.meas tran vdout1_123ck1420 FIND v(dout1_123) AT=715.025n

.meas tran vdout1_124ck1420 FIND v(dout1_124) AT=715.025n

.meas tran vdout1_125ck1420 FIND v(dout1_125) AT=715.025n

.meas tran vdout1_126ck1420 FIND v(dout1_126) AT=715.025n

.meas tran vdout1_127ck1420 FIND v(dout1_127) AT=715.025n

.meas tran vdout1_0ck1430 FIND v(dout1_0) AT=720.025n

.meas tran vdout1_1ck1430 FIND v(dout1_1) AT=720.025n

.meas tran vdout1_2ck1430 FIND v(dout1_2) AT=720.025n

.meas tran vdout1_3ck1430 FIND v(dout1_3) AT=720.025n

.meas tran vdout1_4ck1430 FIND v(dout1_4) AT=720.025n

.meas tran vdout1_5ck1430 FIND v(dout1_5) AT=720.025n

.meas tran vdout1_6ck1430 FIND v(dout1_6) AT=720.025n

.meas tran vdout1_7ck1430 FIND v(dout1_7) AT=720.025n

.meas tran vdout1_8ck1430 FIND v(dout1_8) AT=720.025n

.meas tran vdout1_9ck1430 FIND v(dout1_9) AT=720.025n

.meas tran vdout1_10ck1430 FIND v(dout1_10) AT=720.025n

.meas tran vdout1_11ck1430 FIND v(dout1_11) AT=720.025n

.meas tran vdout1_12ck1430 FIND v(dout1_12) AT=720.025n

.meas tran vdout1_13ck1430 FIND v(dout1_13) AT=720.025n

.meas tran vdout1_14ck1430 FIND v(dout1_14) AT=720.025n

.meas tran vdout1_15ck1430 FIND v(dout1_15) AT=720.025n

.meas tran vdout1_16ck1430 FIND v(dout1_16) AT=720.025n

.meas tran vdout1_17ck1430 FIND v(dout1_17) AT=720.025n

.meas tran vdout1_18ck1430 FIND v(dout1_18) AT=720.025n

.meas tran vdout1_19ck1430 FIND v(dout1_19) AT=720.025n

.meas tran vdout1_20ck1430 FIND v(dout1_20) AT=720.025n

.meas tran vdout1_21ck1430 FIND v(dout1_21) AT=720.025n

.meas tran vdout1_22ck1430 FIND v(dout1_22) AT=720.025n

.meas tran vdout1_23ck1430 FIND v(dout1_23) AT=720.025n

.meas tran vdout1_24ck1430 FIND v(dout1_24) AT=720.025n

.meas tran vdout1_25ck1430 FIND v(dout1_25) AT=720.025n

.meas tran vdout1_26ck1430 FIND v(dout1_26) AT=720.025n

.meas tran vdout1_27ck1430 FIND v(dout1_27) AT=720.025n

.meas tran vdout1_28ck1430 FIND v(dout1_28) AT=720.025n

.meas tran vdout1_29ck1430 FIND v(dout1_29) AT=720.025n

.meas tran vdout1_30ck1430 FIND v(dout1_30) AT=720.025n

.meas tran vdout1_31ck1430 FIND v(dout1_31) AT=720.025n

.meas tran vdout1_32ck1430 FIND v(dout1_32) AT=720.025n

.meas tran vdout1_33ck1430 FIND v(dout1_33) AT=720.025n

.meas tran vdout1_34ck1430 FIND v(dout1_34) AT=720.025n

.meas tran vdout1_35ck1430 FIND v(dout1_35) AT=720.025n

.meas tran vdout1_36ck1430 FIND v(dout1_36) AT=720.025n

.meas tran vdout1_37ck1430 FIND v(dout1_37) AT=720.025n

.meas tran vdout1_38ck1430 FIND v(dout1_38) AT=720.025n

.meas tran vdout1_39ck1430 FIND v(dout1_39) AT=720.025n

.meas tran vdout1_40ck1430 FIND v(dout1_40) AT=720.025n

.meas tran vdout1_41ck1430 FIND v(dout1_41) AT=720.025n

.meas tran vdout1_42ck1430 FIND v(dout1_42) AT=720.025n

.meas tran vdout1_43ck1430 FIND v(dout1_43) AT=720.025n

.meas tran vdout1_44ck1430 FIND v(dout1_44) AT=720.025n

.meas tran vdout1_45ck1430 FIND v(dout1_45) AT=720.025n

.meas tran vdout1_46ck1430 FIND v(dout1_46) AT=720.025n

.meas tran vdout1_47ck1430 FIND v(dout1_47) AT=720.025n

.meas tran vdout1_48ck1430 FIND v(dout1_48) AT=720.025n

.meas tran vdout1_49ck1430 FIND v(dout1_49) AT=720.025n

.meas tran vdout1_50ck1430 FIND v(dout1_50) AT=720.025n

.meas tran vdout1_51ck1430 FIND v(dout1_51) AT=720.025n

.meas tran vdout1_52ck1430 FIND v(dout1_52) AT=720.025n

.meas tran vdout1_53ck1430 FIND v(dout1_53) AT=720.025n

.meas tran vdout1_54ck1430 FIND v(dout1_54) AT=720.025n

.meas tran vdout1_55ck1430 FIND v(dout1_55) AT=720.025n

.meas tran vdout1_56ck1430 FIND v(dout1_56) AT=720.025n

.meas tran vdout1_57ck1430 FIND v(dout1_57) AT=720.025n

.meas tran vdout1_58ck1430 FIND v(dout1_58) AT=720.025n

.meas tran vdout1_59ck1430 FIND v(dout1_59) AT=720.025n

.meas tran vdout1_60ck1430 FIND v(dout1_60) AT=720.025n

.meas tran vdout1_61ck1430 FIND v(dout1_61) AT=720.025n

.meas tran vdout1_62ck1430 FIND v(dout1_62) AT=720.025n

.meas tran vdout1_63ck1430 FIND v(dout1_63) AT=720.025n

.meas tran vdout1_64ck1430 FIND v(dout1_64) AT=720.025n

.meas tran vdout1_65ck1430 FIND v(dout1_65) AT=720.025n

.meas tran vdout1_66ck1430 FIND v(dout1_66) AT=720.025n

.meas tran vdout1_67ck1430 FIND v(dout1_67) AT=720.025n

.meas tran vdout1_68ck1430 FIND v(dout1_68) AT=720.025n

.meas tran vdout1_69ck1430 FIND v(dout1_69) AT=720.025n

.meas tran vdout1_70ck1430 FIND v(dout1_70) AT=720.025n

.meas tran vdout1_71ck1430 FIND v(dout1_71) AT=720.025n

.meas tran vdout1_72ck1430 FIND v(dout1_72) AT=720.025n

.meas tran vdout1_73ck1430 FIND v(dout1_73) AT=720.025n

.meas tran vdout1_74ck1430 FIND v(dout1_74) AT=720.025n

.meas tran vdout1_75ck1430 FIND v(dout1_75) AT=720.025n

.meas tran vdout1_76ck1430 FIND v(dout1_76) AT=720.025n

.meas tran vdout1_77ck1430 FIND v(dout1_77) AT=720.025n

.meas tran vdout1_78ck1430 FIND v(dout1_78) AT=720.025n

.meas tran vdout1_79ck1430 FIND v(dout1_79) AT=720.025n

.meas tran vdout1_80ck1430 FIND v(dout1_80) AT=720.025n

.meas tran vdout1_81ck1430 FIND v(dout1_81) AT=720.025n

.meas tran vdout1_82ck1430 FIND v(dout1_82) AT=720.025n

.meas tran vdout1_83ck1430 FIND v(dout1_83) AT=720.025n

.meas tran vdout1_84ck1430 FIND v(dout1_84) AT=720.025n

.meas tran vdout1_85ck1430 FIND v(dout1_85) AT=720.025n

.meas tran vdout1_86ck1430 FIND v(dout1_86) AT=720.025n

.meas tran vdout1_87ck1430 FIND v(dout1_87) AT=720.025n

.meas tran vdout1_88ck1430 FIND v(dout1_88) AT=720.025n

.meas tran vdout1_89ck1430 FIND v(dout1_89) AT=720.025n

.meas tran vdout1_90ck1430 FIND v(dout1_90) AT=720.025n

.meas tran vdout1_91ck1430 FIND v(dout1_91) AT=720.025n

.meas tran vdout1_92ck1430 FIND v(dout1_92) AT=720.025n

.meas tran vdout1_93ck1430 FIND v(dout1_93) AT=720.025n

.meas tran vdout1_94ck1430 FIND v(dout1_94) AT=720.025n

.meas tran vdout1_95ck1430 FIND v(dout1_95) AT=720.025n

.meas tran vdout1_96ck1430 FIND v(dout1_96) AT=720.025n

.meas tran vdout1_97ck1430 FIND v(dout1_97) AT=720.025n

.meas tran vdout1_98ck1430 FIND v(dout1_98) AT=720.025n

.meas tran vdout1_99ck1430 FIND v(dout1_99) AT=720.025n

.meas tran vdout1_100ck1430 FIND v(dout1_100) AT=720.025n

.meas tran vdout1_101ck1430 FIND v(dout1_101) AT=720.025n

.meas tran vdout1_102ck1430 FIND v(dout1_102) AT=720.025n

.meas tran vdout1_103ck1430 FIND v(dout1_103) AT=720.025n

.meas tran vdout1_104ck1430 FIND v(dout1_104) AT=720.025n

.meas tran vdout1_105ck1430 FIND v(dout1_105) AT=720.025n

.meas tran vdout1_106ck1430 FIND v(dout1_106) AT=720.025n

.meas tran vdout1_107ck1430 FIND v(dout1_107) AT=720.025n

.meas tran vdout1_108ck1430 FIND v(dout1_108) AT=720.025n

.meas tran vdout1_109ck1430 FIND v(dout1_109) AT=720.025n

.meas tran vdout1_110ck1430 FIND v(dout1_110) AT=720.025n

.meas tran vdout1_111ck1430 FIND v(dout1_111) AT=720.025n

.meas tran vdout1_112ck1430 FIND v(dout1_112) AT=720.025n

.meas tran vdout1_113ck1430 FIND v(dout1_113) AT=720.025n

.meas tran vdout1_114ck1430 FIND v(dout1_114) AT=720.025n

.meas tran vdout1_115ck1430 FIND v(dout1_115) AT=720.025n

.meas tran vdout1_116ck1430 FIND v(dout1_116) AT=720.025n

.meas tran vdout1_117ck1430 FIND v(dout1_117) AT=720.025n

.meas tran vdout1_118ck1430 FIND v(dout1_118) AT=720.025n

.meas tran vdout1_119ck1430 FIND v(dout1_119) AT=720.025n

.meas tran vdout1_120ck1430 FIND v(dout1_120) AT=720.025n

.meas tran vdout1_121ck1430 FIND v(dout1_121) AT=720.025n

.meas tran vdout1_122ck1430 FIND v(dout1_122) AT=720.025n

.meas tran vdout1_123ck1430 FIND v(dout1_123) AT=720.025n

.meas tran vdout1_124ck1430 FIND v(dout1_124) AT=720.025n

.meas tran vdout1_125ck1430 FIND v(dout1_125) AT=720.025n

.meas tran vdout1_126ck1430 FIND v(dout1_126) AT=720.025n

.meas tran vdout1_127ck1430 FIND v(dout1_127) AT=720.025n

.meas tran vdout1_0ck1490 FIND v(dout1_0) AT=750.025n

.meas tran vdout1_1ck1490 FIND v(dout1_1) AT=750.025n

.meas tran vdout1_2ck1490 FIND v(dout1_2) AT=750.025n

.meas tran vdout1_3ck1490 FIND v(dout1_3) AT=750.025n

.meas tran vdout1_4ck1490 FIND v(dout1_4) AT=750.025n

.meas tran vdout1_5ck1490 FIND v(dout1_5) AT=750.025n

.meas tran vdout1_6ck1490 FIND v(dout1_6) AT=750.025n

.meas tran vdout1_7ck1490 FIND v(dout1_7) AT=750.025n

.meas tran vdout1_8ck1490 FIND v(dout1_8) AT=750.025n

.meas tran vdout1_9ck1490 FIND v(dout1_9) AT=750.025n

.meas tran vdout1_10ck1490 FIND v(dout1_10) AT=750.025n

.meas tran vdout1_11ck1490 FIND v(dout1_11) AT=750.025n

.meas tran vdout1_12ck1490 FIND v(dout1_12) AT=750.025n

.meas tran vdout1_13ck1490 FIND v(dout1_13) AT=750.025n

.meas tran vdout1_14ck1490 FIND v(dout1_14) AT=750.025n

.meas tran vdout1_15ck1490 FIND v(dout1_15) AT=750.025n

.meas tran vdout1_16ck1490 FIND v(dout1_16) AT=750.025n

.meas tran vdout1_17ck1490 FIND v(dout1_17) AT=750.025n

.meas tran vdout1_18ck1490 FIND v(dout1_18) AT=750.025n

.meas tran vdout1_19ck1490 FIND v(dout1_19) AT=750.025n

.meas tran vdout1_20ck1490 FIND v(dout1_20) AT=750.025n

.meas tran vdout1_21ck1490 FIND v(dout1_21) AT=750.025n

.meas tran vdout1_22ck1490 FIND v(dout1_22) AT=750.025n

.meas tran vdout1_23ck1490 FIND v(dout1_23) AT=750.025n

.meas tran vdout1_24ck1490 FIND v(dout1_24) AT=750.025n

.meas tran vdout1_25ck1490 FIND v(dout1_25) AT=750.025n

.meas tran vdout1_26ck1490 FIND v(dout1_26) AT=750.025n

.meas tran vdout1_27ck1490 FIND v(dout1_27) AT=750.025n

.meas tran vdout1_28ck1490 FIND v(dout1_28) AT=750.025n

.meas tran vdout1_29ck1490 FIND v(dout1_29) AT=750.025n

.meas tran vdout1_30ck1490 FIND v(dout1_30) AT=750.025n

.meas tran vdout1_31ck1490 FIND v(dout1_31) AT=750.025n

.meas tran vdout1_32ck1490 FIND v(dout1_32) AT=750.025n

.meas tran vdout1_33ck1490 FIND v(dout1_33) AT=750.025n

.meas tran vdout1_34ck1490 FIND v(dout1_34) AT=750.025n

.meas tran vdout1_35ck1490 FIND v(dout1_35) AT=750.025n

.meas tran vdout1_36ck1490 FIND v(dout1_36) AT=750.025n

.meas tran vdout1_37ck1490 FIND v(dout1_37) AT=750.025n

.meas tran vdout1_38ck1490 FIND v(dout1_38) AT=750.025n

.meas tran vdout1_39ck1490 FIND v(dout1_39) AT=750.025n

.meas tran vdout1_40ck1490 FIND v(dout1_40) AT=750.025n

.meas tran vdout1_41ck1490 FIND v(dout1_41) AT=750.025n

.meas tran vdout1_42ck1490 FIND v(dout1_42) AT=750.025n

.meas tran vdout1_43ck1490 FIND v(dout1_43) AT=750.025n

.meas tran vdout1_44ck1490 FIND v(dout1_44) AT=750.025n

.meas tran vdout1_45ck1490 FIND v(dout1_45) AT=750.025n

.meas tran vdout1_46ck1490 FIND v(dout1_46) AT=750.025n

.meas tran vdout1_47ck1490 FIND v(dout1_47) AT=750.025n

.meas tran vdout1_48ck1490 FIND v(dout1_48) AT=750.025n

.meas tran vdout1_49ck1490 FIND v(dout1_49) AT=750.025n

.meas tran vdout1_50ck1490 FIND v(dout1_50) AT=750.025n

.meas tran vdout1_51ck1490 FIND v(dout1_51) AT=750.025n

.meas tran vdout1_52ck1490 FIND v(dout1_52) AT=750.025n

.meas tran vdout1_53ck1490 FIND v(dout1_53) AT=750.025n

.meas tran vdout1_54ck1490 FIND v(dout1_54) AT=750.025n

.meas tran vdout1_55ck1490 FIND v(dout1_55) AT=750.025n

.meas tran vdout1_56ck1490 FIND v(dout1_56) AT=750.025n

.meas tran vdout1_57ck1490 FIND v(dout1_57) AT=750.025n

.meas tran vdout1_58ck1490 FIND v(dout1_58) AT=750.025n

.meas tran vdout1_59ck1490 FIND v(dout1_59) AT=750.025n

.meas tran vdout1_60ck1490 FIND v(dout1_60) AT=750.025n

.meas tran vdout1_61ck1490 FIND v(dout1_61) AT=750.025n

.meas tran vdout1_62ck1490 FIND v(dout1_62) AT=750.025n

.meas tran vdout1_63ck1490 FIND v(dout1_63) AT=750.025n

.meas tran vdout1_64ck1490 FIND v(dout1_64) AT=750.025n

.meas tran vdout1_65ck1490 FIND v(dout1_65) AT=750.025n

.meas tran vdout1_66ck1490 FIND v(dout1_66) AT=750.025n

.meas tran vdout1_67ck1490 FIND v(dout1_67) AT=750.025n

.meas tran vdout1_68ck1490 FIND v(dout1_68) AT=750.025n

.meas tran vdout1_69ck1490 FIND v(dout1_69) AT=750.025n

.meas tran vdout1_70ck1490 FIND v(dout1_70) AT=750.025n

.meas tran vdout1_71ck1490 FIND v(dout1_71) AT=750.025n

.meas tran vdout1_72ck1490 FIND v(dout1_72) AT=750.025n

.meas tran vdout1_73ck1490 FIND v(dout1_73) AT=750.025n

.meas tran vdout1_74ck1490 FIND v(dout1_74) AT=750.025n

.meas tran vdout1_75ck1490 FIND v(dout1_75) AT=750.025n

.meas tran vdout1_76ck1490 FIND v(dout1_76) AT=750.025n

.meas tran vdout1_77ck1490 FIND v(dout1_77) AT=750.025n

.meas tran vdout1_78ck1490 FIND v(dout1_78) AT=750.025n

.meas tran vdout1_79ck1490 FIND v(dout1_79) AT=750.025n

.meas tran vdout1_80ck1490 FIND v(dout1_80) AT=750.025n

.meas tran vdout1_81ck1490 FIND v(dout1_81) AT=750.025n

.meas tran vdout1_82ck1490 FIND v(dout1_82) AT=750.025n

.meas tran vdout1_83ck1490 FIND v(dout1_83) AT=750.025n

.meas tran vdout1_84ck1490 FIND v(dout1_84) AT=750.025n

.meas tran vdout1_85ck1490 FIND v(dout1_85) AT=750.025n

.meas tran vdout1_86ck1490 FIND v(dout1_86) AT=750.025n

.meas tran vdout1_87ck1490 FIND v(dout1_87) AT=750.025n

.meas tran vdout1_88ck1490 FIND v(dout1_88) AT=750.025n

.meas tran vdout1_89ck1490 FIND v(dout1_89) AT=750.025n

.meas tran vdout1_90ck1490 FIND v(dout1_90) AT=750.025n

.meas tran vdout1_91ck1490 FIND v(dout1_91) AT=750.025n

.meas tran vdout1_92ck1490 FIND v(dout1_92) AT=750.025n

.meas tran vdout1_93ck1490 FIND v(dout1_93) AT=750.025n

.meas tran vdout1_94ck1490 FIND v(dout1_94) AT=750.025n

.meas tran vdout1_95ck1490 FIND v(dout1_95) AT=750.025n

.meas tran vdout1_96ck1490 FIND v(dout1_96) AT=750.025n

.meas tran vdout1_97ck1490 FIND v(dout1_97) AT=750.025n

.meas tran vdout1_98ck1490 FIND v(dout1_98) AT=750.025n

.meas tran vdout1_99ck1490 FIND v(dout1_99) AT=750.025n

.meas tran vdout1_100ck1490 FIND v(dout1_100) AT=750.025n

.meas tran vdout1_101ck1490 FIND v(dout1_101) AT=750.025n

.meas tran vdout1_102ck1490 FIND v(dout1_102) AT=750.025n

.meas tran vdout1_103ck1490 FIND v(dout1_103) AT=750.025n

.meas tran vdout1_104ck1490 FIND v(dout1_104) AT=750.025n

.meas tran vdout1_105ck1490 FIND v(dout1_105) AT=750.025n

.meas tran vdout1_106ck1490 FIND v(dout1_106) AT=750.025n

.meas tran vdout1_107ck1490 FIND v(dout1_107) AT=750.025n

.meas tran vdout1_108ck1490 FIND v(dout1_108) AT=750.025n

.meas tran vdout1_109ck1490 FIND v(dout1_109) AT=750.025n

.meas tran vdout1_110ck1490 FIND v(dout1_110) AT=750.025n

.meas tran vdout1_111ck1490 FIND v(dout1_111) AT=750.025n

.meas tran vdout1_112ck1490 FIND v(dout1_112) AT=750.025n

.meas tran vdout1_113ck1490 FIND v(dout1_113) AT=750.025n

.meas tran vdout1_114ck1490 FIND v(dout1_114) AT=750.025n

.meas tran vdout1_115ck1490 FIND v(dout1_115) AT=750.025n

.meas tran vdout1_116ck1490 FIND v(dout1_116) AT=750.025n

.meas tran vdout1_117ck1490 FIND v(dout1_117) AT=750.025n

.meas tran vdout1_118ck1490 FIND v(dout1_118) AT=750.025n

.meas tran vdout1_119ck1490 FIND v(dout1_119) AT=750.025n

.meas tran vdout1_120ck1490 FIND v(dout1_120) AT=750.025n

.meas tran vdout1_121ck1490 FIND v(dout1_121) AT=750.025n

.meas tran vdout1_122ck1490 FIND v(dout1_122) AT=750.025n

.meas tran vdout1_123ck1490 FIND v(dout1_123) AT=750.025n

.meas tran vdout1_124ck1490 FIND v(dout1_124) AT=750.025n

.meas tran vdout1_125ck1490 FIND v(dout1_125) AT=750.025n

.meas tran vdout1_126ck1490 FIND v(dout1_126) AT=750.025n

.meas tran vdout1_127ck1490 FIND v(dout1_127) AT=750.025n

.meas tran vdout1_0ck1520 FIND v(dout1_0) AT=765.025n

.meas tran vdout1_1ck1520 FIND v(dout1_1) AT=765.025n

.meas tran vdout1_2ck1520 FIND v(dout1_2) AT=765.025n

.meas tran vdout1_3ck1520 FIND v(dout1_3) AT=765.025n

.meas tran vdout1_4ck1520 FIND v(dout1_4) AT=765.025n

.meas tran vdout1_5ck1520 FIND v(dout1_5) AT=765.025n

.meas tran vdout1_6ck1520 FIND v(dout1_6) AT=765.025n

.meas tran vdout1_7ck1520 FIND v(dout1_7) AT=765.025n

.meas tran vdout1_8ck1520 FIND v(dout1_8) AT=765.025n

.meas tran vdout1_9ck1520 FIND v(dout1_9) AT=765.025n

.meas tran vdout1_10ck1520 FIND v(dout1_10) AT=765.025n

.meas tran vdout1_11ck1520 FIND v(dout1_11) AT=765.025n

.meas tran vdout1_12ck1520 FIND v(dout1_12) AT=765.025n

.meas tran vdout1_13ck1520 FIND v(dout1_13) AT=765.025n

.meas tran vdout1_14ck1520 FIND v(dout1_14) AT=765.025n

.meas tran vdout1_15ck1520 FIND v(dout1_15) AT=765.025n

.meas tran vdout1_16ck1520 FIND v(dout1_16) AT=765.025n

.meas tran vdout1_17ck1520 FIND v(dout1_17) AT=765.025n

.meas tran vdout1_18ck1520 FIND v(dout1_18) AT=765.025n

.meas tran vdout1_19ck1520 FIND v(dout1_19) AT=765.025n

.meas tran vdout1_20ck1520 FIND v(dout1_20) AT=765.025n

.meas tran vdout1_21ck1520 FIND v(dout1_21) AT=765.025n

.meas tran vdout1_22ck1520 FIND v(dout1_22) AT=765.025n

.meas tran vdout1_23ck1520 FIND v(dout1_23) AT=765.025n

.meas tran vdout1_24ck1520 FIND v(dout1_24) AT=765.025n

.meas tran vdout1_25ck1520 FIND v(dout1_25) AT=765.025n

.meas tran vdout1_26ck1520 FIND v(dout1_26) AT=765.025n

.meas tran vdout1_27ck1520 FIND v(dout1_27) AT=765.025n

.meas tran vdout1_28ck1520 FIND v(dout1_28) AT=765.025n

.meas tran vdout1_29ck1520 FIND v(dout1_29) AT=765.025n

.meas tran vdout1_30ck1520 FIND v(dout1_30) AT=765.025n

.meas tran vdout1_31ck1520 FIND v(dout1_31) AT=765.025n

.meas tran vdout1_32ck1520 FIND v(dout1_32) AT=765.025n

.meas tran vdout1_33ck1520 FIND v(dout1_33) AT=765.025n

.meas tran vdout1_34ck1520 FIND v(dout1_34) AT=765.025n

.meas tran vdout1_35ck1520 FIND v(dout1_35) AT=765.025n

.meas tran vdout1_36ck1520 FIND v(dout1_36) AT=765.025n

.meas tran vdout1_37ck1520 FIND v(dout1_37) AT=765.025n

.meas tran vdout1_38ck1520 FIND v(dout1_38) AT=765.025n

.meas tran vdout1_39ck1520 FIND v(dout1_39) AT=765.025n

.meas tran vdout1_40ck1520 FIND v(dout1_40) AT=765.025n

.meas tran vdout1_41ck1520 FIND v(dout1_41) AT=765.025n

.meas tran vdout1_42ck1520 FIND v(dout1_42) AT=765.025n

.meas tran vdout1_43ck1520 FIND v(dout1_43) AT=765.025n

.meas tran vdout1_44ck1520 FIND v(dout1_44) AT=765.025n

.meas tran vdout1_45ck1520 FIND v(dout1_45) AT=765.025n

.meas tran vdout1_46ck1520 FIND v(dout1_46) AT=765.025n

.meas tran vdout1_47ck1520 FIND v(dout1_47) AT=765.025n

.meas tran vdout1_48ck1520 FIND v(dout1_48) AT=765.025n

.meas tran vdout1_49ck1520 FIND v(dout1_49) AT=765.025n

.meas tran vdout1_50ck1520 FIND v(dout1_50) AT=765.025n

.meas tran vdout1_51ck1520 FIND v(dout1_51) AT=765.025n

.meas tran vdout1_52ck1520 FIND v(dout1_52) AT=765.025n

.meas tran vdout1_53ck1520 FIND v(dout1_53) AT=765.025n

.meas tran vdout1_54ck1520 FIND v(dout1_54) AT=765.025n

.meas tran vdout1_55ck1520 FIND v(dout1_55) AT=765.025n

.meas tran vdout1_56ck1520 FIND v(dout1_56) AT=765.025n

.meas tran vdout1_57ck1520 FIND v(dout1_57) AT=765.025n

.meas tran vdout1_58ck1520 FIND v(dout1_58) AT=765.025n

.meas tran vdout1_59ck1520 FIND v(dout1_59) AT=765.025n

.meas tran vdout1_60ck1520 FIND v(dout1_60) AT=765.025n

.meas tran vdout1_61ck1520 FIND v(dout1_61) AT=765.025n

.meas tran vdout1_62ck1520 FIND v(dout1_62) AT=765.025n

.meas tran vdout1_63ck1520 FIND v(dout1_63) AT=765.025n

.meas tran vdout1_64ck1520 FIND v(dout1_64) AT=765.025n

.meas tran vdout1_65ck1520 FIND v(dout1_65) AT=765.025n

.meas tran vdout1_66ck1520 FIND v(dout1_66) AT=765.025n

.meas tran vdout1_67ck1520 FIND v(dout1_67) AT=765.025n

.meas tran vdout1_68ck1520 FIND v(dout1_68) AT=765.025n

.meas tran vdout1_69ck1520 FIND v(dout1_69) AT=765.025n

.meas tran vdout1_70ck1520 FIND v(dout1_70) AT=765.025n

.meas tran vdout1_71ck1520 FIND v(dout1_71) AT=765.025n

.meas tran vdout1_72ck1520 FIND v(dout1_72) AT=765.025n

.meas tran vdout1_73ck1520 FIND v(dout1_73) AT=765.025n

.meas tran vdout1_74ck1520 FIND v(dout1_74) AT=765.025n

.meas tran vdout1_75ck1520 FIND v(dout1_75) AT=765.025n

.meas tran vdout1_76ck1520 FIND v(dout1_76) AT=765.025n

.meas tran vdout1_77ck1520 FIND v(dout1_77) AT=765.025n

.meas tran vdout1_78ck1520 FIND v(dout1_78) AT=765.025n

.meas tran vdout1_79ck1520 FIND v(dout1_79) AT=765.025n

.meas tran vdout1_80ck1520 FIND v(dout1_80) AT=765.025n

.meas tran vdout1_81ck1520 FIND v(dout1_81) AT=765.025n

.meas tran vdout1_82ck1520 FIND v(dout1_82) AT=765.025n

.meas tran vdout1_83ck1520 FIND v(dout1_83) AT=765.025n

.meas tran vdout1_84ck1520 FIND v(dout1_84) AT=765.025n

.meas tran vdout1_85ck1520 FIND v(dout1_85) AT=765.025n

.meas tran vdout1_86ck1520 FIND v(dout1_86) AT=765.025n

.meas tran vdout1_87ck1520 FIND v(dout1_87) AT=765.025n

.meas tran vdout1_88ck1520 FIND v(dout1_88) AT=765.025n

.meas tran vdout1_89ck1520 FIND v(dout1_89) AT=765.025n

.meas tran vdout1_90ck1520 FIND v(dout1_90) AT=765.025n

.meas tran vdout1_91ck1520 FIND v(dout1_91) AT=765.025n

.meas tran vdout1_92ck1520 FIND v(dout1_92) AT=765.025n

.meas tran vdout1_93ck1520 FIND v(dout1_93) AT=765.025n

.meas tran vdout1_94ck1520 FIND v(dout1_94) AT=765.025n

.meas tran vdout1_95ck1520 FIND v(dout1_95) AT=765.025n

.meas tran vdout1_96ck1520 FIND v(dout1_96) AT=765.025n

.meas tran vdout1_97ck1520 FIND v(dout1_97) AT=765.025n

.meas tran vdout1_98ck1520 FIND v(dout1_98) AT=765.025n

.meas tran vdout1_99ck1520 FIND v(dout1_99) AT=765.025n

.meas tran vdout1_100ck1520 FIND v(dout1_100) AT=765.025n

.meas tran vdout1_101ck1520 FIND v(dout1_101) AT=765.025n

.meas tran vdout1_102ck1520 FIND v(dout1_102) AT=765.025n

.meas tran vdout1_103ck1520 FIND v(dout1_103) AT=765.025n

.meas tran vdout1_104ck1520 FIND v(dout1_104) AT=765.025n

.meas tran vdout1_105ck1520 FIND v(dout1_105) AT=765.025n

.meas tran vdout1_106ck1520 FIND v(dout1_106) AT=765.025n

.meas tran vdout1_107ck1520 FIND v(dout1_107) AT=765.025n

.meas tran vdout1_108ck1520 FIND v(dout1_108) AT=765.025n

.meas tran vdout1_109ck1520 FIND v(dout1_109) AT=765.025n

.meas tran vdout1_110ck1520 FIND v(dout1_110) AT=765.025n

.meas tran vdout1_111ck1520 FIND v(dout1_111) AT=765.025n

.meas tran vdout1_112ck1520 FIND v(dout1_112) AT=765.025n

.meas tran vdout1_113ck1520 FIND v(dout1_113) AT=765.025n

.meas tran vdout1_114ck1520 FIND v(dout1_114) AT=765.025n

.meas tran vdout1_115ck1520 FIND v(dout1_115) AT=765.025n

.meas tran vdout1_116ck1520 FIND v(dout1_116) AT=765.025n

.meas tran vdout1_117ck1520 FIND v(dout1_117) AT=765.025n

.meas tran vdout1_118ck1520 FIND v(dout1_118) AT=765.025n

.meas tran vdout1_119ck1520 FIND v(dout1_119) AT=765.025n

.meas tran vdout1_120ck1520 FIND v(dout1_120) AT=765.025n

.meas tran vdout1_121ck1520 FIND v(dout1_121) AT=765.025n

.meas tran vdout1_122ck1520 FIND v(dout1_122) AT=765.025n

.meas tran vdout1_123ck1520 FIND v(dout1_123) AT=765.025n

.meas tran vdout1_124ck1520 FIND v(dout1_124) AT=765.025n

.meas tran vdout1_125ck1520 FIND v(dout1_125) AT=765.025n

.meas tran vdout1_126ck1520 FIND v(dout1_126) AT=765.025n

.meas tran vdout1_127ck1520 FIND v(dout1_127) AT=765.025n

.meas tran vdout1_0ck1540 FIND v(dout1_0) AT=775.025n

.meas tran vdout1_1ck1540 FIND v(dout1_1) AT=775.025n

.meas tran vdout1_2ck1540 FIND v(dout1_2) AT=775.025n

.meas tran vdout1_3ck1540 FIND v(dout1_3) AT=775.025n

.meas tran vdout1_4ck1540 FIND v(dout1_4) AT=775.025n

.meas tran vdout1_5ck1540 FIND v(dout1_5) AT=775.025n

.meas tran vdout1_6ck1540 FIND v(dout1_6) AT=775.025n

.meas tran vdout1_7ck1540 FIND v(dout1_7) AT=775.025n

.meas tran vdout1_8ck1540 FIND v(dout1_8) AT=775.025n

.meas tran vdout1_9ck1540 FIND v(dout1_9) AT=775.025n

.meas tran vdout1_10ck1540 FIND v(dout1_10) AT=775.025n

.meas tran vdout1_11ck1540 FIND v(dout1_11) AT=775.025n

.meas tran vdout1_12ck1540 FIND v(dout1_12) AT=775.025n

.meas tran vdout1_13ck1540 FIND v(dout1_13) AT=775.025n

.meas tran vdout1_14ck1540 FIND v(dout1_14) AT=775.025n

.meas tran vdout1_15ck1540 FIND v(dout1_15) AT=775.025n

.meas tran vdout1_16ck1540 FIND v(dout1_16) AT=775.025n

.meas tran vdout1_17ck1540 FIND v(dout1_17) AT=775.025n

.meas tran vdout1_18ck1540 FIND v(dout1_18) AT=775.025n

.meas tran vdout1_19ck1540 FIND v(dout1_19) AT=775.025n

.meas tran vdout1_20ck1540 FIND v(dout1_20) AT=775.025n

.meas tran vdout1_21ck1540 FIND v(dout1_21) AT=775.025n

.meas tran vdout1_22ck1540 FIND v(dout1_22) AT=775.025n

.meas tran vdout1_23ck1540 FIND v(dout1_23) AT=775.025n

.meas tran vdout1_24ck1540 FIND v(dout1_24) AT=775.025n

.meas tran vdout1_25ck1540 FIND v(dout1_25) AT=775.025n

.meas tran vdout1_26ck1540 FIND v(dout1_26) AT=775.025n

.meas tran vdout1_27ck1540 FIND v(dout1_27) AT=775.025n

.meas tran vdout1_28ck1540 FIND v(dout1_28) AT=775.025n

.meas tran vdout1_29ck1540 FIND v(dout1_29) AT=775.025n

.meas tran vdout1_30ck1540 FIND v(dout1_30) AT=775.025n

.meas tran vdout1_31ck1540 FIND v(dout1_31) AT=775.025n

.meas tran vdout1_32ck1540 FIND v(dout1_32) AT=775.025n

.meas tran vdout1_33ck1540 FIND v(dout1_33) AT=775.025n

.meas tran vdout1_34ck1540 FIND v(dout1_34) AT=775.025n

.meas tran vdout1_35ck1540 FIND v(dout1_35) AT=775.025n

.meas tran vdout1_36ck1540 FIND v(dout1_36) AT=775.025n

.meas tran vdout1_37ck1540 FIND v(dout1_37) AT=775.025n

.meas tran vdout1_38ck1540 FIND v(dout1_38) AT=775.025n

.meas tran vdout1_39ck1540 FIND v(dout1_39) AT=775.025n

.meas tran vdout1_40ck1540 FIND v(dout1_40) AT=775.025n

.meas tran vdout1_41ck1540 FIND v(dout1_41) AT=775.025n

.meas tran vdout1_42ck1540 FIND v(dout1_42) AT=775.025n

.meas tran vdout1_43ck1540 FIND v(dout1_43) AT=775.025n

.meas tran vdout1_44ck1540 FIND v(dout1_44) AT=775.025n

.meas tran vdout1_45ck1540 FIND v(dout1_45) AT=775.025n

.meas tran vdout1_46ck1540 FIND v(dout1_46) AT=775.025n

.meas tran vdout1_47ck1540 FIND v(dout1_47) AT=775.025n

.meas tran vdout1_48ck1540 FIND v(dout1_48) AT=775.025n

.meas tran vdout1_49ck1540 FIND v(dout1_49) AT=775.025n

.meas tran vdout1_50ck1540 FIND v(dout1_50) AT=775.025n

.meas tran vdout1_51ck1540 FIND v(dout1_51) AT=775.025n

.meas tran vdout1_52ck1540 FIND v(dout1_52) AT=775.025n

.meas tran vdout1_53ck1540 FIND v(dout1_53) AT=775.025n

.meas tran vdout1_54ck1540 FIND v(dout1_54) AT=775.025n

.meas tran vdout1_55ck1540 FIND v(dout1_55) AT=775.025n

.meas tran vdout1_56ck1540 FIND v(dout1_56) AT=775.025n

.meas tran vdout1_57ck1540 FIND v(dout1_57) AT=775.025n

.meas tran vdout1_58ck1540 FIND v(dout1_58) AT=775.025n

.meas tran vdout1_59ck1540 FIND v(dout1_59) AT=775.025n

.meas tran vdout1_60ck1540 FIND v(dout1_60) AT=775.025n

.meas tran vdout1_61ck1540 FIND v(dout1_61) AT=775.025n

.meas tran vdout1_62ck1540 FIND v(dout1_62) AT=775.025n

.meas tran vdout1_63ck1540 FIND v(dout1_63) AT=775.025n

.meas tran vdout1_64ck1540 FIND v(dout1_64) AT=775.025n

.meas tran vdout1_65ck1540 FIND v(dout1_65) AT=775.025n

.meas tran vdout1_66ck1540 FIND v(dout1_66) AT=775.025n

.meas tran vdout1_67ck1540 FIND v(dout1_67) AT=775.025n

.meas tran vdout1_68ck1540 FIND v(dout1_68) AT=775.025n

.meas tran vdout1_69ck1540 FIND v(dout1_69) AT=775.025n

.meas tran vdout1_70ck1540 FIND v(dout1_70) AT=775.025n

.meas tran vdout1_71ck1540 FIND v(dout1_71) AT=775.025n

.meas tran vdout1_72ck1540 FIND v(dout1_72) AT=775.025n

.meas tran vdout1_73ck1540 FIND v(dout1_73) AT=775.025n

.meas tran vdout1_74ck1540 FIND v(dout1_74) AT=775.025n

.meas tran vdout1_75ck1540 FIND v(dout1_75) AT=775.025n

.meas tran vdout1_76ck1540 FIND v(dout1_76) AT=775.025n

.meas tran vdout1_77ck1540 FIND v(dout1_77) AT=775.025n

.meas tran vdout1_78ck1540 FIND v(dout1_78) AT=775.025n

.meas tran vdout1_79ck1540 FIND v(dout1_79) AT=775.025n

.meas tran vdout1_80ck1540 FIND v(dout1_80) AT=775.025n

.meas tran vdout1_81ck1540 FIND v(dout1_81) AT=775.025n

.meas tran vdout1_82ck1540 FIND v(dout1_82) AT=775.025n

.meas tran vdout1_83ck1540 FIND v(dout1_83) AT=775.025n

.meas tran vdout1_84ck1540 FIND v(dout1_84) AT=775.025n

.meas tran vdout1_85ck1540 FIND v(dout1_85) AT=775.025n

.meas tran vdout1_86ck1540 FIND v(dout1_86) AT=775.025n

.meas tran vdout1_87ck1540 FIND v(dout1_87) AT=775.025n

.meas tran vdout1_88ck1540 FIND v(dout1_88) AT=775.025n

.meas tran vdout1_89ck1540 FIND v(dout1_89) AT=775.025n

.meas tran vdout1_90ck1540 FIND v(dout1_90) AT=775.025n

.meas tran vdout1_91ck1540 FIND v(dout1_91) AT=775.025n

.meas tran vdout1_92ck1540 FIND v(dout1_92) AT=775.025n

.meas tran vdout1_93ck1540 FIND v(dout1_93) AT=775.025n

.meas tran vdout1_94ck1540 FIND v(dout1_94) AT=775.025n

.meas tran vdout1_95ck1540 FIND v(dout1_95) AT=775.025n

.meas tran vdout1_96ck1540 FIND v(dout1_96) AT=775.025n

.meas tran vdout1_97ck1540 FIND v(dout1_97) AT=775.025n

.meas tran vdout1_98ck1540 FIND v(dout1_98) AT=775.025n

.meas tran vdout1_99ck1540 FIND v(dout1_99) AT=775.025n

.meas tran vdout1_100ck1540 FIND v(dout1_100) AT=775.025n

.meas tran vdout1_101ck1540 FIND v(dout1_101) AT=775.025n

.meas tran vdout1_102ck1540 FIND v(dout1_102) AT=775.025n

.meas tran vdout1_103ck1540 FIND v(dout1_103) AT=775.025n

.meas tran vdout1_104ck1540 FIND v(dout1_104) AT=775.025n

.meas tran vdout1_105ck1540 FIND v(dout1_105) AT=775.025n

.meas tran vdout1_106ck1540 FIND v(dout1_106) AT=775.025n

.meas tran vdout1_107ck1540 FIND v(dout1_107) AT=775.025n

.meas tran vdout1_108ck1540 FIND v(dout1_108) AT=775.025n

.meas tran vdout1_109ck1540 FIND v(dout1_109) AT=775.025n

.meas tran vdout1_110ck1540 FIND v(dout1_110) AT=775.025n

.meas tran vdout1_111ck1540 FIND v(dout1_111) AT=775.025n

.meas tran vdout1_112ck1540 FIND v(dout1_112) AT=775.025n

.meas tran vdout1_113ck1540 FIND v(dout1_113) AT=775.025n

.meas tran vdout1_114ck1540 FIND v(dout1_114) AT=775.025n

.meas tran vdout1_115ck1540 FIND v(dout1_115) AT=775.025n

.meas tran vdout1_116ck1540 FIND v(dout1_116) AT=775.025n

.meas tran vdout1_117ck1540 FIND v(dout1_117) AT=775.025n

.meas tran vdout1_118ck1540 FIND v(dout1_118) AT=775.025n

.meas tran vdout1_119ck1540 FIND v(dout1_119) AT=775.025n

.meas tran vdout1_120ck1540 FIND v(dout1_120) AT=775.025n

.meas tran vdout1_121ck1540 FIND v(dout1_121) AT=775.025n

.meas tran vdout1_122ck1540 FIND v(dout1_122) AT=775.025n

.meas tran vdout1_123ck1540 FIND v(dout1_123) AT=775.025n

.meas tran vdout1_124ck1540 FIND v(dout1_124) AT=775.025n

.meas tran vdout1_125ck1540 FIND v(dout1_125) AT=775.025n

.meas tran vdout1_126ck1540 FIND v(dout1_126) AT=775.025n

.meas tran vdout1_127ck1540 FIND v(dout1_127) AT=775.025n

.meas tran vdout1_0ck1580 FIND v(dout1_0) AT=795.025n

.meas tran vdout1_1ck1580 FIND v(dout1_1) AT=795.025n

.meas tran vdout1_2ck1580 FIND v(dout1_2) AT=795.025n

.meas tran vdout1_3ck1580 FIND v(dout1_3) AT=795.025n

.meas tran vdout1_4ck1580 FIND v(dout1_4) AT=795.025n

.meas tran vdout1_5ck1580 FIND v(dout1_5) AT=795.025n

.meas tran vdout1_6ck1580 FIND v(dout1_6) AT=795.025n

.meas tran vdout1_7ck1580 FIND v(dout1_7) AT=795.025n

.meas tran vdout1_8ck1580 FIND v(dout1_8) AT=795.025n

.meas tran vdout1_9ck1580 FIND v(dout1_9) AT=795.025n

.meas tran vdout1_10ck1580 FIND v(dout1_10) AT=795.025n

.meas tran vdout1_11ck1580 FIND v(dout1_11) AT=795.025n

.meas tran vdout1_12ck1580 FIND v(dout1_12) AT=795.025n

.meas tran vdout1_13ck1580 FIND v(dout1_13) AT=795.025n

.meas tran vdout1_14ck1580 FIND v(dout1_14) AT=795.025n

.meas tran vdout1_15ck1580 FIND v(dout1_15) AT=795.025n

.meas tran vdout1_16ck1580 FIND v(dout1_16) AT=795.025n

.meas tran vdout1_17ck1580 FIND v(dout1_17) AT=795.025n

.meas tran vdout1_18ck1580 FIND v(dout1_18) AT=795.025n

.meas tran vdout1_19ck1580 FIND v(dout1_19) AT=795.025n

.meas tran vdout1_20ck1580 FIND v(dout1_20) AT=795.025n

.meas tran vdout1_21ck1580 FIND v(dout1_21) AT=795.025n

.meas tran vdout1_22ck1580 FIND v(dout1_22) AT=795.025n

.meas tran vdout1_23ck1580 FIND v(dout1_23) AT=795.025n

.meas tran vdout1_24ck1580 FIND v(dout1_24) AT=795.025n

.meas tran vdout1_25ck1580 FIND v(dout1_25) AT=795.025n

.meas tran vdout1_26ck1580 FIND v(dout1_26) AT=795.025n

.meas tran vdout1_27ck1580 FIND v(dout1_27) AT=795.025n

.meas tran vdout1_28ck1580 FIND v(dout1_28) AT=795.025n

.meas tran vdout1_29ck1580 FIND v(dout1_29) AT=795.025n

.meas tran vdout1_30ck1580 FIND v(dout1_30) AT=795.025n

.meas tran vdout1_31ck1580 FIND v(dout1_31) AT=795.025n

.meas tran vdout1_32ck1580 FIND v(dout1_32) AT=795.025n

.meas tran vdout1_33ck1580 FIND v(dout1_33) AT=795.025n

.meas tran vdout1_34ck1580 FIND v(dout1_34) AT=795.025n

.meas tran vdout1_35ck1580 FIND v(dout1_35) AT=795.025n

.meas tran vdout1_36ck1580 FIND v(dout1_36) AT=795.025n

.meas tran vdout1_37ck1580 FIND v(dout1_37) AT=795.025n

.meas tran vdout1_38ck1580 FIND v(dout1_38) AT=795.025n

.meas tran vdout1_39ck1580 FIND v(dout1_39) AT=795.025n

.meas tran vdout1_40ck1580 FIND v(dout1_40) AT=795.025n

.meas tran vdout1_41ck1580 FIND v(dout1_41) AT=795.025n

.meas tran vdout1_42ck1580 FIND v(dout1_42) AT=795.025n

.meas tran vdout1_43ck1580 FIND v(dout1_43) AT=795.025n

.meas tran vdout1_44ck1580 FIND v(dout1_44) AT=795.025n

.meas tran vdout1_45ck1580 FIND v(dout1_45) AT=795.025n

.meas tran vdout1_46ck1580 FIND v(dout1_46) AT=795.025n

.meas tran vdout1_47ck1580 FIND v(dout1_47) AT=795.025n

.meas tran vdout1_48ck1580 FIND v(dout1_48) AT=795.025n

.meas tran vdout1_49ck1580 FIND v(dout1_49) AT=795.025n

.meas tran vdout1_50ck1580 FIND v(dout1_50) AT=795.025n

.meas tran vdout1_51ck1580 FIND v(dout1_51) AT=795.025n

.meas tran vdout1_52ck1580 FIND v(dout1_52) AT=795.025n

.meas tran vdout1_53ck1580 FIND v(dout1_53) AT=795.025n

.meas tran vdout1_54ck1580 FIND v(dout1_54) AT=795.025n

.meas tran vdout1_55ck1580 FIND v(dout1_55) AT=795.025n

.meas tran vdout1_56ck1580 FIND v(dout1_56) AT=795.025n

.meas tran vdout1_57ck1580 FIND v(dout1_57) AT=795.025n

.meas tran vdout1_58ck1580 FIND v(dout1_58) AT=795.025n

.meas tran vdout1_59ck1580 FIND v(dout1_59) AT=795.025n

.meas tran vdout1_60ck1580 FIND v(dout1_60) AT=795.025n

.meas tran vdout1_61ck1580 FIND v(dout1_61) AT=795.025n

.meas tran vdout1_62ck1580 FIND v(dout1_62) AT=795.025n

.meas tran vdout1_63ck1580 FIND v(dout1_63) AT=795.025n

.meas tran vdout1_64ck1580 FIND v(dout1_64) AT=795.025n

.meas tran vdout1_65ck1580 FIND v(dout1_65) AT=795.025n

.meas tran vdout1_66ck1580 FIND v(dout1_66) AT=795.025n

.meas tran vdout1_67ck1580 FIND v(dout1_67) AT=795.025n

.meas tran vdout1_68ck1580 FIND v(dout1_68) AT=795.025n

.meas tran vdout1_69ck1580 FIND v(dout1_69) AT=795.025n

.meas tran vdout1_70ck1580 FIND v(dout1_70) AT=795.025n

.meas tran vdout1_71ck1580 FIND v(dout1_71) AT=795.025n

.meas tran vdout1_72ck1580 FIND v(dout1_72) AT=795.025n

.meas tran vdout1_73ck1580 FIND v(dout1_73) AT=795.025n

.meas tran vdout1_74ck1580 FIND v(dout1_74) AT=795.025n

.meas tran vdout1_75ck1580 FIND v(dout1_75) AT=795.025n

.meas tran vdout1_76ck1580 FIND v(dout1_76) AT=795.025n

.meas tran vdout1_77ck1580 FIND v(dout1_77) AT=795.025n

.meas tran vdout1_78ck1580 FIND v(dout1_78) AT=795.025n

.meas tran vdout1_79ck1580 FIND v(dout1_79) AT=795.025n

.meas tran vdout1_80ck1580 FIND v(dout1_80) AT=795.025n

.meas tran vdout1_81ck1580 FIND v(dout1_81) AT=795.025n

.meas tran vdout1_82ck1580 FIND v(dout1_82) AT=795.025n

.meas tran vdout1_83ck1580 FIND v(dout1_83) AT=795.025n

.meas tran vdout1_84ck1580 FIND v(dout1_84) AT=795.025n

.meas tran vdout1_85ck1580 FIND v(dout1_85) AT=795.025n

.meas tran vdout1_86ck1580 FIND v(dout1_86) AT=795.025n

.meas tran vdout1_87ck1580 FIND v(dout1_87) AT=795.025n

.meas tran vdout1_88ck1580 FIND v(dout1_88) AT=795.025n

.meas tran vdout1_89ck1580 FIND v(dout1_89) AT=795.025n

.meas tran vdout1_90ck1580 FIND v(dout1_90) AT=795.025n

.meas tran vdout1_91ck1580 FIND v(dout1_91) AT=795.025n

.meas tran vdout1_92ck1580 FIND v(dout1_92) AT=795.025n

.meas tran vdout1_93ck1580 FIND v(dout1_93) AT=795.025n

.meas tran vdout1_94ck1580 FIND v(dout1_94) AT=795.025n

.meas tran vdout1_95ck1580 FIND v(dout1_95) AT=795.025n

.meas tran vdout1_96ck1580 FIND v(dout1_96) AT=795.025n

.meas tran vdout1_97ck1580 FIND v(dout1_97) AT=795.025n

.meas tran vdout1_98ck1580 FIND v(dout1_98) AT=795.025n

.meas tran vdout1_99ck1580 FIND v(dout1_99) AT=795.025n

.meas tran vdout1_100ck1580 FIND v(dout1_100) AT=795.025n

.meas tran vdout1_101ck1580 FIND v(dout1_101) AT=795.025n

.meas tran vdout1_102ck1580 FIND v(dout1_102) AT=795.025n

.meas tran vdout1_103ck1580 FIND v(dout1_103) AT=795.025n

.meas tran vdout1_104ck1580 FIND v(dout1_104) AT=795.025n

.meas tran vdout1_105ck1580 FIND v(dout1_105) AT=795.025n

.meas tran vdout1_106ck1580 FIND v(dout1_106) AT=795.025n

.meas tran vdout1_107ck1580 FIND v(dout1_107) AT=795.025n

.meas tran vdout1_108ck1580 FIND v(dout1_108) AT=795.025n

.meas tran vdout1_109ck1580 FIND v(dout1_109) AT=795.025n

.meas tran vdout1_110ck1580 FIND v(dout1_110) AT=795.025n

.meas tran vdout1_111ck1580 FIND v(dout1_111) AT=795.025n

.meas tran vdout1_112ck1580 FIND v(dout1_112) AT=795.025n

.meas tran vdout1_113ck1580 FIND v(dout1_113) AT=795.025n

.meas tran vdout1_114ck1580 FIND v(dout1_114) AT=795.025n

.meas tran vdout1_115ck1580 FIND v(dout1_115) AT=795.025n

.meas tran vdout1_116ck1580 FIND v(dout1_116) AT=795.025n

.meas tran vdout1_117ck1580 FIND v(dout1_117) AT=795.025n

.meas tran vdout1_118ck1580 FIND v(dout1_118) AT=795.025n

.meas tran vdout1_119ck1580 FIND v(dout1_119) AT=795.025n

.meas tran vdout1_120ck1580 FIND v(dout1_120) AT=795.025n

.meas tran vdout1_121ck1580 FIND v(dout1_121) AT=795.025n

.meas tran vdout1_122ck1580 FIND v(dout1_122) AT=795.025n

.meas tran vdout1_123ck1580 FIND v(dout1_123) AT=795.025n

.meas tran vdout1_124ck1580 FIND v(dout1_124) AT=795.025n

.meas tran vdout1_125ck1580 FIND v(dout1_125) AT=795.025n

.meas tran vdout1_126ck1580 FIND v(dout1_126) AT=795.025n

.meas tran vdout1_127ck1580 FIND v(dout1_127) AT=795.025n

.meas tran vdout1_0ck1600 FIND v(dout1_0) AT=805.025n

.meas tran vdout1_1ck1600 FIND v(dout1_1) AT=805.025n

.meas tran vdout1_2ck1600 FIND v(dout1_2) AT=805.025n

.meas tran vdout1_3ck1600 FIND v(dout1_3) AT=805.025n

.meas tran vdout1_4ck1600 FIND v(dout1_4) AT=805.025n

.meas tran vdout1_5ck1600 FIND v(dout1_5) AT=805.025n

.meas tran vdout1_6ck1600 FIND v(dout1_6) AT=805.025n

.meas tran vdout1_7ck1600 FIND v(dout1_7) AT=805.025n

.meas tran vdout1_8ck1600 FIND v(dout1_8) AT=805.025n

.meas tran vdout1_9ck1600 FIND v(dout1_9) AT=805.025n

.meas tran vdout1_10ck1600 FIND v(dout1_10) AT=805.025n

.meas tran vdout1_11ck1600 FIND v(dout1_11) AT=805.025n

.meas tran vdout1_12ck1600 FIND v(dout1_12) AT=805.025n

.meas tran vdout1_13ck1600 FIND v(dout1_13) AT=805.025n

.meas tran vdout1_14ck1600 FIND v(dout1_14) AT=805.025n

.meas tran vdout1_15ck1600 FIND v(dout1_15) AT=805.025n

.meas tran vdout1_16ck1600 FIND v(dout1_16) AT=805.025n

.meas tran vdout1_17ck1600 FIND v(dout1_17) AT=805.025n

.meas tran vdout1_18ck1600 FIND v(dout1_18) AT=805.025n

.meas tran vdout1_19ck1600 FIND v(dout1_19) AT=805.025n

.meas tran vdout1_20ck1600 FIND v(dout1_20) AT=805.025n

.meas tran vdout1_21ck1600 FIND v(dout1_21) AT=805.025n

.meas tran vdout1_22ck1600 FIND v(dout1_22) AT=805.025n

.meas tran vdout1_23ck1600 FIND v(dout1_23) AT=805.025n

.meas tran vdout1_24ck1600 FIND v(dout1_24) AT=805.025n

.meas tran vdout1_25ck1600 FIND v(dout1_25) AT=805.025n

.meas tran vdout1_26ck1600 FIND v(dout1_26) AT=805.025n

.meas tran vdout1_27ck1600 FIND v(dout1_27) AT=805.025n

.meas tran vdout1_28ck1600 FIND v(dout1_28) AT=805.025n

.meas tran vdout1_29ck1600 FIND v(dout1_29) AT=805.025n

.meas tran vdout1_30ck1600 FIND v(dout1_30) AT=805.025n

.meas tran vdout1_31ck1600 FIND v(dout1_31) AT=805.025n

.meas tran vdout1_32ck1600 FIND v(dout1_32) AT=805.025n

.meas tran vdout1_33ck1600 FIND v(dout1_33) AT=805.025n

.meas tran vdout1_34ck1600 FIND v(dout1_34) AT=805.025n

.meas tran vdout1_35ck1600 FIND v(dout1_35) AT=805.025n

.meas tran vdout1_36ck1600 FIND v(dout1_36) AT=805.025n

.meas tran vdout1_37ck1600 FIND v(dout1_37) AT=805.025n

.meas tran vdout1_38ck1600 FIND v(dout1_38) AT=805.025n

.meas tran vdout1_39ck1600 FIND v(dout1_39) AT=805.025n

.meas tran vdout1_40ck1600 FIND v(dout1_40) AT=805.025n

.meas tran vdout1_41ck1600 FIND v(dout1_41) AT=805.025n

.meas tran vdout1_42ck1600 FIND v(dout1_42) AT=805.025n

.meas tran vdout1_43ck1600 FIND v(dout1_43) AT=805.025n

.meas tran vdout1_44ck1600 FIND v(dout1_44) AT=805.025n

.meas tran vdout1_45ck1600 FIND v(dout1_45) AT=805.025n

.meas tran vdout1_46ck1600 FIND v(dout1_46) AT=805.025n

.meas tran vdout1_47ck1600 FIND v(dout1_47) AT=805.025n

.meas tran vdout1_48ck1600 FIND v(dout1_48) AT=805.025n

.meas tran vdout1_49ck1600 FIND v(dout1_49) AT=805.025n

.meas tran vdout1_50ck1600 FIND v(dout1_50) AT=805.025n

.meas tran vdout1_51ck1600 FIND v(dout1_51) AT=805.025n

.meas tran vdout1_52ck1600 FIND v(dout1_52) AT=805.025n

.meas tran vdout1_53ck1600 FIND v(dout1_53) AT=805.025n

.meas tran vdout1_54ck1600 FIND v(dout1_54) AT=805.025n

.meas tran vdout1_55ck1600 FIND v(dout1_55) AT=805.025n

.meas tran vdout1_56ck1600 FIND v(dout1_56) AT=805.025n

.meas tran vdout1_57ck1600 FIND v(dout1_57) AT=805.025n

.meas tran vdout1_58ck1600 FIND v(dout1_58) AT=805.025n

.meas tran vdout1_59ck1600 FIND v(dout1_59) AT=805.025n

.meas tran vdout1_60ck1600 FIND v(dout1_60) AT=805.025n

.meas tran vdout1_61ck1600 FIND v(dout1_61) AT=805.025n

.meas tran vdout1_62ck1600 FIND v(dout1_62) AT=805.025n

.meas tran vdout1_63ck1600 FIND v(dout1_63) AT=805.025n

.meas tran vdout1_64ck1600 FIND v(dout1_64) AT=805.025n

.meas tran vdout1_65ck1600 FIND v(dout1_65) AT=805.025n

.meas tran vdout1_66ck1600 FIND v(dout1_66) AT=805.025n

.meas tran vdout1_67ck1600 FIND v(dout1_67) AT=805.025n

.meas tran vdout1_68ck1600 FIND v(dout1_68) AT=805.025n

.meas tran vdout1_69ck1600 FIND v(dout1_69) AT=805.025n

.meas tran vdout1_70ck1600 FIND v(dout1_70) AT=805.025n

.meas tran vdout1_71ck1600 FIND v(dout1_71) AT=805.025n

.meas tran vdout1_72ck1600 FIND v(dout1_72) AT=805.025n

.meas tran vdout1_73ck1600 FIND v(dout1_73) AT=805.025n

.meas tran vdout1_74ck1600 FIND v(dout1_74) AT=805.025n

.meas tran vdout1_75ck1600 FIND v(dout1_75) AT=805.025n

.meas tran vdout1_76ck1600 FIND v(dout1_76) AT=805.025n

.meas tran vdout1_77ck1600 FIND v(dout1_77) AT=805.025n

.meas tran vdout1_78ck1600 FIND v(dout1_78) AT=805.025n

.meas tran vdout1_79ck1600 FIND v(dout1_79) AT=805.025n

.meas tran vdout1_80ck1600 FIND v(dout1_80) AT=805.025n

.meas tran vdout1_81ck1600 FIND v(dout1_81) AT=805.025n

.meas tran vdout1_82ck1600 FIND v(dout1_82) AT=805.025n

.meas tran vdout1_83ck1600 FIND v(dout1_83) AT=805.025n

.meas tran vdout1_84ck1600 FIND v(dout1_84) AT=805.025n

.meas tran vdout1_85ck1600 FIND v(dout1_85) AT=805.025n

.meas tran vdout1_86ck1600 FIND v(dout1_86) AT=805.025n

.meas tran vdout1_87ck1600 FIND v(dout1_87) AT=805.025n

.meas tran vdout1_88ck1600 FIND v(dout1_88) AT=805.025n

.meas tran vdout1_89ck1600 FIND v(dout1_89) AT=805.025n

.meas tran vdout1_90ck1600 FIND v(dout1_90) AT=805.025n

.meas tran vdout1_91ck1600 FIND v(dout1_91) AT=805.025n

.meas tran vdout1_92ck1600 FIND v(dout1_92) AT=805.025n

.meas tran vdout1_93ck1600 FIND v(dout1_93) AT=805.025n

.meas tran vdout1_94ck1600 FIND v(dout1_94) AT=805.025n

.meas tran vdout1_95ck1600 FIND v(dout1_95) AT=805.025n

.meas tran vdout1_96ck1600 FIND v(dout1_96) AT=805.025n

.meas tran vdout1_97ck1600 FIND v(dout1_97) AT=805.025n

.meas tran vdout1_98ck1600 FIND v(dout1_98) AT=805.025n

.meas tran vdout1_99ck1600 FIND v(dout1_99) AT=805.025n

.meas tran vdout1_100ck1600 FIND v(dout1_100) AT=805.025n

.meas tran vdout1_101ck1600 FIND v(dout1_101) AT=805.025n

.meas tran vdout1_102ck1600 FIND v(dout1_102) AT=805.025n

.meas tran vdout1_103ck1600 FIND v(dout1_103) AT=805.025n

.meas tran vdout1_104ck1600 FIND v(dout1_104) AT=805.025n

.meas tran vdout1_105ck1600 FIND v(dout1_105) AT=805.025n

.meas tran vdout1_106ck1600 FIND v(dout1_106) AT=805.025n

.meas tran vdout1_107ck1600 FIND v(dout1_107) AT=805.025n

.meas tran vdout1_108ck1600 FIND v(dout1_108) AT=805.025n

.meas tran vdout1_109ck1600 FIND v(dout1_109) AT=805.025n

.meas tran vdout1_110ck1600 FIND v(dout1_110) AT=805.025n

.meas tran vdout1_111ck1600 FIND v(dout1_111) AT=805.025n

.meas tran vdout1_112ck1600 FIND v(dout1_112) AT=805.025n

.meas tran vdout1_113ck1600 FIND v(dout1_113) AT=805.025n

.meas tran vdout1_114ck1600 FIND v(dout1_114) AT=805.025n

.meas tran vdout1_115ck1600 FIND v(dout1_115) AT=805.025n

.meas tran vdout1_116ck1600 FIND v(dout1_116) AT=805.025n

.meas tran vdout1_117ck1600 FIND v(dout1_117) AT=805.025n

.meas tran vdout1_118ck1600 FIND v(dout1_118) AT=805.025n

.meas tran vdout1_119ck1600 FIND v(dout1_119) AT=805.025n

.meas tran vdout1_120ck1600 FIND v(dout1_120) AT=805.025n

.meas tran vdout1_121ck1600 FIND v(dout1_121) AT=805.025n

.meas tran vdout1_122ck1600 FIND v(dout1_122) AT=805.025n

.meas tran vdout1_123ck1600 FIND v(dout1_123) AT=805.025n

.meas tran vdout1_124ck1600 FIND v(dout1_124) AT=805.025n

.meas tran vdout1_125ck1600 FIND v(dout1_125) AT=805.025n

.meas tran vdout1_126ck1600 FIND v(dout1_126) AT=805.025n

.meas tran vdout1_127ck1600 FIND v(dout1_127) AT=805.025n

.meas tran vdout1_0ck1610 FIND v(dout1_0) AT=810.025n

.meas tran vdout1_1ck1610 FIND v(dout1_1) AT=810.025n

.meas tran vdout1_2ck1610 FIND v(dout1_2) AT=810.025n

.meas tran vdout1_3ck1610 FIND v(dout1_3) AT=810.025n

.meas tran vdout1_4ck1610 FIND v(dout1_4) AT=810.025n

.meas tran vdout1_5ck1610 FIND v(dout1_5) AT=810.025n

.meas tran vdout1_6ck1610 FIND v(dout1_6) AT=810.025n

.meas tran vdout1_7ck1610 FIND v(dout1_7) AT=810.025n

.meas tran vdout1_8ck1610 FIND v(dout1_8) AT=810.025n

.meas tran vdout1_9ck1610 FIND v(dout1_9) AT=810.025n

.meas tran vdout1_10ck1610 FIND v(dout1_10) AT=810.025n

.meas tran vdout1_11ck1610 FIND v(dout1_11) AT=810.025n

.meas tran vdout1_12ck1610 FIND v(dout1_12) AT=810.025n

.meas tran vdout1_13ck1610 FIND v(dout1_13) AT=810.025n

.meas tran vdout1_14ck1610 FIND v(dout1_14) AT=810.025n

.meas tran vdout1_15ck1610 FIND v(dout1_15) AT=810.025n

.meas tran vdout1_16ck1610 FIND v(dout1_16) AT=810.025n

.meas tran vdout1_17ck1610 FIND v(dout1_17) AT=810.025n

.meas tran vdout1_18ck1610 FIND v(dout1_18) AT=810.025n

.meas tran vdout1_19ck1610 FIND v(dout1_19) AT=810.025n

.meas tran vdout1_20ck1610 FIND v(dout1_20) AT=810.025n

.meas tran vdout1_21ck1610 FIND v(dout1_21) AT=810.025n

.meas tran vdout1_22ck1610 FIND v(dout1_22) AT=810.025n

.meas tran vdout1_23ck1610 FIND v(dout1_23) AT=810.025n

.meas tran vdout1_24ck1610 FIND v(dout1_24) AT=810.025n

.meas tran vdout1_25ck1610 FIND v(dout1_25) AT=810.025n

.meas tran vdout1_26ck1610 FIND v(dout1_26) AT=810.025n

.meas tran vdout1_27ck1610 FIND v(dout1_27) AT=810.025n

.meas tran vdout1_28ck1610 FIND v(dout1_28) AT=810.025n

.meas tran vdout1_29ck1610 FIND v(dout1_29) AT=810.025n

.meas tran vdout1_30ck1610 FIND v(dout1_30) AT=810.025n

.meas tran vdout1_31ck1610 FIND v(dout1_31) AT=810.025n

.meas tran vdout1_32ck1610 FIND v(dout1_32) AT=810.025n

.meas tran vdout1_33ck1610 FIND v(dout1_33) AT=810.025n

.meas tran vdout1_34ck1610 FIND v(dout1_34) AT=810.025n

.meas tran vdout1_35ck1610 FIND v(dout1_35) AT=810.025n

.meas tran vdout1_36ck1610 FIND v(dout1_36) AT=810.025n

.meas tran vdout1_37ck1610 FIND v(dout1_37) AT=810.025n

.meas tran vdout1_38ck1610 FIND v(dout1_38) AT=810.025n

.meas tran vdout1_39ck1610 FIND v(dout1_39) AT=810.025n

.meas tran vdout1_40ck1610 FIND v(dout1_40) AT=810.025n

.meas tran vdout1_41ck1610 FIND v(dout1_41) AT=810.025n

.meas tran vdout1_42ck1610 FIND v(dout1_42) AT=810.025n

.meas tran vdout1_43ck1610 FIND v(dout1_43) AT=810.025n

.meas tran vdout1_44ck1610 FIND v(dout1_44) AT=810.025n

.meas tran vdout1_45ck1610 FIND v(dout1_45) AT=810.025n

.meas tran vdout1_46ck1610 FIND v(dout1_46) AT=810.025n

.meas tran vdout1_47ck1610 FIND v(dout1_47) AT=810.025n

.meas tran vdout1_48ck1610 FIND v(dout1_48) AT=810.025n

.meas tran vdout1_49ck1610 FIND v(dout1_49) AT=810.025n

.meas tran vdout1_50ck1610 FIND v(dout1_50) AT=810.025n

.meas tran vdout1_51ck1610 FIND v(dout1_51) AT=810.025n

.meas tran vdout1_52ck1610 FIND v(dout1_52) AT=810.025n

.meas tran vdout1_53ck1610 FIND v(dout1_53) AT=810.025n

.meas tran vdout1_54ck1610 FIND v(dout1_54) AT=810.025n

.meas tran vdout1_55ck1610 FIND v(dout1_55) AT=810.025n

.meas tran vdout1_56ck1610 FIND v(dout1_56) AT=810.025n

.meas tran vdout1_57ck1610 FIND v(dout1_57) AT=810.025n

.meas tran vdout1_58ck1610 FIND v(dout1_58) AT=810.025n

.meas tran vdout1_59ck1610 FIND v(dout1_59) AT=810.025n

.meas tran vdout1_60ck1610 FIND v(dout1_60) AT=810.025n

.meas tran vdout1_61ck1610 FIND v(dout1_61) AT=810.025n

.meas tran vdout1_62ck1610 FIND v(dout1_62) AT=810.025n

.meas tran vdout1_63ck1610 FIND v(dout1_63) AT=810.025n

.meas tran vdout1_64ck1610 FIND v(dout1_64) AT=810.025n

.meas tran vdout1_65ck1610 FIND v(dout1_65) AT=810.025n

.meas tran vdout1_66ck1610 FIND v(dout1_66) AT=810.025n

.meas tran vdout1_67ck1610 FIND v(dout1_67) AT=810.025n

.meas tran vdout1_68ck1610 FIND v(dout1_68) AT=810.025n

.meas tran vdout1_69ck1610 FIND v(dout1_69) AT=810.025n

.meas tran vdout1_70ck1610 FIND v(dout1_70) AT=810.025n

.meas tran vdout1_71ck1610 FIND v(dout1_71) AT=810.025n

.meas tran vdout1_72ck1610 FIND v(dout1_72) AT=810.025n

.meas tran vdout1_73ck1610 FIND v(dout1_73) AT=810.025n

.meas tran vdout1_74ck1610 FIND v(dout1_74) AT=810.025n

.meas tran vdout1_75ck1610 FIND v(dout1_75) AT=810.025n

.meas tran vdout1_76ck1610 FIND v(dout1_76) AT=810.025n

.meas tran vdout1_77ck1610 FIND v(dout1_77) AT=810.025n

.meas tran vdout1_78ck1610 FIND v(dout1_78) AT=810.025n

.meas tran vdout1_79ck1610 FIND v(dout1_79) AT=810.025n

.meas tran vdout1_80ck1610 FIND v(dout1_80) AT=810.025n

.meas tran vdout1_81ck1610 FIND v(dout1_81) AT=810.025n

.meas tran vdout1_82ck1610 FIND v(dout1_82) AT=810.025n

.meas tran vdout1_83ck1610 FIND v(dout1_83) AT=810.025n

.meas tran vdout1_84ck1610 FIND v(dout1_84) AT=810.025n

.meas tran vdout1_85ck1610 FIND v(dout1_85) AT=810.025n

.meas tran vdout1_86ck1610 FIND v(dout1_86) AT=810.025n

.meas tran vdout1_87ck1610 FIND v(dout1_87) AT=810.025n

.meas tran vdout1_88ck1610 FIND v(dout1_88) AT=810.025n

.meas tran vdout1_89ck1610 FIND v(dout1_89) AT=810.025n

.meas tran vdout1_90ck1610 FIND v(dout1_90) AT=810.025n

.meas tran vdout1_91ck1610 FIND v(dout1_91) AT=810.025n

.meas tran vdout1_92ck1610 FIND v(dout1_92) AT=810.025n

.meas tran vdout1_93ck1610 FIND v(dout1_93) AT=810.025n

.meas tran vdout1_94ck1610 FIND v(dout1_94) AT=810.025n

.meas tran vdout1_95ck1610 FIND v(dout1_95) AT=810.025n

.meas tran vdout1_96ck1610 FIND v(dout1_96) AT=810.025n

.meas tran vdout1_97ck1610 FIND v(dout1_97) AT=810.025n

.meas tran vdout1_98ck1610 FIND v(dout1_98) AT=810.025n

.meas tran vdout1_99ck1610 FIND v(dout1_99) AT=810.025n

.meas tran vdout1_100ck1610 FIND v(dout1_100) AT=810.025n

.meas tran vdout1_101ck1610 FIND v(dout1_101) AT=810.025n

.meas tran vdout1_102ck1610 FIND v(dout1_102) AT=810.025n

.meas tran vdout1_103ck1610 FIND v(dout1_103) AT=810.025n

.meas tran vdout1_104ck1610 FIND v(dout1_104) AT=810.025n

.meas tran vdout1_105ck1610 FIND v(dout1_105) AT=810.025n

.meas tran vdout1_106ck1610 FIND v(dout1_106) AT=810.025n

.meas tran vdout1_107ck1610 FIND v(dout1_107) AT=810.025n

.meas tran vdout1_108ck1610 FIND v(dout1_108) AT=810.025n

.meas tran vdout1_109ck1610 FIND v(dout1_109) AT=810.025n

.meas tran vdout1_110ck1610 FIND v(dout1_110) AT=810.025n

.meas tran vdout1_111ck1610 FIND v(dout1_111) AT=810.025n

.meas tran vdout1_112ck1610 FIND v(dout1_112) AT=810.025n

.meas tran vdout1_113ck1610 FIND v(dout1_113) AT=810.025n

.meas tran vdout1_114ck1610 FIND v(dout1_114) AT=810.025n

.meas tran vdout1_115ck1610 FIND v(dout1_115) AT=810.025n

.meas tran vdout1_116ck1610 FIND v(dout1_116) AT=810.025n

.meas tran vdout1_117ck1610 FIND v(dout1_117) AT=810.025n

.meas tran vdout1_118ck1610 FIND v(dout1_118) AT=810.025n

.meas tran vdout1_119ck1610 FIND v(dout1_119) AT=810.025n

.meas tran vdout1_120ck1610 FIND v(dout1_120) AT=810.025n

.meas tran vdout1_121ck1610 FIND v(dout1_121) AT=810.025n

.meas tran vdout1_122ck1610 FIND v(dout1_122) AT=810.025n

.meas tran vdout1_123ck1610 FIND v(dout1_123) AT=810.025n

.meas tran vdout1_124ck1610 FIND v(dout1_124) AT=810.025n

.meas tran vdout1_125ck1610 FIND v(dout1_125) AT=810.025n

.meas tran vdout1_126ck1610 FIND v(dout1_126) AT=810.025n

.meas tran vdout1_127ck1610 FIND v(dout1_127) AT=810.025n

.meas tran vdout1_0ck1620 FIND v(dout1_0) AT=815.025n

.meas tran vdout1_1ck1620 FIND v(dout1_1) AT=815.025n

.meas tran vdout1_2ck1620 FIND v(dout1_2) AT=815.025n

.meas tran vdout1_3ck1620 FIND v(dout1_3) AT=815.025n

.meas tran vdout1_4ck1620 FIND v(dout1_4) AT=815.025n

.meas tran vdout1_5ck1620 FIND v(dout1_5) AT=815.025n

.meas tran vdout1_6ck1620 FIND v(dout1_6) AT=815.025n

.meas tran vdout1_7ck1620 FIND v(dout1_7) AT=815.025n

.meas tran vdout1_8ck1620 FIND v(dout1_8) AT=815.025n

.meas tran vdout1_9ck1620 FIND v(dout1_9) AT=815.025n

.meas tran vdout1_10ck1620 FIND v(dout1_10) AT=815.025n

.meas tran vdout1_11ck1620 FIND v(dout1_11) AT=815.025n

.meas tran vdout1_12ck1620 FIND v(dout1_12) AT=815.025n

.meas tran vdout1_13ck1620 FIND v(dout1_13) AT=815.025n

.meas tran vdout1_14ck1620 FIND v(dout1_14) AT=815.025n

.meas tran vdout1_15ck1620 FIND v(dout1_15) AT=815.025n

.meas tran vdout1_16ck1620 FIND v(dout1_16) AT=815.025n

.meas tran vdout1_17ck1620 FIND v(dout1_17) AT=815.025n

.meas tran vdout1_18ck1620 FIND v(dout1_18) AT=815.025n

.meas tran vdout1_19ck1620 FIND v(dout1_19) AT=815.025n

.meas tran vdout1_20ck1620 FIND v(dout1_20) AT=815.025n

.meas tran vdout1_21ck1620 FIND v(dout1_21) AT=815.025n

.meas tran vdout1_22ck1620 FIND v(dout1_22) AT=815.025n

.meas tran vdout1_23ck1620 FIND v(dout1_23) AT=815.025n

.meas tran vdout1_24ck1620 FIND v(dout1_24) AT=815.025n

.meas tran vdout1_25ck1620 FIND v(dout1_25) AT=815.025n

.meas tran vdout1_26ck1620 FIND v(dout1_26) AT=815.025n

.meas tran vdout1_27ck1620 FIND v(dout1_27) AT=815.025n

.meas tran vdout1_28ck1620 FIND v(dout1_28) AT=815.025n

.meas tran vdout1_29ck1620 FIND v(dout1_29) AT=815.025n

.meas tran vdout1_30ck1620 FIND v(dout1_30) AT=815.025n

.meas tran vdout1_31ck1620 FIND v(dout1_31) AT=815.025n

.meas tran vdout1_32ck1620 FIND v(dout1_32) AT=815.025n

.meas tran vdout1_33ck1620 FIND v(dout1_33) AT=815.025n

.meas tran vdout1_34ck1620 FIND v(dout1_34) AT=815.025n

.meas tran vdout1_35ck1620 FIND v(dout1_35) AT=815.025n

.meas tran vdout1_36ck1620 FIND v(dout1_36) AT=815.025n

.meas tran vdout1_37ck1620 FIND v(dout1_37) AT=815.025n

.meas tran vdout1_38ck1620 FIND v(dout1_38) AT=815.025n

.meas tran vdout1_39ck1620 FIND v(dout1_39) AT=815.025n

.meas tran vdout1_40ck1620 FIND v(dout1_40) AT=815.025n

.meas tran vdout1_41ck1620 FIND v(dout1_41) AT=815.025n

.meas tran vdout1_42ck1620 FIND v(dout1_42) AT=815.025n

.meas tran vdout1_43ck1620 FIND v(dout1_43) AT=815.025n

.meas tran vdout1_44ck1620 FIND v(dout1_44) AT=815.025n

.meas tran vdout1_45ck1620 FIND v(dout1_45) AT=815.025n

.meas tran vdout1_46ck1620 FIND v(dout1_46) AT=815.025n

.meas tran vdout1_47ck1620 FIND v(dout1_47) AT=815.025n

.meas tran vdout1_48ck1620 FIND v(dout1_48) AT=815.025n

.meas tran vdout1_49ck1620 FIND v(dout1_49) AT=815.025n

.meas tran vdout1_50ck1620 FIND v(dout1_50) AT=815.025n

.meas tran vdout1_51ck1620 FIND v(dout1_51) AT=815.025n

.meas tran vdout1_52ck1620 FIND v(dout1_52) AT=815.025n

.meas tran vdout1_53ck1620 FIND v(dout1_53) AT=815.025n

.meas tran vdout1_54ck1620 FIND v(dout1_54) AT=815.025n

.meas tran vdout1_55ck1620 FIND v(dout1_55) AT=815.025n

.meas tran vdout1_56ck1620 FIND v(dout1_56) AT=815.025n

.meas tran vdout1_57ck1620 FIND v(dout1_57) AT=815.025n

.meas tran vdout1_58ck1620 FIND v(dout1_58) AT=815.025n

.meas tran vdout1_59ck1620 FIND v(dout1_59) AT=815.025n

.meas tran vdout1_60ck1620 FIND v(dout1_60) AT=815.025n

.meas tran vdout1_61ck1620 FIND v(dout1_61) AT=815.025n

.meas tran vdout1_62ck1620 FIND v(dout1_62) AT=815.025n

.meas tran vdout1_63ck1620 FIND v(dout1_63) AT=815.025n

.meas tran vdout1_64ck1620 FIND v(dout1_64) AT=815.025n

.meas tran vdout1_65ck1620 FIND v(dout1_65) AT=815.025n

.meas tran vdout1_66ck1620 FIND v(dout1_66) AT=815.025n

.meas tran vdout1_67ck1620 FIND v(dout1_67) AT=815.025n

.meas tran vdout1_68ck1620 FIND v(dout1_68) AT=815.025n

.meas tran vdout1_69ck1620 FIND v(dout1_69) AT=815.025n

.meas tran vdout1_70ck1620 FIND v(dout1_70) AT=815.025n

.meas tran vdout1_71ck1620 FIND v(dout1_71) AT=815.025n

.meas tran vdout1_72ck1620 FIND v(dout1_72) AT=815.025n

.meas tran vdout1_73ck1620 FIND v(dout1_73) AT=815.025n

.meas tran vdout1_74ck1620 FIND v(dout1_74) AT=815.025n

.meas tran vdout1_75ck1620 FIND v(dout1_75) AT=815.025n

.meas tran vdout1_76ck1620 FIND v(dout1_76) AT=815.025n

.meas tran vdout1_77ck1620 FIND v(dout1_77) AT=815.025n

.meas tran vdout1_78ck1620 FIND v(dout1_78) AT=815.025n

.meas tran vdout1_79ck1620 FIND v(dout1_79) AT=815.025n

.meas tran vdout1_80ck1620 FIND v(dout1_80) AT=815.025n

.meas tran vdout1_81ck1620 FIND v(dout1_81) AT=815.025n

.meas tran vdout1_82ck1620 FIND v(dout1_82) AT=815.025n

.meas tran vdout1_83ck1620 FIND v(dout1_83) AT=815.025n

.meas tran vdout1_84ck1620 FIND v(dout1_84) AT=815.025n

.meas tran vdout1_85ck1620 FIND v(dout1_85) AT=815.025n

.meas tran vdout1_86ck1620 FIND v(dout1_86) AT=815.025n

.meas tran vdout1_87ck1620 FIND v(dout1_87) AT=815.025n

.meas tran vdout1_88ck1620 FIND v(dout1_88) AT=815.025n

.meas tran vdout1_89ck1620 FIND v(dout1_89) AT=815.025n

.meas tran vdout1_90ck1620 FIND v(dout1_90) AT=815.025n

.meas tran vdout1_91ck1620 FIND v(dout1_91) AT=815.025n

.meas tran vdout1_92ck1620 FIND v(dout1_92) AT=815.025n

.meas tran vdout1_93ck1620 FIND v(dout1_93) AT=815.025n

.meas tran vdout1_94ck1620 FIND v(dout1_94) AT=815.025n

.meas tran vdout1_95ck1620 FIND v(dout1_95) AT=815.025n

.meas tran vdout1_96ck1620 FIND v(dout1_96) AT=815.025n

.meas tran vdout1_97ck1620 FIND v(dout1_97) AT=815.025n

.meas tran vdout1_98ck1620 FIND v(dout1_98) AT=815.025n

.meas tran vdout1_99ck1620 FIND v(dout1_99) AT=815.025n

.meas tran vdout1_100ck1620 FIND v(dout1_100) AT=815.025n

.meas tran vdout1_101ck1620 FIND v(dout1_101) AT=815.025n

.meas tran vdout1_102ck1620 FIND v(dout1_102) AT=815.025n

.meas tran vdout1_103ck1620 FIND v(dout1_103) AT=815.025n

.meas tran vdout1_104ck1620 FIND v(dout1_104) AT=815.025n

.meas tran vdout1_105ck1620 FIND v(dout1_105) AT=815.025n

.meas tran vdout1_106ck1620 FIND v(dout1_106) AT=815.025n

.meas tran vdout1_107ck1620 FIND v(dout1_107) AT=815.025n

.meas tran vdout1_108ck1620 FIND v(dout1_108) AT=815.025n

.meas tran vdout1_109ck1620 FIND v(dout1_109) AT=815.025n

.meas tran vdout1_110ck1620 FIND v(dout1_110) AT=815.025n

.meas tran vdout1_111ck1620 FIND v(dout1_111) AT=815.025n

.meas tran vdout1_112ck1620 FIND v(dout1_112) AT=815.025n

.meas tran vdout1_113ck1620 FIND v(dout1_113) AT=815.025n

.meas tran vdout1_114ck1620 FIND v(dout1_114) AT=815.025n

.meas tran vdout1_115ck1620 FIND v(dout1_115) AT=815.025n

.meas tran vdout1_116ck1620 FIND v(dout1_116) AT=815.025n

.meas tran vdout1_117ck1620 FIND v(dout1_117) AT=815.025n

.meas tran vdout1_118ck1620 FIND v(dout1_118) AT=815.025n

.meas tran vdout1_119ck1620 FIND v(dout1_119) AT=815.025n

.meas tran vdout1_120ck1620 FIND v(dout1_120) AT=815.025n

.meas tran vdout1_121ck1620 FIND v(dout1_121) AT=815.025n

.meas tran vdout1_122ck1620 FIND v(dout1_122) AT=815.025n

.meas tran vdout1_123ck1620 FIND v(dout1_123) AT=815.025n

.meas tran vdout1_124ck1620 FIND v(dout1_124) AT=815.025n

.meas tran vdout1_125ck1620 FIND v(dout1_125) AT=815.025n

.meas tran vdout1_126ck1620 FIND v(dout1_126) AT=815.025n

.meas tran vdout1_127ck1620 FIND v(dout1_127) AT=815.025n

.meas tran vdout1_0ck1630 FIND v(dout1_0) AT=820.025n

.meas tran vdout1_1ck1630 FIND v(dout1_1) AT=820.025n

.meas tran vdout1_2ck1630 FIND v(dout1_2) AT=820.025n

.meas tran vdout1_3ck1630 FIND v(dout1_3) AT=820.025n

.meas tran vdout1_4ck1630 FIND v(dout1_4) AT=820.025n

.meas tran vdout1_5ck1630 FIND v(dout1_5) AT=820.025n

.meas tran vdout1_6ck1630 FIND v(dout1_6) AT=820.025n

.meas tran vdout1_7ck1630 FIND v(dout1_7) AT=820.025n

.meas tran vdout1_8ck1630 FIND v(dout1_8) AT=820.025n

.meas tran vdout1_9ck1630 FIND v(dout1_9) AT=820.025n

.meas tran vdout1_10ck1630 FIND v(dout1_10) AT=820.025n

.meas tran vdout1_11ck1630 FIND v(dout1_11) AT=820.025n

.meas tran vdout1_12ck1630 FIND v(dout1_12) AT=820.025n

.meas tran vdout1_13ck1630 FIND v(dout1_13) AT=820.025n

.meas tran vdout1_14ck1630 FIND v(dout1_14) AT=820.025n

.meas tran vdout1_15ck1630 FIND v(dout1_15) AT=820.025n

.meas tran vdout1_16ck1630 FIND v(dout1_16) AT=820.025n

.meas tran vdout1_17ck1630 FIND v(dout1_17) AT=820.025n

.meas tran vdout1_18ck1630 FIND v(dout1_18) AT=820.025n

.meas tran vdout1_19ck1630 FIND v(dout1_19) AT=820.025n

.meas tran vdout1_20ck1630 FIND v(dout1_20) AT=820.025n

.meas tran vdout1_21ck1630 FIND v(dout1_21) AT=820.025n

.meas tran vdout1_22ck1630 FIND v(dout1_22) AT=820.025n

.meas tran vdout1_23ck1630 FIND v(dout1_23) AT=820.025n

.meas tran vdout1_24ck1630 FIND v(dout1_24) AT=820.025n

.meas tran vdout1_25ck1630 FIND v(dout1_25) AT=820.025n

.meas tran vdout1_26ck1630 FIND v(dout1_26) AT=820.025n

.meas tran vdout1_27ck1630 FIND v(dout1_27) AT=820.025n

.meas tran vdout1_28ck1630 FIND v(dout1_28) AT=820.025n

.meas tran vdout1_29ck1630 FIND v(dout1_29) AT=820.025n

.meas tran vdout1_30ck1630 FIND v(dout1_30) AT=820.025n

.meas tran vdout1_31ck1630 FIND v(dout1_31) AT=820.025n

.meas tran vdout1_32ck1630 FIND v(dout1_32) AT=820.025n

.meas tran vdout1_33ck1630 FIND v(dout1_33) AT=820.025n

.meas tran vdout1_34ck1630 FIND v(dout1_34) AT=820.025n

.meas tran vdout1_35ck1630 FIND v(dout1_35) AT=820.025n

.meas tran vdout1_36ck1630 FIND v(dout1_36) AT=820.025n

.meas tran vdout1_37ck1630 FIND v(dout1_37) AT=820.025n

.meas tran vdout1_38ck1630 FIND v(dout1_38) AT=820.025n

.meas tran vdout1_39ck1630 FIND v(dout1_39) AT=820.025n

.meas tran vdout1_40ck1630 FIND v(dout1_40) AT=820.025n

.meas tran vdout1_41ck1630 FIND v(dout1_41) AT=820.025n

.meas tran vdout1_42ck1630 FIND v(dout1_42) AT=820.025n

.meas tran vdout1_43ck1630 FIND v(dout1_43) AT=820.025n

.meas tran vdout1_44ck1630 FIND v(dout1_44) AT=820.025n

.meas tran vdout1_45ck1630 FIND v(dout1_45) AT=820.025n

.meas tran vdout1_46ck1630 FIND v(dout1_46) AT=820.025n

.meas tran vdout1_47ck1630 FIND v(dout1_47) AT=820.025n

.meas tran vdout1_48ck1630 FIND v(dout1_48) AT=820.025n

.meas tran vdout1_49ck1630 FIND v(dout1_49) AT=820.025n

.meas tran vdout1_50ck1630 FIND v(dout1_50) AT=820.025n

.meas tran vdout1_51ck1630 FIND v(dout1_51) AT=820.025n

.meas tran vdout1_52ck1630 FIND v(dout1_52) AT=820.025n

.meas tran vdout1_53ck1630 FIND v(dout1_53) AT=820.025n

.meas tran vdout1_54ck1630 FIND v(dout1_54) AT=820.025n

.meas tran vdout1_55ck1630 FIND v(dout1_55) AT=820.025n

.meas tran vdout1_56ck1630 FIND v(dout1_56) AT=820.025n

.meas tran vdout1_57ck1630 FIND v(dout1_57) AT=820.025n

.meas tran vdout1_58ck1630 FIND v(dout1_58) AT=820.025n

.meas tran vdout1_59ck1630 FIND v(dout1_59) AT=820.025n

.meas tran vdout1_60ck1630 FIND v(dout1_60) AT=820.025n

.meas tran vdout1_61ck1630 FIND v(dout1_61) AT=820.025n

.meas tran vdout1_62ck1630 FIND v(dout1_62) AT=820.025n

.meas tran vdout1_63ck1630 FIND v(dout1_63) AT=820.025n

.meas tran vdout1_64ck1630 FIND v(dout1_64) AT=820.025n

.meas tran vdout1_65ck1630 FIND v(dout1_65) AT=820.025n

.meas tran vdout1_66ck1630 FIND v(dout1_66) AT=820.025n

.meas tran vdout1_67ck1630 FIND v(dout1_67) AT=820.025n

.meas tran vdout1_68ck1630 FIND v(dout1_68) AT=820.025n

.meas tran vdout1_69ck1630 FIND v(dout1_69) AT=820.025n

.meas tran vdout1_70ck1630 FIND v(dout1_70) AT=820.025n

.meas tran vdout1_71ck1630 FIND v(dout1_71) AT=820.025n

.meas tran vdout1_72ck1630 FIND v(dout1_72) AT=820.025n

.meas tran vdout1_73ck1630 FIND v(dout1_73) AT=820.025n

.meas tran vdout1_74ck1630 FIND v(dout1_74) AT=820.025n

.meas tran vdout1_75ck1630 FIND v(dout1_75) AT=820.025n

.meas tran vdout1_76ck1630 FIND v(dout1_76) AT=820.025n

.meas tran vdout1_77ck1630 FIND v(dout1_77) AT=820.025n

.meas tran vdout1_78ck1630 FIND v(dout1_78) AT=820.025n

.meas tran vdout1_79ck1630 FIND v(dout1_79) AT=820.025n

.meas tran vdout1_80ck1630 FIND v(dout1_80) AT=820.025n

.meas tran vdout1_81ck1630 FIND v(dout1_81) AT=820.025n

.meas tran vdout1_82ck1630 FIND v(dout1_82) AT=820.025n

.meas tran vdout1_83ck1630 FIND v(dout1_83) AT=820.025n

.meas tran vdout1_84ck1630 FIND v(dout1_84) AT=820.025n

.meas tran vdout1_85ck1630 FIND v(dout1_85) AT=820.025n

.meas tran vdout1_86ck1630 FIND v(dout1_86) AT=820.025n

.meas tran vdout1_87ck1630 FIND v(dout1_87) AT=820.025n

.meas tran vdout1_88ck1630 FIND v(dout1_88) AT=820.025n

.meas tran vdout1_89ck1630 FIND v(dout1_89) AT=820.025n

.meas tran vdout1_90ck1630 FIND v(dout1_90) AT=820.025n

.meas tran vdout1_91ck1630 FIND v(dout1_91) AT=820.025n

.meas tran vdout1_92ck1630 FIND v(dout1_92) AT=820.025n

.meas tran vdout1_93ck1630 FIND v(dout1_93) AT=820.025n

.meas tran vdout1_94ck1630 FIND v(dout1_94) AT=820.025n

.meas tran vdout1_95ck1630 FIND v(dout1_95) AT=820.025n

.meas tran vdout1_96ck1630 FIND v(dout1_96) AT=820.025n

.meas tran vdout1_97ck1630 FIND v(dout1_97) AT=820.025n

.meas tran vdout1_98ck1630 FIND v(dout1_98) AT=820.025n

.meas tran vdout1_99ck1630 FIND v(dout1_99) AT=820.025n

.meas tran vdout1_100ck1630 FIND v(dout1_100) AT=820.025n

.meas tran vdout1_101ck1630 FIND v(dout1_101) AT=820.025n

.meas tran vdout1_102ck1630 FIND v(dout1_102) AT=820.025n

.meas tran vdout1_103ck1630 FIND v(dout1_103) AT=820.025n

.meas tran vdout1_104ck1630 FIND v(dout1_104) AT=820.025n

.meas tran vdout1_105ck1630 FIND v(dout1_105) AT=820.025n

.meas tran vdout1_106ck1630 FIND v(dout1_106) AT=820.025n

.meas tran vdout1_107ck1630 FIND v(dout1_107) AT=820.025n

.meas tran vdout1_108ck1630 FIND v(dout1_108) AT=820.025n

.meas tran vdout1_109ck1630 FIND v(dout1_109) AT=820.025n

.meas tran vdout1_110ck1630 FIND v(dout1_110) AT=820.025n

.meas tran vdout1_111ck1630 FIND v(dout1_111) AT=820.025n

.meas tran vdout1_112ck1630 FIND v(dout1_112) AT=820.025n

.meas tran vdout1_113ck1630 FIND v(dout1_113) AT=820.025n

.meas tran vdout1_114ck1630 FIND v(dout1_114) AT=820.025n

.meas tran vdout1_115ck1630 FIND v(dout1_115) AT=820.025n

.meas tran vdout1_116ck1630 FIND v(dout1_116) AT=820.025n

.meas tran vdout1_117ck1630 FIND v(dout1_117) AT=820.025n

.meas tran vdout1_118ck1630 FIND v(dout1_118) AT=820.025n

.meas tran vdout1_119ck1630 FIND v(dout1_119) AT=820.025n

.meas tran vdout1_120ck1630 FIND v(dout1_120) AT=820.025n

.meas tran vdout1_121ck1630 FIND v(dout1_121) AT=820.025n

.meas tran vdout1_122ck1630 FIND v(dout1_122) AT=820.025n

.meas tran vdout1_123ck1630 FIND v(dout1_123) AT=820.025n

.meas tran vdout1_124ck1630 FIND v(dout1_124) AT=820.025n

.meas tran vdout1_125ck1630 FIND v(dout1_125) AT=820.025n

.meas tran vdout1_126ck1630 FIND v(dout1_126) AT=820.025n

.meas tran vdout1_127ck1630 FIND v(dout1_127) AT=820.025n

.meas tran vdout1_0ck1650 FIND v(dout1_0) AT=830.025n

.meas tran vdout1_1ck1650 FIND v(dout1_1) AT=830.025n

.meas tran vdout1_2ck1650 FIND v(dout1_2) AT=830.025n

.meas tran vdout1_3ck1650 FIND v(dout1_3) AT=830.025n

.meas tran vdout1_4ck1650 FIND v(dout1_4) AT=830.025n

.meas tran vdout1_5ck1650 FIND v(dout1_5) AT=830.025n

.meas tran vdout1_6ck1650 FIND v(dout1_6) AT=830.025n

.meas tran vdout1_7ck1650 FIND v(dout1_7) AT=830.025n

.meas tran vdout1_8ck1650 FIND v(dout1_8) AT=830.025n

.meas tran vdout1_9ck1650 FIND v(dout1_9) AT=830.025n

.meas tran vdout1_10ck1650 FIND v(dout1_10) AT=830.025n

.meas tran vdout1_11ck1650 FIND v(dout1_11) AT=830.025n

.meas tran vdout1_12ck1650 FIND v(dout1_12) AT=830.025n

.meas tran vdout1_13ck1650 FIND v(dout1_13) AT=830.025n

.meas tran vdout1_14ck1650 FIND v(dout1_14) AT=830.025n

.meas tran vdout1_15ck1650 FIND v(dout1_15) AT=830.025n

.meas tran vdout1_16ck1650 FIND v(dout1_16) AT=830.025n

.meas tran vdout1_17ck1650 FIND v(dout1_17) AT=830.025n

.meas tran vdout1_18ck1650 FIND v(dout1_18) AT=830.025n

.meas tran vdout1_19ck1650 FIND v(dout1_19) AT=830.025n

.meas tran vdout1_20ck1650 FIND v(dout1_20) AT=830.025n

.meas tran vdout1_21ck1650 FIND v(dout1_21) AT=830.025n

.meas tran vdout1_22ck1650 FIND v(dout1_22) AT=830.025n

.meas tran vdout1_23ck1650 FIND v(dout1_23) AT=830.025n

.meas tran vdout1_24ck1650 FIND v(dout1_24) AT=830.025n

.meas tran vdout1_25ck1650 FIND v(dout1_25) AT=830.025n

.meas tran vdout1_26ck1650 FIND v(dout1_26) AT=830.025n

.meas tran vdout1_27ck1650 FIND v(dout1_27) AT=830.025n

.meas tran vdout1_28ck1650 FIND v(dout1_28) AT=830.025n

.meas tran vdout1_29ck1650 FIND v(dout1_29) AT=830.025n

.meas tran vdout1_30ck1650 FIND v(dout1_30) AT=830.025n

.meas tran vdout1_31ck1650 FIND v(dout1_31) AT=830.025n

.meas tran vdout1_32ck1650 FIND v(dout1_32) AT=830.025n

.meas tran vdout1_33ck1650 FIND v(dout1_33) AT=830.025n

.meas tran vdout1_34ck1650 FIND v(dout1_34) AT=830.025n

.meas tran vdout1_35ck1650 FIND v(dout1_35) AT=830.025n

.meas tran vdout1_36ck1650 FIND v(dout1_36) AT=830.025n

.meas tran vdout1_37ck1650 FIND v(dout1_37) AT=830.025n

.meas tran vdout1_38ck1650 FIND v(dout1_38) AT=830.025n

.meas tran vdout1_39ck1650 FIND v(dout1_39) AT=830.025n

.meas tran vdout1_40ck1650 FIND v(dout1_40) AT=830.025n

.meas tran vdout1_41ck1650 FIND v(dout1_41) AT=830.025n

.meas tran vdout1_42ck1650 FIND v(dout1_42) AT=830.025n

.meas tran vdout1_43ck1650 FIND v(dout1_43) AT=830.025n

.meas tran vdout1_44ck1650 FIND v(dout1_44) AT=830.025n

.meas tran vdout1_45ck1650 FIND v(dout1_45) AT=830.025n

.meas tran vdout1_46ck1650 FIND v(dout1_46) AT=830.025n

.meas tran vdout1_47ck1650 FIND v(dout1_47) AT=830.025n

.meas tran vdout1_48ck1650 FIND v(dout1_48) AT=830.025n

.meas tran vdout1_49ck1650 FIND v(dout1_49) AT=830.025n

.meas tran vdout1_50ck1650 FIND v(dout1_50) AT=830.025n

.meas tran vdout1_51ck1650 FIND v(dout1_51) AT=830.025n

.meas tran vdout1_52ck1650 FIND v(dout1_52) AT=830.025n

.meas tran vdout1_53ck1650 FIND v(dout1_53) AT=830.025n

.meas tran vdout1_54ck1650 FIND v(dout1_54) AT=830.025n

.meas tran vdout1_55ck1650 FIND v(dout1_55) AT=830.025n

.meas tran vdout1_56ck1650 FIND v(dout1_56) AT=830.025n

.meas tran vdout1_57ck1650 FIND v(dout1_57) AT=830.025n

.meas tran vdout1_58ck1650 FIND v(dout1_58) AT=830.025n

.meas tran vdout1_59ck1650 FIND v(dout1_59) AT=830.025n

.meas tran vdout1_60ck1650 FIND v(dout1_60) AT=830.025n

.meas tran vdout1_61ck1650 FIND v(dout1_61) AT=830.025n

.meas tran vdout1_62ck1650 FIND v(dout1_62) AT=830.025n

.meas tran vdout1_63ck1650 FIND v(dout1_63) AT=830.025n

.meas tran vdout1_64ck1650 FIND v(dout1_64) AT=830.025n

.meas tran vdout1_65ck1650 FIND v(dout1_65) AT=830.025n

.meas tran vdout1_66ck1650 FIND v(dout1_66) AT=830.025n

.meas tran vdout1_67ck1650 FIND v(dout1_67) AT=830.025n

.meas tran vdout1_68ck1650 FIND v(dout1_68) AT=830.025n

.meas tran vdout1_69ck1650 FIND v(dout1_69) AT=830.025n

.meas tran vdout1_70ck1650 FIND v(dout1_70) AT=830.025n

.meas tran vdout1_71ck1650 FIND v(dout1_71) AT=830.025n

.meas tran vdout1_72ck1650 FIND v(dout1_72) AT=830.025n

.meas tran vdout1_73ck1650 FIND v(dout1_73) AT=830.025n

.meas tran vdout1_74ck1650 FIND v(dout1_74) AT=830.025n

.meas tran vdout1_75ck1650 FIND v(dout1_75) AT=830.025n

.meas tran vdout1_76ck1650 FIND v(dout1_76) AT=830.025n

.meas tran vdout1_77ck1650 FIND v(dout1_77) AT=830.025n

.meas tran vdout1_78ck1650 FIND v(dout1_78) AT=830.025n

.meas tran vdout1_79ck1650 FIND v(dout1_79) AT=830.025n

.meas tran vdout1_80ck1650 FIND v(dout1_80) AT=830.025n

.meas tran vdout1_81ck1650 FIND v(dout1_81) AT=830.025n

.meas tran vdout1_82ck1650 FIND v(dout1_82) AT=830.025n

.meas tran vdout1_83ck1650 FIND v(dout1_83) AT=830.025n

.meas tran vdout1_84ck1650 FIND v(dout1_84) AT=830.025n

.meas tran vdout1_85ck1650 FIND v(dout1_85) AT=830.025n

.meas tran vdout1_86ck1650 FIND v(dout1_86) AT=830.025n

.meas tran vdout1_87ck1650 FIND v(dout1_87) AT=830.025n

.meas tran vdout1_88ck1650 FIND v(dout1_88) AT=830.025n

.meas tran vdout1_89ck1650 FIND v(dout1_89) AT=830.025n

.meas tran vdout1_90ck1650 FIND v(dout1_90) AT=830.025n

.meas tran vdout1_91ck1650 FIND v(dout1_91) AT=830.025n

.meas tran vdout1_92ck1650 FIND v(dout1_92) AT=830.025n

.meas tran vdout1_93ck1650 FIND v(dout1_93) AT=830.025n

.meas tran vdout1_94ck1650 FIND v(dout1_94) AT=830.025n

.meas tran vdout1_95ck1650 FIND v(dout1_95) AT=830.025n

.meas tran vdout1_96ck1650 FIND v(dout1_96) AT=830.025n

.meas tran vdout1_97ck1650 FIND v(dout1_97) AT=830.025n

.meas tran vdout1_98ck1650 FIND v(dout1_98) AT=830.025n

.meas tran vdout1_99ck1650 FIND v(dout1_99) AT=830.025n

.meas tran vdout1_100ck1650 FIND v(dout1_100) AT=830.025n

.meas tran vdout1_101ck1650 FIND v(dout1_101) AT=830.025n

.meas tran vdout1_102ck1650 FIND v(dout1_102) AT=830.025n

.meas tran vdout1_103ck1650 FIND v(dout1_103) AT=830.025n

.meas tran vdout1_104ck1650 FIND v(dout1_104) AT=830.025n

.meas tran vdout1_105ck1650 FIND v(dout1_105) AT=830.025n

.meas tran vdout1_106ck1650 FIND v(dout1_106) AT=830.025n

.meas tran vdout1_107ck1650 FIND v(dout1_107) AT=830.025n

.meas tran vdout1_108ck1650 FIND v(dout1_108) AT=830.025n

.meas tran vdout1_109ck1650 FIND v(dout1_109) AT=830.025n

.meas tran vdout1_110ck1650 FIND v(dout1_110) AT=830.025n

.meas tran vdout1_111ck1650 FIND v(dout1_111) AT=830.025n

.meas tran vdout1_112ck1650 FIND v(dout1_112) AT=830.025n

.meas tran vdout1_113ck1650 FIND v(dout1_113) AT=830.025n

.meas tran vdout1_114ck1650 FIND v(dout1_114) AT=830.025n

.meas tran vdout1_115ck1650 FIND v(dout1_115) AT=830.025n

.meas tran vdout1_116ck1650 FIND v(dout1_116) AT=830.025n

.meas tran vdout1_117ck1650 FIND v(dout1_117) AT=830.025n

.meas tran vdout1_118ck1650 FIND v(dout1_118) AT=830.025n

.meas tran vdout1_119ck1650 FIND v(dout1_119) AT=830.025n

.meas tran vdout1_120ck1650 FIND v(dout1_120) AT=830.025n

.meas tran vdout1_121ck1650 FIND v(dout1_121) AT=830.025n

.meas tran vdout1_122ck1650 FIND v(dout1_122) AT=830.025n

.meas tran vdout1_123ck1650 FIND v(dout1_123) AT=830.025n

.meas tran vdout1_124ck1650 FIND v(dout1_124) AT=830.025n

.meas tran vdout1_125ck1650 FIND v(dout1_125) AT=830.025n

.meas tran vdout1_126ck1650 FIND v(dout1_126) AT=830.025n

.meas tran vdout1_127ck1650 FIND v(dout1_127) AT=830.025n

.meas tran vdout1_0ck1660 FIND v(dout1_0) AT=835.025n

.meas tran vdout1_1ck1660 FIND v(dout1_1) AT=835.025n

.meas tran vdout1_2ck1660 FIND v(dout1_2) AT=835.025n

.meas tran vdout1_3ck1660 FIND v(dout1_3) AT=835.025n

.meas tran vdout1_4ck1660 FIND v(dout1_4) AT=835.025n

.meas tran vdout1_5ck1660 FIND v(dout1_5) AT=835.025n

.meas tran vdout1_6ck1660 FIND v(dout1_6) AT=835.025n

.meas tran vdout1_7ck1660 FIND v(dout1_7) AT=835.025n

.meas tran vdout1_8ck1660 FIND v(dout1_8) AT=835.025n

.meas tran vdout1_9ck1660 FIND v(dout1_9) AT=835.025n

.meas tran vdout1_10ck1660 FIND v(dout1_10) AT=835.025n

.meas tran vdout1_11ck1660 FIND v(dout1_11) AT=835.025n

.meas tran vdout1_12ck1660 FIND v(dout1_12) AT=835.025n

.meas tran vdout1_13ck1660 FIND v(dout1_13) AT=835.025n

.meas tran vdout1_14ck1660 FIND v(dout1_14) AT=835.025n

.meas tran vdout1_15ck1660 FIND v(dout1_15) AT=835.025n

.meas tran vdout1_16ck1660 FIND v(dout1_16) AT=835.025n

.meas tran vdout1_17ck1660 FIND v(dout1_17) AT=835.025n

.meas tran vdout1_18ck1660 FIND v(dout1_18) AT=835.025n

.meas tran vdout1_19ck1660 FIND v(dout1_19) AT=835.025n

.meas tran vdout1_20ck1660 FIND v(dout1_20) AT=835.025n

.meas tran vdout1_21ck1660 FIND v(dout1_21) AT=835.025n

.meas tran vdout1_22ck1660 FIND v(dout1_22) AT=835.025n

.meas tran vdout1_23ck1660 FIND v(dout1_23) AT=835.025n

.meas tran vdout1_24ck1660 FIND v(dout1_24) AT=835.025n

.meas tran vdout1_25ck1660 FIND v(dout1_25) AT=835.025n

.meas tran vdout1_26ck1660 FIND v(dout1_26) AT=835.025n

.meas tran vdout1_27ck1660 FIND v(dout1_27) AT=835.025n

.meas tran vdout1_28ck1660 FIND v(dout1_28) AT=835.025n

.meas tran vdout1_29ck1660 FIND v(dout1_29) AT=835.025n

.meas tran vdout1_30ck1660 FIND v(dout1_30) AT=835.025n

.meas tran vdout1_31ck1660 FIND v(dout1_31) AT=835.025n

.meas tran vdout1_32ck1660 FIND v(dout1_32) AT=835.025n

.meas tran vdout1_33ck1660 FIND v(dout1_33) AT=835.025n

.meas tran vdout1_34ck1660 FIND v(dout1_34) AT=835.025n

.meas tran vdout1_35ck1660 FIND v(dout1_35) AT=835.025n

.meas tran vdout1_36ck1660 FIND v(dout1_36) AT=835.025n

.meas tran vdout1_37ck1660 FIND v(dout1_37) AT=835.025n

.meas tran vdout1_38ck1660 FIND v(dout1_38) AT=835.025n

.meas tran vdout1_39ck1660 FIND v(dout1_39) AT=835.025n

.meas tran vdout1_40ck1660 FIND v(dout1_40) AT=835.025n

.meas tran vdout1_41ck1660 FIND v(dout1_41) AT=835.025n

.meas tran vdout1_42ck1660 FIND v(dout1_42) AT=835.025n

.meas tran vdout1_43ck1660 FIND v(dout1_43) AT=835.025n

.meas tran vdout1_44ck1660 FIND v(dout1_44) AT=835.025n

.meas tran vdout1_45ck1660 FIND v(dout1_45) AT=835.025n

.meas tran vdout1_46ck1660 FIND v(dout1_46) AT=835.025n

.meas tran vdout1_47ck1660 FIND v(dout1_47) AT=835.025n

.meas tran vdout1_48ck1660 FIND v(dout1_48) AT=835.025n

.meas tran vdout1_49ck1660 FIND v(dout1_49) AT=835.025n

.meas tran vdout1_50ck1660 FIND v(dout1_50) AT=835.025n

.meas tran vdout1_51ck1660 FIND v(dout1_51) AT=835.025n

.meas tran vdout1_52ck1660 FIND v(dout1_52) AT=835.025n

.meas tran vdout1_53ck1660 FIND v(dout1_53) AT=835.025n

.meas tran vdout1_54ck1660 FIND v(dout1_54) AT=835.025n

.meas tran vdout1_55ck1660 FIND v(dout1_55) AT=835.025n

.meas tran vdout1_56ck1660 FIND v(dout1_56) AT=835.025n

.meas tran vdout1_57ck1660 FIND v(dout1_57) AT=835.025n

.meas tran vdout1_58ck1660 FIND v(dout1_58) AT=835.025n

.meas tran vdout1_59ck1660 FIND v(dout1_59) AT=835.025n

.meas tran vdout1_60ck1660 FIND v(dout1_60) AT=835.025n

.meas tran vdout1_61ck1660 FIND v(dout1_61) AT=835.025n

.meas tran vdout1_62ck1660 FIND v(dout1_62) AT=835.025n

.meas tran vdout1_63ck1660 FIND v(dout1_63) AT=835.025n

.meas tran vdout1_64ck1660 FIND v(dout1_64) AT=835.025n

.meas tran vdout1_65ck1660 FIND v(dout1_65) AT=835.025n

.meas tran vdout1_66ck1660 FIND v(dout1_66) AT=835.025n

.meas tran vdout1_67ck1660 FIND v(dout1_67) AT=835.025n

.meas tran vdout1_68ck1660 FIND v(dout1_68) AT=835.025n

.meas tran vdout1_69ck1660 FIND v(dout1_69) AT=835.025n

.meas tran vdout1_70ck1660 FIND v(dout1_70) AT=835.025n

.meas tran vdout1_71ck1660 FIND v(dout1_71) AT=835.025n

.meas tran vdout1_72ck1660 FIND v(dout1_72) AT=835.025n

.meas tran vdout1_73ck1660 FIND v(dout1_73) AT=835.025n

.meas tran vdout1_74ck1660 FIND v(dout1_74) AT=835.025n

.meas tran vdout1_75ck1660 FIND v(dout1_75) AT=835.025n

.meas tran vdout1_76ck1660 FIND v(dout1_76) AT=835.025n

.meas tran vdout1_77ck1660 FIND v(dout1_77) AT=835.025n

.meas tran vdout1_78ck1660 FIND v(dout1_78) AT=835.025n

.meas tran vdout1_79ck1660 FIND v(dout1_79) AT=835.025n

.meas tran vdout1_80ck1660 FIND v(dout1_80) AT=835.025n

.meas tran vdout1_81ck1660 FIND v(dout1_81) AT=835.025n

.meas tran vdout1_82ck1660 FIND v(dout1_82) AT=835.025n

.meas tran vdout1_83ck1660 FIND v(dout1_83) AT=835.025n

.meas tran vdout1_84ck1660 FIND v(dout1_84) AT=835.025n

.meas tran vdout1_85ck1660 FIND v(dout1_85) AT=835.025n

.meas tran vdout1_86ck1660 FIND v(dout1_86) AT=835.025n

.meas tran vdout1_87ck1660 FIND v(dout1_87) AT=835.025n

.meas tran vdout1_88ck1660 FIND v(dout1_88) AT=835.025n

.meas tran vdout1_89ck1660 FIND v(dout1_89) AT=835.025n

.meas tran vdout1_90ck1660 FIND v(dout1_90) AT=835.025n

.meas tran vdout1_91ck1660 FIND v(dout1_91) AT=835.025n

.meas tran vdout1_92ck1660 FIND v(dout1_92) AT=835.025n

.meas tran vdout1_93ck1660 FIND v(dout1_93) AT=835.025n

.meas tran vdout1_94ck1660 FIND v(dout1_94) AT=835.025n

.meas tran vdout1_95ck1660 FIND v(dout1_95) AT=835.025n

.meas tran vdout1_96ck1660 FIND v(dout1_96) AT=835.025n

.meas tran vdout1_97ck1660 FIND v(dout1_97) AT=835.025n

.meas tran vdout1_98ck1660 FIND v(dout1_98) AT=835.025n

.meas tran vdout1_99ck1660 FIND v(dout1_99) AT=835.025n

.meas tran vdout1_100ck1660 FIND v(dout1_100) AT=835.025n

.meas tran vdout1_101ck1660 FIND v(dout1_101) AT=835.025n

.meas tran vdout1_102ck1660 FIND v(dout1_102) AT=835.025n

.meas tran vdout1_103ck1660 FIND v(dout1_103) AT=835.025n

.meas tran vdout1_104ck1660 FIND v(dout1_104) AT=835.025n

.meas tran vdout1_105ck1660 FIND v(dout1_105) AT=835.025n

.meas tran vdout1_106ck1660 FIND v(dout1_106) AT=835.025n

.meas tran vdout1_107ck1660 FIND v(dout1_107) AT=835.025n

.meas tran vdout1_108ck1660 FIND v(dout1_108) AT=835.025n

.meas tran vdout1_109ck1660 FIND v(dout1_109) AT=835.025n

.meas tran vdout1_110ck1660 FIND v(dout1_110) AT=835.025n

.meas tran vdout1_111ck1660 FIND v(dout1_111) AT=835.025n

.meas tran vdout1_112ck1660 FIND v(dout1_112) AT=835.025n

.meas tran vdout1_113ck1660 FIND v(dout1_113) AT=835.025n

.meas tran vdout1_114ck1660 FIND v(dout1_114) AT=835.025n

.meas tran vdout1_115ck1660 FIND v(dout1_115) AT=835.025n

.meas tran vdout1_116ck1660 FIND v(dout1_116) AT=835.025n

.meas tran vdout1_117ck1660 FIND v(dout1_117) AT=835.025n

.meas tran vdout1_118ck1660 FIND v(dout1_118) AT=835.025n

.meas tran vdout1_119ck1660 FIND v(dout1_119) AT=835.025n

.meas tran vdout1_120ck1660 FIND v(dout1_120) AT=835.025n

.meas tran vdout1_121ck1660 FIND v(dout1_121) AT=835.025n

.meas tran vdout1_122ck1660 FIND v(dout1_122) AT=835.025n

.meas tran vdout1_123ck1660 FIND v(dout1_123) AT=835.025n

.meas tran vdout1_124ck1660 FIND v(dout1_124) AT=835.025n

.meas tran vdout1_125ck1660 FIND v(dout1_125) AT=835.025n

.meas tran vdout1_126ck1660 FIND v(dout1_126) AT=835.025n

.meas tran vdout1_127ck1660 FIND v(dout1_127) AT=835.025n

.meas tran vdout1_0ck1690 FIND v(dout1_0) AT=850.025n

.meas tran vdout1_1ck1690 FIND v(dout1_1) AT=850.025n

.meas tran vdout1_2ck1690 FIND v(dout1_2) AT=850.025n

.meas tran vdout1_3ck1690 FIND v(dout1_3) AT=850.025n

.meas tran vdout1_4ck1690 FIND v(dout1_4) AT=850.025n

.meas tran vdout1_5ck1690 FIND v(dout1_5) AT=850.025n

.meas tran vdout1_6ck1690 FIND v(dout1_6) AT=850.025n

.meas tran vdout1_7ck1690 FIND v(dout1_7) AT=850.025n

.meas tran vdout1_8ck1690 FIND v(dout1_8) AT=850.025n

.meas tran vdout1_9ck1690 FIND v(dout1_9) AT=850.025n

.meas tran vdout1_10ck1690 FIND v(dout1_10) AT=850.025n

.meas tran vdout1_11ck1690 FIND v(dout1_11) AT=850.025n

.meas tran vdout1_12ck1690 FIND v(dout1_12) AT=850.025n

.meas tran vdout1_13ck1690 FIND v(dout1_13) AT=850.025n

.meas tran vdout1_14ck1690 FIND v(dout1_14) AT=850.025n

.meas tran vdout1_15ck1690 FIND v(dout1_15) AT=850.025n

.meas tran vdout1_16ck1690 FIND v(dout1_16) AT=850.025n

.meas tran vdout1_17ck1690 FIND v(dout1_17) AT=850.025n

.meas tran vdout1_18ck1690 FIND v(dout1_18) AT=850.025n

.meas tran vdout1_19ck1690 FIND v(dout1_19) AT=850.025n

.meas tran vdout1_20ck1690 FIND v(dout1_20) AT=850.025n

.meas tran vdout1_21ck1690 FIND v(dout1_21) AT=850.025n

.meas tran vdout1_22ck1690 FIND v(dout1_22) AT=850.025n

.meas tran vdout1_23ck1690 FIND v(dout1_23) AT=850.025n

.meas tran vdout1_24ck1690 FIND v(dout1_24) AT=850.025n

.meas tran vdout1_25ck1690 FIND v(dout1_25) AT=850.025n

.meas tran vdout1_26ck1690 FIND v(dout1_26) AT=850.025n

.meas tran vdout1_27ck1690 FIND v(dout1_27) AT=850.025n

.meas tran vdout1_28ck1690 FIND v(dout1_28) AT=850.025n

.meas tran vdout1_29ck1690 FIND v(dout1_29) AT=850.025n

.meas tran vdout1_30ck1690 FIND v(dout1_30) AT=850.025n

.meas tran vdout1_31ck1690 FIND v(dout1_31) AT=850.025n

.meas tran vdout1_32ck1690 FIND v(dout1_32) AT=850.025n

.meas tran vdout1_33ck1690 FIND v(dout1_33) AT=850.025n

.meas tran vdout1_34ck1690 FIND v(dout1_34) AT=850.025n

.meas tran vdout1_35ck1690 FIND v(dout1_35) AT=850.025n

.meas tran vdout1_36ck1690 FIND v(dout1_36) AT=850.025n

.meas tran vdout1_37ck1690 FIND v(dout1_37) AT=850.025n

.meas tran vdout1_38ck1690 FIND v(dout1_38) AT=850.025n

.meas tran vdout1_39ck1690 FIND v(dout1_39) AT=850.025n

.meas tran vdout1_40ck1690 FIND v(dout1_40) AT=850.025n

.meas tran vdout1_41ck1690 FIND v(dout1_41) AT=850.025n

.meas tran vdout1_42ck1690 FIND v(dout1_42) AT=850.025n

.meas tran vdout1_43ck1690 FIND v(dout1_43) AT=850.025n

.meas tran vdout1_44ck1690 FIND v(dout1_44) AT=850.025n

.meas tran vdout1_45ck1690 FIND v(dout1_45) AT=850.025n

.meas tran vdout1_46ck1690 FIND v(dout1_46) AT=850.025n

.meas tran vdout1_47ck1690 FIND v(dout1_47) AT=850.025n

.meas tran vdout1_48ck1690 FIND v(dout1_48) AT=850.025n

.meas tran vdout1_49ck1690 FIND v(dout1_49) AT=850.025n

.meas tran vdout1_50ck1690 FIND v(dout1_50) AT=850.025n

.meas tran vdout1_51ck1690 FIND v(dout1_51) AT=850.025n

.meas tran vdout1_52ck1690 FIND v(dout1_52) AT=850.025n

.meas tran vdout1_53ck1690 FIND v(dout1_53) AT=850.025n

.meas tran vdout1_54ck1690 FIND v(dout1_54) AT=850.025n

.meas tran vdout1_55ck1690 FIND v(dout1_55) AT=850.025n

.meas tran vdout1_56ck1690 FIND v(dout1_56) AT=850.025n

.meas tran vdout1_57ck1690 FIND v(dout1_57) AT=850.025n

.meas tran vdout1_58ck1690 FIND v(dout1_58) AT=850.025n

.meas tran vdout1_59ck1690 FIND v(dout1_59) AT=850.025n

.meas tran vdout1_60ck1690 FIND v(dout1_60) AT=850.025n

.meas tran vdout1_61ck1690 FIND v(dout1_61) AT=850.025n

.meas tran vdout1_62ck1690 FIND v(dout1_62) AT=850.025n

.meas tran vdout1_63ck1690 FIND v(dout1_63) AT=850.025n

.meas tran vdout1_64ck1690 FIND v(dout1_64) AT=850.025n

.meas tran vdout1_65ck1690 FIND v(dout1_65) AT=850.025n

.meas tran vdout1_66ck1690 FIND v(dout1_66) AT=850.025n

.meas tran vdout1_67ck1690 FIND v(dout1_67) AT=850.025n

.meas tran vdout1_68ck1690 FIND v(dout1_68) AT=850.025n

.meas tran vdout1_69ck1690 FIND v(dout1_69) AT=850.025n

.meas tran vdout1_70ck1690 FIND v(dout1_70) AT=850.025n

.meas tran vdout1_71ck1690 FIND v(dout1_71) AT=850.025n

.meas tran vdout1_72ck1690 FIND v(dout1_72) AT=850.025n

.meas tran vdout1_73ck1690 FIND v(dout1_73) AT=850.025n

.meas tran vdout1_74ck1690 FIND v(dout1_74) AT=850.025n

.meas tran vdout1_75ck1690 FIND v(dout1_75) AT=850.025n

.meas tran vdout1_76ck1690 FIND v(dout1_76) AT=850.025n

.meas tran vdout1_77ck1690 FIND v(dout1_77) AT=850.025n

.meas tran vdout1_78ck1690 FIND v(dout1_78) AT=850.025n

.meas tran vdout1_79ck1690 FIND v(dout1_79) AT=850.025n

.meas tran vdout1_80ck1690 FIND v(dout1_80) AT=850.025n

.meas tran vdout1_81ck1690 FIND v(dout1_81) AT=850.025n

.meas tran vdout1_82ck1690 FIND v(dout1_82) AT=850.025n

.meas tran vdout1_83ck1690 FIND v(dout1_83) AT=850.025n

.meas tran vdout1_84ck1690 FIND v(dout1_84) AT=850.025n

.meas tran vdout1_85ck1690 FIND v(dout1_85) AT=850.025n

.meas tran vdout1_86ck1690 FIND v(dout1_86) AT=850.025n

.meas tran vdout1_87ck1690 FIND v(dout1_87) AT=850.025n

.meas tran vdout1_88ck1690 FIND v(dout1_88) AT=850.025n

.meas tran vdout1_89ck1690 FIND v(dout1_89) AT=850.025n

.meas tran vdout1_90ck1690 FIND v(dout1_90) AT=850.025n

.meas tran vdout1_91ck1690 FIND v(dout1_91) AT=850.025n

.meas tran vdout1_92ck1690 FIND v(dout1_92) AT=850.025n

.meas tran vdout1_93ck1690 FIND v(dout1_93) AT=850.025n

.meas tran vdout1_94ck1690 FIND v(dout1_94) AT=850.025n

.meas tran vdout1_95ck1690 FIND v(dout1_95) AT=850.025n

.meas tran vdout1_96ck1690 FIND v(dout1_96) AT=850.025n

.meas tran vdout1_97ck1690 FIND v(dout1_97) AT=850.025n

.meas tran vdout1_98ck1690 FIND v(dout1_98) AT=850.025n

.meas tran vdout1_99ck1690 FIND v(dout1_99) AT=850.025n

.meas tran vdout1_100ck1690 FIND v(dout1_100) AT=850.025n

.meas tran vdout1_101ck1690 FIND v(dout1_101) AT=850.025n

.meas tran vdout1_102ck1690 FIND v(dout1_102) AT=850.025n

.meas tran vdout1_103ck1690 FIND v(dout1_103) AT=850.025n

.meas tran vdout1_104ck1690 FIND v(dout1_104) AT=850.025n

.meas tran vdout1_105ck1690 FIND v(dout1_105) AT=850.025n

.meas tran vdout1_106ck1690 FIND v(dout1_106) AT=850.025n

.meas tran vdout1_107ck1690 FIND v(dout1_107) AT=850.025n

.meas tran vdout1_108ck1690 FIND v(dout1_108) AT=850.025n

.meas tran vdout1_109ck1690 FIND v(dout1_109) AT=850.025n

.meas tran vdout1_110ck1690 FIND v(dout1_110) AT=850.025n

.meas tran vdout1_111ck1690 FIND v(dout1_111) AT=850.025n

.meas tran vdout1_112ck1690 FIND v(dout1_112) AT=850.025n

.meas tran vdout1_113ck1690 FIND v(dout1_113) AT=850.025n

.meas tran vdout1_114ck1690 FIND v(dout1_114) AT=850.025n

.meas tran vdout1_115ck1690 FIND v(dout1_115) AT=850.025n

.meas tran vdout1_116ck1690 FIND v(dout1_116) AT=850.025n

.meas tran vdout1_117ck1690 FIND v(dout1_117) AT=850.025n

.meas tran vdout1_118ck1690 FIND v(dout1_118) AT=850.025n

.meas tran vdout1_119ck1690 FIND v(dout1_119) AT=850.025n

.meas tran vdout1_120ck1690 FIND v(dout1_120) AT=850.025n

.meas tran vdout1_121ck1690 FIND v(dout1_121) AT=850.025n

.meas tran vdout1_122ck1690 FIND v(dout1_122) AT=850.025n

.meas tran vdout1_123ck1690 FIND v(dout1_123) AT=850.025n

.meas tran vdout1_124ck1690 FIND v(dout1_124) AT=850.025n

.meas tran vdout1_125ck1690 FIND v(dout1_125) AT=850.025n

.meas tran vdout1_126ck1690 FIND v(dout1_126) AT=850.025n

.meas tran vdout1_127ck1690 FIND v(dout1_127) AT=850.025n

.meas tran vdout1_0ck1730 FIND v(dout1_0) AT=870.025n

.meas tran vdout1_1ck1730 FIND v(dout1_1) AT=870.025n

.meas tran vdout1_2ck1730 FIND v(dout1_2) AT=870.025n

.meas tran vdout1_3ck1730 FIND v(dout1_3) AT=870.025n

.meas tran vdout1_4ck1730 FIND v(dout1_4) AT=870.025n

.meas tran vdout1_5ck1730 FIND v(dout1_5) AT=870.025n

.meas tran vdout1_6ck1730 FIND v(dout1_6) AT=870.025n

.meas tran vdout1_7ck1730 FIND v(dout1_7) AT=870.025n

.meas tran vdout1_8ck1730 FIND v(dout1_8) AT=870.025n

.meas tran vdout1_9ck1730 FIND v(dout1_9) AT=870.025n

.meas tran vdout1_10ck1730 FIND v(dout1_10) AT=870.025n

.meas tran vdout1_11ck1730 FIND v(dout1_11) AT=870.025n

.meas tran vdout1_12ck1730 FIND v(dout1_12) AT=870.025n

.meas tran vdout1_13ck1730 FIND v(dout1_13) AT=870.025n

.meas tran vdout1_14ck1730 FIND v(dout1_14) AT=870.025n

.meas tran vdout1_15ck1730 FIND v(dout1_15) AT=870.025n

.meas tran vdout1_16ck1730 FIND v(dout1_16) AT=870.025n

.meas tran vdout1_17ck1730 FIND v(dout1_17) AT=870.025n

.meas tran vdout1_18ck1730 FIND v(dout1_18) AT=870.025n

.meas tran vdout1_19ck1730 FIND v(dout1_19) AT=870.025n

.meas tran vdout1_20ck1730 FIND v(dout1_20) AT=870.025n

.meas tran vdout1_21ck1730 FIND v(dout1_21) AT=870.025n

.meas tran vdout1_22ck1730 FIND v(dout1_22) AT=870.025n

.meas tran vdout1_23ck1730 FIND v(dout1_23) AT=870.025n

.meas tran vdout1_24ck1730 FIND v(dout1_24) AT=870.025n

.meas tran vdout1_25ck1730 FIND v(dout1_25) AT=870.025n

.meas tran vdout1_26ck1730 FIND v(dout1_26) AT=870.025n

.meas tran vdout1_27ck1730 FIND v(dout1_27) AT=870.025n

.meas tran vdout1_28ck1730 FIND v(dout1_28) AT=870.025n

.meas tran vdout1_29ck1730 FIND v(dout1_29) AT=870.025n

.meas tran vdout1_30ck1730 FIND v(dout1_30) AT=870.025n

.meas tran vdout1_31ck1730 FIND v(dout1_31) AT=870.025n

.meas tran vdout1_32ck1730 FIND v(dout1_32) AT=870.025n

.meas tran vdout1_33ck1730 FIND v(dout1_33) AT=870.025n

.meas tran vdout1_34ck1730 FIND v(dout1_34) AT=870.025n

.meas tran vdout1_35ck1730 FIND v(dout1_35) AT=870.025n

.meas tran vdout1_36ck1730 FIND v(dout1_36) AT=870.025n

.meas tran vdout1_37ck1730 FIND v(dout1_37) AT=870.025n

.meas tran vdout1_38ck1730 FIND v(dout1_38) AT=870.025n

.meas tran vdout1_39ck1730 FIND v(dout1_39) AT=870.025n

.meas tran vdout1_40ck1730 FIND v(dout1_40) AT=870.025n

.meas tran vdout1_41ck1730 FIND v(dout1_41) AT=870.025n

.meas tran vdout1_42ck1730 FIND v(dout1_42) AT=870.025n

.meas tran vdout1_43ck1730 FIND v(dout1_43) AT=870.025n

.meas tran vdout1_44ck1730 FIND v(dout1_44) AT=870.025n

.meas tran vdout1_45ck1730 FIND v(dout1_45) AT=870.025n

.meas tran vdout1_46ck1730 FIND v(dout1_46) AT=870.025n

.meas tran vdout1_47ck1730 FIND v(dout1_47) AT=870.025n

.meas tran vdout1_48ck1730 FIND v(dout1_48) AT=870.025n

.meas tran vdout1_49ck1730 FIND v(dout1_49) AT=870.025n

.meas tran vdout1_50ck1730 FIND v(dout1_50) AT=870.025n

.meas tran vdout1_51ck1730 FIND v(dout1_51) AT=870.025n

.meas tran vdout1_52ck1730 FIND v(dout1_52) AT=870.025n

.meas tran vdout1_53ck1730 FIND v(dout1_53) AT=870.025n

.meas tran vdout1_54ck1730 FIND v(dout1_54) AT=870.025n

.meas tran vdout1_55ck1730 FIND v(dout1_55) AT=870.025n

.meas tran vdout1_56ck1730 FIND v(dout1_56) AT=870.025n

.meas tran vdout1_57ck1730 FIND v(dout1_57) AT=870.025n

.meas tran vdout1_58ck1730 FIND v(dout1_58) AT=870.025n

.meas tran vdout1_59ck1730 FIND v(dout1_59) AT=870.025n

.meas tran vdout1_60ck1730 FIND v(dout1_60) AT=870.025n

.meas tran vdout1_61ck1730 FIND v(dout1_61) AT=870.025n

.meas tran vdout1_62ck1730 FIND v(dout1_62) AT=870.025n

.meas tran vdout1_63ck1730 FIND v(dout1_63) AT=870.025n

.meas tran vdout1_64ck1730 FIND v(dout1_64) AT=870.025n

.meas tran vdout1_65ck1730 FIND v(dout1_65) AT=870.025n

.meas tran vdout1_66ck1730 FIND v(dout1_66) AT=870.025n

.meas tran vdout1_67ck1730 FIND v(dout1_67) AT=870.025n

.meas tran vdout1_68ck1730 FIND v(dout1_68) AT=870.025n

.meas tran vdout1_69ck1730 FIND v(dout1_69) AT=870.025n

.meas tran vdout1_70ck1730 FIND v(dout1_70) AT=870.025n

.meas tran vdout1_71ck1730 FIND v(dout1_71) AT=870.025n

.meas tran vdout1_72ck1730 FIND v(dout1_72) AT=870.025n

.meas tran vdout1_73ck1730 FIND v(dout1_73) AT=870.025n

.meas tran vdout1_74ck1730 FIND v(dout1_74) AT=870.025n

.meas tran vdout1_75ck1730 FIND v(dout1_75) AT=870.025n

.meas tran vdout1_76ck1730 FIND v(dout1_76) AT=870.025n

.meas tran vdout1_77ck1730 FIND v(dout1_77) AT=870.025n

.meas tran vdout1_78ck1730 FIND v(dout1_78) AT=870.025n

.meas tran vdout1_79ck1730 FIND v(dout1_79) AT=870.025n

.meas tran vdout1_80ck1730 FIND v(dout1_80) AT=870.025n

.meas tran vdout1_81ck1730 FIND v(dout1_81) AT=870.025n

.meas tran vdout1_82ck1730 FIND v(dout1_82) AT=870.025n

.meas tran vdout1_83ck1730 FIND v(dout1_83) AT=870.025n

.meas tran vdout1_84ck1730 FIND v(dout1_84) AT=870.025n

.meas tran vdout1_85ck1730 FIND v(dout1_85) AT=870.025n

.meas tran vdout1_86ck1730 FIND v(dout1_86) AT=870.025n

.meas tran vdout1_87ck1730 FIND v(dout1_87) AT=870.025n

.meas tran vdout1_88ck1730 FIND v(dout1_88) AT=870.025n

.meas tran vdout1_89ck1730 FIND v(dout1_89) AT=870.025n

.meas tran vdout1_90ck1730 FIND v(dout1_90) AT=870.025n

.meas tran vdout1_91ck1730 FIND v(dout1_91) AT=870.025n

.meas tran vdout1_92ck1730 FIND v(dout1_92) AT=870.025n

.meas tran vdout1_93ck1730 FIND v(dout1_93) AT=870.025n

.meas tran vdout1_94ck1730 FIND v(dout1_94) AT=870.025n

.meas tran vdout1_95ck1730 FIND v(dout1_95) AT=870.025n

.meas tran vdout1_96ck1730 FIND v(dout1_96) AT=870.025n

.meas tran vdout1_97ck1730 FIND v(dout1_97) AT=870.025n

.meas tran vdout1_98ck1730 FIND v(dout1_98) AT=870.025n

.meas tran vdout1_99ck1730 FIND v(dout1_99) AT=870.025n

.meas tran vdout1_100ck1730 FIND v(dout1_100) AT=870.025n

.meas tran vdout1_101ck1730 FIND v(dout1_101) AT=870.025n

.meas tran vdout1_102ck1730 FIND v(dout1_102) AT=870.025n

.meas tran vdout1_103ck1730 FIND v(dout1_103) AT=870.025n

.meas tran vdout1_104ck1730 FIND v(dout1_104) AT=870.025n

.meas tran vdout1_105ck1730 FIND v(dout1_105) AT=870.025n

.meas tran vdout1_106ck1730 FIND v(dout1_106) AT=870.025n

.meas tran vdout1_107ck1730 FIND v(dout1_107) AT=870.025n

.meas tran vdout1_108ck1730 FIND v(dout1_108) AT=870.025n

.meas tran vdout1_109ck1730 FIND v(dout1_109) AT=870.025n

.meas tran vdout1_110ck1730 FIND v(dout1_110) AT=870.025n

.meas tran vdout1_111ck1730 FIND v(dout1_111) AT=870.025n

.meas tran vdout1_112ck1730 FIND v(dout1_112) AT=870.025n

.meas tran vdout1_113ck1730 FIND v(dout1_113) AT=870.025n

.meas tran vdout1_114ck1730 FIND v(dout1_114) AT=870.025n

.meas tran vdout1_115ck1730 FIND v(dout1_115) AT=870.025n

.meas tran vdout1_116ck1730 FIND v(dout1_116) AT=870.025n

.meas tran vdout1_117ck1730 FIND v(dout1_117) AT=870.025n

.meas tran vdout1_118ck1730 FIND v(dout1_118) AT=870.025n

.meas tran vdout1_119ck1730 FIND v(dout1_119) AT=870.025n

.meas tran vdout1_120ck1730 FIND v(dout1_120) AT=870.025n

.meas tran vdout1_121ck1730 FIND v(dout1_121) AT=870.025n

.meas tran vdout1_122ck1730 FIND v(dout1_122) AT=870.025n

.meas tran vdout1_123ck1730 FIND v(dout1_123) AT=870.025n

.meas tran vdout1_124ck1730 FIND v(dout1_124) AT=870.025n

.meas tran vdout1_125ck1730 FIND v(dout1_125) AT=870.025n

.meas tran vdout1_126ck1730 FIND v(dout1_126) AT=870.025n

.meas tran vdout1_127ck1730 FIND v(dout1_127) AT=870.025n

.meas tran vdout1_0ck1750 FIND v(dout1_0) AT=880.025n

.meas tran vdout1_1ck1750 FIND v(dout1_1) AT=880.025n

.meas tran vdout1_2ck1750 FIND v(dout1_2) AT=880.025n

.meas tran vdout1_3ck1750 FIND v(dout1_3) AT=880.025n

.meas tran vdout1_4ck1750 FIND v(dout1_4) AT=880.025n

.meas tran vdout1_5ck1750 FIND v(dout1_5) AT=880.025n

.meas tran vdout1_6ck1750 FIND v(dout1_6) AT=880.025n

.meas tran vdout1_7ck1750 FIND v(dout1_7) AT=880.025n

.meas tran vdout1_8ck1750 FIND v(dout1_8) AT=880.025n

.meas tran vdout1_9ck1750 FIND v(dout1_9) AT=880.025n

.meas tran vdout1_10ck1750 FIND v(dout1_10) AT=880.025n

.meas tran vdout1_11ck1750 FIND v(dout1_11) AT=880.025n

.meas tran vdout1_12ck1750 FIND v(dout1_12) AT=880.025n

.meas tran vdout1_13ck1750 FIND v(dout1_13) AT=880.025n

.meas tran vdout1_14ck1750 FIND v(dout1_14) AT=880.025n

.meas tran vdout1_15ck1750 FIND v(dout1_15) AT=880.025n

.meas tran vdout1_16ck1750 FIND v(dout1_16) AT=880.025n

.meas tran vdout1_17ck1750 FIND v(dout1_17) AT=880.025n

.meas tran vdout1_18ck1750 FIND v(dout1_18) AT=880.025n

.meas tran vdout1_19ck1750 FIND v(dout1_19) AT=880.025n

.meas tran vdout1_20ck1750 FIND v(dout1_20) AT=880.025n

.meas tran vdout1_21ck1750 FIND v(dout1_21) AT=880.025n

.meas tran vdout1_22ck1750 FIND v(dout1_22) AT=880.025n

.meas tran vdout1_23ck1750 FIND v(dout1_23) AT=880.025n

.meas tran vdout1_24ck1750 FIND v(dout1_24) AT=880.025n

.meas tran vdout1_25ck1750 FIND v(dout1_25) AT=880.025n

.meas tran vdout1_26ck1750 FIND v(dout1_26) AT=880.025n

.meas tran vdout1_27ck1750 FIND v(dout1_27) AT=880.025n

.meas tran vdout1_28ck1750 FIND v(dout1_28) AT=880.025n

.meas tran vdout1_29ck1750 FIND v(dout1_29) AT=880.025n

.meas tran vdout1_30ck1750 FIND v(dout1_30) AT=880.025n

.meas tran vdout1_31ck1750 FIND v(dout1_31) AT=880.025n

.meas tran vdout1_32ck1750 FIND v(dout1_32) AT=880.025n

.meas tran vdout1_33ck1750 FIND v(dout1_33) AT=880.025n

.meas tran vdout1_34ck1750 FIND v(dout1_34) AT=880.025n

.meas tran vdout1_35ck1750 FIND v(dout1_35) AT=880.025n

.meas tran vdout1_36ck1750 FIND v(dout1_36) AT=880.025n

.meas tran vdout1_37ck1750 FIND v(dout1_37) AT=880.025n

.meas tran vdout1_38ck1750 FIND v(dout1_38) AT=880.025n

.meas tran vdout1_39ck1750 FIND v(dout1_39) AT=880.025n

.meas tran vdout1_40ck1750 FIND v(dout1_40) AT=880.025n

.meas tran vdout1_41ck1750 FIND v(dout1_41) AT=880.025n

.meas tran vdout1_42ck1750 FIND v(dout1_42) AT=880.025n

.meas tran vdout1_43ck1750 FIND v(dout1_43) AT=880.025n

.meas tran vdout1_44ck1750 FIND v(dout1_44) AT=880.025n

.meas tran vdout1_45ck1750 FIND v(dout1_45) AT=880.025n

.meas tran vdout1_46ck1750 FIND v(dout1_46) AT=880.025n

.meas tran vdout1_47ck1750 FIND v(dout1_47) AT=880.025n

.meas tran vdout1_48ck1750 FIND v(dout1_48) AT=880.025n

.meas tran vdout1_49ck1750 FIND v(dout1_49) AT=880.025n

.meas tran vdout1_50ck1750 FIND v(dout1_50) AT=880.025n

.meas tran vdout1_51ck1750 FIND v(dout1_51) AT=880.025n

.meas tran vdout1_52ck1750 FIND v(dout1_52) AT=880.025n

.meas tran vdout1_53ck1750 FIND v(dout1_53) AT=880.025n

.meas tran vdout1_54ck1750 FIND v(dout1_54) AT=880.025n

.meas tran vdout1_55ck1750 FIND v(dout1_55) AT=880.025n

.meas tran vdout1_56ck1750 FIND v(dout1_56) AT=880.025n

.meas tran vdout1_57ck1750 FIND v(dout1_57) AT=880.025n

.meas tran vdout1_58ck1750 FIND v(dout1_58) AT=880.025n

.meas tran vdout1_59ck1750 FIND v(dout1_59) AT=880.025n

.meas tran vdout1_60ck1750 FIND v(dout1_60) AT=880.025n

.meas tran vdout1_61ck1750 FIND v(dout1_61) AT=880.025n

.meas tran vdout1_62ck1750 FIND v(dout1_62) AT=880.025n

.meas tran vdout1_63ck1750 FIND v(dout1_63) AT=880.025n

.meas tran vdout1_64ck1750 FIND v(dout1_64) AT=880.025n

.meas tran vdout1_65ck1750 FIND v(dout1_65) AT=880.025n

.meas tran vdout1_66ck1750 FIND v(dout1_66) AT=880.025n

.meas tran vdout1_67ck1750 FIND v(dout1_67) AT=880.025n

.meas tran vdout1_68ck1750 FIND v(dout1_68) AT=880.025n

.meas tran vdout1_69ck1750 FIND v(dout1_69) AT=880.025n

.meas tran vdout1_70ck1750 FIND v(dout1_70) AT=880.025n

.meas tran vdout1_71ck1750 FIND v(dout1_71) AT=880.025n

.meas tran vdout1_72ck1750 FIND v(dout1_72) AT=880.025n

.meas tran vdout1_73ck1750 FIND v(dout1_73) AT=880.025n

.meas tran vdout1_74ck1750 FIND v(dout1_74) AT=880.025n

.meas tran vdout1_75ck1750 FIND v(dout1_75) AT=880.025n

.meas tran vdout1_76ck1750 FIND v(dout1_76) AT=880.025n

.meas tran vdout1_77ck1750 FIND v(dout1_77) AT=880.025n

.meas tran vdout1_78ck1750 FIND v(dout1_78) AT=880.025n

.meas tran vdout1_79ck1750 FIND v(dout1_79) AT=880.025n

.meas tran vdout1_80ck1750 FIND v(dout1_80) AT=880.025n

.meas tran vdout1_81ck1750 FIND v(dout1_81) AT=880.025n

.meas tran vdout1_82ck1750 FIND v(dout1_82) AT=880.025n

.meas tran vdout1_83ck1750 FIND v(dout1_83) AT=880.025n

.meas tran vdout1_84ck1750 FIND v(dout1_84) AT=880.025n

.meas tran vdout1_85ck1750 FIND v(dout1_85) AT=880.025n

.meas tran vdout1_86ck1750 FIND v(dout1_86) AT=880.025n

.meas tran vdout1_87ck1750 FIND v(dout1_87) AT=880.025n

.meas tran vdout1_88ck1750 FIND v(dout1_88) AT=880.025n

.meas tran vdout1_89ck1750 FIND v(dout1_89) AT=880.025n

.meas tran vdout1_90ck1750 FIND v(dout1_90) AT=880.025n

.meas tran vdout1_91ck1750 FIND v(dout1_91) AT=880.025n

.meas tran vdout1_92ck1750 FIND v(dout1_92) AT=880.025n

.meas tran vdout1_93ck1750 FIND v(dout1_93) AT=880.025n

.meas tran vdout1_94ck1750 FIND v(dout1_94) AT=880.025n

.meas tran vdout1_95ck1750 FIND v(dout1_95) AT=880.025n

.meas tran vdout1_96ck1750 FIND v(dout1_96) AT=880.025n

.meas tran vdout1_97ck1750 FIND v(dout1_97) AT=880.025n

.meas tran vdout1_98ck1750 FIND v(dout1_98) AT=880.025n

.meas tran vdout1_99ck1750 FIND v(dout1_99) AT=880.025n

.meas tran vdout1_100ck1750 FIND v(dout1_100) AT=880.025n

.meas tran vdout1_101ck1750 FIND v(dout1_101) AT=880.025n

.meas tran vdout1_102ck1750 FIND v(dout1_102) AT=880.025n

.meas tran vdout1_103ck1750 FIND v(dout1_103) AT=880.025n

.meas tran vdout1_104ck1750 FIND v(dout1_104) AT=880.025n

.meas tran vdout1_105ck1750 FIND v(dout1_105) AT=880.025n

.meas tran vdout1_106ck1750 FIND v(dout1_106) AT=880.025n

.meas tran vdout1_107ck1750 FIND v(dout1_107) AT=880.025n

.meas tran vdout1_108ck1750 FIND v(dout1_108) AT=880.025n

.meas tran vdout1_109ck1750 FIND v(dout1_109) AT=880.025n

.meas tran vdout1_110ck1750 FIND v(dout1_110) AT=880.025n

.meas tran vdout1_111ck1750 FIND v(dout1_111) AT=880.025n

.meas tran vdout1_112ck1750 FIND v(dout1_112) AT=880.025n

.meas tran vdout1_113ck1750 FIND v(dout1_113) AT=880.025n

.meas tran vdout1_114ck1750 FIND v(dout1_114) AT=880.025n

.meas tran vdout1_115ck1750 FIND v(dout1_115) AT=880.025n

.meas tran vdout1_116ck1750 FIND v(dout1_116) AT=880.025n

.meas tran vdout1_117ck1750 FIND v(dout1_117) AT=880.025n

.meas tran vdout1_118ck1750 FIND v(dout1_118) AT=880.025n

.meas tran vdout1_119ck1750 FIND v(dout1_119) AT=880.025n

.meas tran vdout1_120ck1750 FIND v(dout1_120) AT=880.025n

.meas tran vdout1_121ck1750 FIND v(dout1_121) AT=880.025n

.meas tran vdout1_122ck1750 FIND v(dout1_122) AT=880.025n

.meas tran vdout1_123ck1750 FIND v(dout1_123) AT=880.025n

.meas tran vdout1_124ck1750 FIND v(dout1_124) AT=880.025n

.meas tran vdout1_125ck1750 FIND v(dout1_125) AT=880.025n

.meas tran vdout1_126ck1750 FIND v(dout1_126) AT=880.025n

.meas tran vdout1_127ck1750 FIND v(dout1_127) AT=880.025n

.meas tran vdout1_0ck1770 FIND v(dout1_0) AT=890.025n

.meas tran vdout1_1ck1770 FIND v(dout1_1) AT=890.025n

.meas tran vdout1_2ck1770 FIND v(dout1_2) AT=890.025n

.meas tran vdout1_3ck1770 FIND v(dout1_3) AT=890.025n

.meas tran vdout1_4ck1770 FIND v(dout1_4) AT=890.025n

.meas tran vdout1_5ck1770 FIND v(dout1_5) AT=890.025n

.meas tran vdout1_6ck1770 FIND v(dout1_6) AT=890.025n

.meas tran vdout1_7ck1770 FIND v(dout1_7) AT=890.025n

.meas tran vdout1_8ck1770 FIND v(dout1_8) AT=890.025n

.meas tran vdout1_9ck1770 FIND v(dout1_9) AT=890.025n

.meas tran vdout1_10ck1770 FIND v(dout1_10) AT=890.025n

.meas tran vdout1_11ck1770 FIND v(dout1_11) AT=890.025n

.meas tran vdout1_12ck1770 FIND v(dout1_12) AT=890.025n

.meas tran vdout1_13ck1770 FIND v(dout1_13) AT=890.025n

.meas tran vdout1_14ck1770 FIND v(dout1_14) AT=890.025n

.meas tran vdout1_15ck1770 FIND v(dout1_15) AT=890.025n

.meas tran vdout1_16ck1770 FIND v(dout1_16) AT=890.025n

.meas tran vdout1_17ck1770 FIND v(dout1_17) AT=890.025n

.meas tran vdout1_18ck1770 FIND v(dout1_18) AT=890.025n

.meas tran vdout1_19ck1770 FIND v(dout1_19) AT=890.025n

.meas tran vdout1_20ck1770 FIND v(dout1_20) AT=890.025n

.meas tran vdout1_21ck1770 FIND v(dout1_21) AT=890.025n

.meas tran vdout1_22ck1770 FIND v(dout1_22) AT=890.025n

.meas tran vdout1_23ck1770 FIND v(dout1_23) AT=890.025n

.meas tran vdout1_24ck1770 FIND v(dout1_24) AT=890.025n

.meas tran vdout1_25ck1770 FIND v(dout1_25) AT=890.025n

.meas tran vdout1_26ck1770 FIND v(dout1_26) AT=890.025n

.meas tran vdout1_27ck1770 FIND v(dout1_27) AT=890.025n

.meas tran vdout1_28ck1770 FIND v(dout1_28) AT=890.025n

.meas tran vdout1_29ck1770 FIND v(dout1_29) AT=890.025n

.meas tran vdout1_30ck1770 FIND v(dout1_30) AT=890.025n

.meas tran vdout1_31ck1770 FIND v(dout1_31) AT=890.025n

.meas tran vdout1_32ck1770 FIND v(dout1_32) AT=890.025n

.meas tran vdout1_33ck1770 FIND v(dout1_33) AT=890.025n

.meas tran vdout1_34ck1770 FIND v(dout1_34) AT=890.025n

.meas tran vdout1_35ck1770 FIND v(dout1_35) AT=890.025n

.meas tran vdout1_36ck1770 FIND v(dout1_36) AT=890.025n

.meas tran vdout1_37ck1770 FIND v(dout1_37) AT=890.025n

.meas tran vdout1_38ck1770 FIND v(dout1_38) AT=890.025n

.meas tran vdout1_39ck1770 FIND v(dout1_39) AT=890.025n

.meas tran vdout1_40ck1770 FIND v(dout1_40) AT=890.025n

.meas tran vdout1_41ck1770 FIND v(dout1_41) AT=890.025n

.meas tran vdout1_42ck1770 FIND v(dout1_42) AT=890.025n

.meas tran vdout1_43ck1770 FIND v(dout1_43) AT=890.025n

.meas tran vdout1_44ck1770 FIND v(dout1_44) AT=890.025n

.meas tran vdout1_45ck1770 FIND v(dout1_45) AT=890.025n

.meas tran vdout1_46ck1770 FIND v(dout1_46) AT=890.025n

.meas tran vdout1_47ck1770 FIND v(dout1_47) AT=890.025n

.meas tran vdout1_48ck1770 FIND v(dout1_48) AT=890.025n

.meas tran vdout1_49ck1770 FIND v(dout1_49) AT=890.025n

.meas tran vdout1_50ck1770 FIND v(dout1_50) AT=890.025n

.meas tran vdout1_51ck1770 FIND v(dout1_51) AT=890.025n

.meas tran vdout1_52ck1770 FIND v(dout1_52) AT=890.025n

.meas tran vdout1_53ck1770 FIND v(dout1_53) AT=890.025n

.meas tran vdout1_54ck1770 FIND v(dout1_54) AT=890.025n

.meas tran vdout1_55ck1770 FIND v(dout1_55) AT=890.025n

.meas tran vdout1_56ck1770 FIND v(dout1_56) AT=890.025n

.meas tran vdout1_57ck1770 FIND v(dout1_57) AT=890.025n

.meas tran vdout1_58ck1770 FIND v(dout1_58) AT=890.025n

.meas tran vdout1_59ck1770 FIND v(dout1_59) AT=890.025n

.meas tran vdout1_60ck1770 FIND v(dout1_60) AT=890.025n

.meas tran vdout1_61ck1770 FIND v(dout1_61) AT=890.025n

.meas tran vdout1_62ck1770 FIND v(dout1_62) AT=890.025n

.meas tran vdout1_63ck1770 FIND v(dout1_63) AT=890.025n

.meas tran vdout1_64ck1770 FIND v(dout1_64) AT=890.025n

.meas tran vdout1_65ck1770 FIND v(dout1_65) AT=890.025n

.meas tran vdout1_66ck1770 FIND v(dout1_66) AT=890.025n

.meas tran vdout1_67ck1770 FIND v(dout1_67) AT=890.025n

.meas tran vdout1_68ck1770 FIND v(dout1_68) AT=890.025n

.meas tran vdout1_69ck1770 FIND v(dout1_69) AT=890.025n

.meas tran vdout1_70ck1770 FIND v(dout1_70) AT=890.025n

.meas tran vdout1_71ck1770 FIND v(dout1_71) AT=890.025n

.meas tran vdout1_72ck1770 FIND v(dout1_72) AT=890.025n

.meas tran vdout1_73ck1770 FIND v(dout1_73) AT=890.025n

.meas tran vdout1_74ck1770 FIND v(dout1_74) AT=890.025n

.meas tran vdout1_75ck1770 FIND v(dout1_75) AT=890.025n

.meas tran vdout1_76ck1770 FIND v(dout1_76) AT=890.025n

.meas tran vdout1_77ck1770 FIND v(dout1_77) AT=890.025n

.meas tran vdout1_78ck1770 FIND v(dout1_78) AT=890.025n

.meas tran vdout1_79ck1770 FIND v(dout1_79) AT=890.025n

.meas tran vdout1_80ck1770 FIND v(dout1_80) AT=890.025n

.meas tran vdout1_81ck1770 FIND v(dout1_81) AT=890.025n

.meas tran vdout1_82ck1770 FIND v(dout1_82) AT=890.025n

.meas tran vdout1_83ck1770 FIND v(dout1_83) AT=890.025n

.meas tran vdout1_84ck1770 FIND v(dout1_84) AT=890.025n

.meas tran vdout1_85ck1770 FIND v(dout1_85) AT=890.025n

.meas tran vdout1_86ck1770 FIND v(dout1_86) AT=890.025n

.meas tran vdout1_87ck1770 FIND v(dout1_87) AT=890.025n

.meas tran vdout1_88ck1770 FIND v(dout1_88) AT=890.025n

.meas tran vdout1_89ck1770 FIND v(dout1_89) AT=890.025n

.meas tran vdout1_90ck1770 FIND v(dout1_90) AT=890.025n

.meas tran vdout1_91ck1770 FIND v(dout1_91) AT=890.025n

.meas tran vdout1_92ck1770 FIND v(dout1_92) AT=890.025n

.meas tran vdout1_93ck1770 FIND v(dout1_93) AT=890.025n

.meas tran vdout1_94ck1770 FIND v(dout1_94) AT=890.025n

.meas tran vdout1_95ck1770 FIND v(dout1_95) AT=890.025n

.meas tran vdout1_96ck1770 FIND v(dout1_96) AT=890.025n

.meas tran vdout1_97ck1770 FIND v(dout1_97) AT=890.025n

.meas tran vdout1_98ck1770 FIND v(dout1_98) AT=890.025n

.meas tran vdout1_99ck1770 FIND v(dout1_99) AT=890.025n

.meas tran vdout1_100ck1770 FIND v(dout1_100) AT=890.025n

.meas tran vdout1_101ck1770 FIND v(dout1_101) AT=890.025n

.meas tran vdout1_102ck1770 FIND v(dout1_102) AT=890.025n

.meas tran vdout1_103ck1770 FIND v(dout1_103) AT=890.025n

.meas tran vdout1_104ck1770 FIND v(dout1_104) AT=890.025n

.meas tran vdout1_105ck1770 FIND v(dout1_105) AT=890.025n

.meas tran vdout1_106ck1770 FIND v(dout1_106) AT=890.025n

.meas tran vdout1_107ck1770 FIND v(dout1_107) AT=890.025n

.meas tran vdout1_108ck1770 FIND v(dout1_108) AT=890.025n

.meas tran vdout1_109ck1770 FIND v(dout1_109) AT=890.025n

.meas tran vdout1_110ck1770 FIND v(dout1_110) AT=890.025n

.meas tran vdout1_111ck1770 FIND v(dout1_111) AT=890.025n

.meas tran vdout1_112ck1770 FIND v(dout1_112) AT=890.025n

.meas tran vdout1_113ck1770 FIND v(dout1_113) AT=890.025n

.meas tran vdout1_114ck1770 FIND v(dout1_114) AT=890.025n

.meas tran vdout1_115ck1770 FIND v(dout1_115) AT=890.025n

.meas tran vdout1_116ck1770 FIND v(dout1_116) AT=890.025n

.meas tran vdout1_117ck1770 FIND v(dout1_117) AT=890.025n

.meas tran vdout1_118ck1770 FIND v(dout1_118) AT=890.025n

.meas tran vdout1_119ck1770 FIND v(dout1_119) AT=890.025n

.meas tran vdout1_120ck1770 FIND v(dout1_120) AT=890.025n

.meas tran vdout1_121ck1770 FIND v(dout1_121) AT=890.025n

.meas tran vdout1_122ck1770 FIND v(dout1_122) AT=890.025n

.meas tran vdout1_123ck1770 FIND v(dout1_123) AT=890.025n

.meas tran vdout1_124ck1770 FIND v(dout1_124) AT=890.025n

.meas tran vdout1_125ck1770 FIND v(dout1_125) AT=890.025n

.meas tran vdout1_126ck1770 FIND v(dout1_126) AT=890.025n

.meas tran vdout1_127ck1770 FIND v(dout1_127) AT=890.025n

.meas tran vdout1_0ck1780 FIND v(dout1_0) AT=895.025n

.meas tran vdout1_1ck1780 FIND v(dout1_1) AT=895.025n

.meas tran vdout1_2ck1780 FIND v(dout1_2) AT=895.025n

.meas tran vdout1_3ck1780 FIND v(dout1_3) AT=895.025n

.meas tran vdout1_4ck1780 FIND v(dout1_4) AT=895.025n

.meas tran vdout1_5ck1780 FIND v(dout1_5) AT=895.025n

.meas tran vdout1_6ck1780 FIND v(dout1_6) AT=895.025n

.meas tran vdout1_7ck1780 FIND v(dout1_7) AT=895.025n

.meas tran vdout1_8ck1780 FIND v(dout1_8) AT=895.025n

.meas tran vdout1_9ck1780 FIND v(dout1_9) AT=895.025n

.meas tran vdout1_10ck1780 FIND v(dout1_10) AT=895.025n

.meas tran vdout1_11ck1780 FIND v(dout1_11) AT=895.025n

.meas tran vdout1_12ck1780 FIND v(dout1_12) AT=895.025n

.meas tran vdout1_13ck1780 FIND v(dout1_13) AT=895.025n

.meas tran vdout1_14ck1780 FIND v(dout1_14) AT=895.025n

.meas tran vdout1_15ck1780 FIND v(dout1_15) AT=895.025n

.meas tran vdout1_16ck1780 FIND v(dout1_16) AT=895.025n

.meas tran vdout1_17ck1780 FIND v(dout1_17) AT=895.025n

.meas tran vdout1_18ck1780 FIND v(dout1_18) AT=895.025n

.meas tran vdout1_19ck1780 FIND v(dout1_19) AT=895.025n

.meas tran vdout1_20ck1780 FIND v(dout1_20) AT=895.025n

.meas tran vdout1_21ck1780 FIND v(dout1_21) AT=895.025n

.meas tran vdout1_22ck1780 FIND v(dout1_22) AT=895.025n

.meas tran vdout1_23ck1780 FIND v(dout1_23) AT=895.025n

.meas tran vdout1_24ck1780 FIND v(dout1_24) AT=895.025n

.meas tran vdout1_25ck1780 FIND v(dout1_25) AT=895.025n

.meas tran vdout1_26ck1780 FIND v(dout1_26) AT=895.025n

.meas tran vdout1_27ck1780 FIND v(dout1_27) AT=895.025n

.meas tran vdout1_28ck1780 FIND v(dout1_28) AT=895.025n

.meas tran vdout1_29ck1780 FIND v(dout1_29) AT=895.025n

.meas tran vdout1_30ck1780 FIND v(dout1_30) AT=895.025n

.meas tran vdout1_31ck1780 FIND v(dout1_31) AT=895.025n

.meas tran vdout1_32ck1780 FIND v(dout1_32) AT=895.025n

.meas tran vdout1_33ck1780 FIND v(dout1_33) AT=895.025n

.meas tran vdout1_34ck1780 FIND v(dout1_34) AT=895.025n

.meas tran vdout1_35ck1780 FIND v(dout1_35) AT=895.025n

.meas tran vdout1_36ck1780 FIND v(dout1_36) AT=895.025n

.meas tran vdout1_37ck1780 FIND v(dout1_37) AT=895.025n

.meas tran vdout1_38ck1780 FIND v(dout1_38) AT=895.025n

.meas tran vdout1_39ck1780 FIND v(dout1_39) AT=895.025n

.meas tran vdout1_40ck1780 FIND v(dout1_40) AT=895.025n

.meas tran vdout1_41ck1780 FIND v(dout1_41) AT=895.025n

.meas tran vdout1_42ck1780 FIND v(dout1_42) AT=895.025n

.meas tran vdout1_43ck1780 FIND v(dout1_43) AT=895.025n

.meas tran vdout1_44ck1780 FIND v(dout1_44) AT=895.025n

.meas tran vdout1_45ck1780 FIND v(dout1_45) AT=895.025n

.meas tran vdout1_46ck1780 FIND v(dout1_46) AT=895.025n

.meas tran vdout1_47ck1780 FIND v(dout1_47) AT=895.025n

.meas tran vdout1_48ck1780 FIND v(dout1_48) AT=895.025n

.meas tran vdout1_49ck1780 FIND v(dout1_49) AT=895.025n

.meas tran vdout1_50ck1780 FIND v(dout1_50) AT=895.025n

.meas tran vdout1_51ck1780 FIND v(dout1_51) AT=895.025n

.meas tran vdout1_52ck1780 FIND v(dout1_52) AT=895.025n

.meas tran vdout1_53ck1780 FIND v(dout1_53) AT=895.025n

.meas tran vdout1_54ck1780 FIND v(dout1_54) AT=895.025n

.meas tran vdout1_55ck1780 FIND v(dout1_55) AT=895.025n

.meas tran vdout1_56ck1780 FIND v(dout1_56) AT=895.025n

.meas tran vdout1_57ck1780 FIND v(dout1_57) AT=895.025n

.meas tran vdout1_58ck1780 FIND v(dout1_58) AT=895.025n

.meas tran vdout1_59ck1780 FIND v(dout1_59) AT=895.025n

.meas tran vdout1_60ck1780 FIND v(dout1_60) AT=895.025n

.meas tran vdout1_61ck1780 FIND v(dout1_61) AT=895.025n

.meas tran vdout1_62ck1780 FIND v(dout1_62) AT=895.025n

.meas tran vdout1_63ck1780 FIND v(dout1_63) AT=895.025n

.meas tran vdout1_64ck1780 FIND v(dout1_64) AT=895.025n

.meas tran vdout1_65ck1780 FIND v(dout1_65) AT=895.025n

.meas tran vdout1_66ck1780 FIND v(dout1_66) AT=895.025n

.meas tran vdout1_67ck1780 FIND v(dout1_67) AT=895.025n

.meas tran vdout1_68ck1780 FIND v(dout1_68) AT=895.025n

.meas tran vdout1_69ck1780 FIND v(dout1_69) AT=895.025n

.meas tran vdout1_70ck1780 FIND v(dout1_70) AT=895.025n

.meas tran vdout1_71ck1780 FIND v(dout1_71) AT=895.025n

.meas tran vdout1_72ck1780 FIND v(dout1_72) AT=895.025n

.meas tran vdout1_73ck1780 FIND v(dout1_73) AT=895.025n

.meas tran vdout1_74ck1780 FIND v(dout1_74) AT=895.025n

.meas tran vdout1_75ck1780 FIND v(dout1_75) AT=895.025n

.meas tran vdout1_76ck1780 FIND v(dout1_76) AT=895.025n

.meas tran vdout1_77ck1780 FIND v(dout1_77) AT=895.025n

.meas tran vdout1_78ck1780 FIND v(dout1_78) AT=895.025n

.meas tran vdout1_79ck1780 FIND v(dout1_79) AT=895.025n

.meas tran vdout1_80ck1780 FIND v(dout1_80) AT=895.025n

.meas tran vdout1_81ck1780 FIND v(dout1_81) AT=895.025n

.meas tran vdout1_82ck1780 FIND v(dout1_82) AT=895.025n

.meas tran vdout1_83ck1780 FIND v(dout1_83) AT=895.025n

.meas tran vdout1_84ck1780 FIND v(dout1_84) AT=895.025n

.meas tran vdout1_85ck1780 FIND v(dout1_85) AT=895.025n

.meas tran vdout1_86ck1780 FIND v(dout1_86) AT=895.025n

.meas tran vdout1_87ck1780 FIND v(dout1_87) AT=895.025n

.meas tran vdout1_88ck1780 FIND v(dout1_88) AT=895.025n

.meas tran vdout1_89ck1780 FIND v(dout1_89) AT=895.025n

.meas tran vdout1_90ck1780 FIND v(dout1_90) AT=895.025n

.meas tran vdout1_91ck1780 FIND v(dout1_91) AT=895.025n

.meas tran vdout1_92ck1780 FIND v(dout1_92) AT=895.025n

.meas tran vdout1_93ck1780 FIND v(dout1_93) AT=895.025n

.meas tran vdout1_94ck1780 FIND v(dout1_94) AT=895.025n

.meas tran vdout1_95ck1780 FIND v(dout1_95) AT=895.025n

.meas tran vdout1_96ck1780 FIND v(dout1_96) AT=895.025n

.meas tran vdout1_97ck1780 FIND v(dout1_97) AT=895.025n

.meas tran vdout1_98ck1780 FIND v(dout1_98) AT=895.025n

.meas tran vdout1_99ck1780 FIND v(dout1_99) AT=895.025n

.meas tran vdout1_100ck1780 FIND v(dout1_100) AT=895.025n

.meas tran vdout1_101ck1780 FIND v(dout1_101) AT=895.025n

.meas tran vdout1_102ck1780 FIND v(dout1_102) AT=895.025n

.meas tran vdout1_103ck1780 FIND v(dout1_103) AT=895.025n

.meas tran vdout1_104ck1780 FIND v(dout1_104) AT=895.025n

.meas tran vdout1_105ck1780 FIND v(dout1_105) AT=895.025n

.meas tran vdout1_106ck1780 FIND v(dout1_106) AT=895.025n

.meas tran vdout1_107ck1780 FIND v(dout1_107) AT=895.025n

.meas tran vdout1_108ck1780 FIND v(dout1_108) AT=895.025n

.meas tran vdout1_109ck1780 FIND v(dout1_109) AT=895.025n

.meas tran vdout1_110ck1780 FIND v(dout1_110) AT=895.025n

.meas tran vdout1_111ck1780 FIND v(dout1_111) AT=895.025n

.meas tran vdout1_112ck1780 FIND v(dout1_112) AT=895.025n

.meas tran vdout1_113ck1780 FIND v(dout1_113) AT=895.025n

.meas tran vdout1_114ck1780 FIND v(dout1_114) AT=895.025n

.meas tran vdout1_115ck1780 FIND v(dout1_115) AT=895.025n

.meas tran vdout1_116ck1780 FIND v(dout1_116) AT=895.025n

.meas tran vdout1_117ck1780 FIND v(dout1_117) AT=895.025n

.meas tran vdout1_118ck1780 FIND v(dout1_118) AT=895.025n

.meas tran vdout1_119ck1780 FIND v(dout1_119) AT=895.025n

.meas tran vdout1_120ck1780 FIND v(dout1_120) AT=895.025n

.meas tran vdout1_121ck1780 FIND v(dout1_121) AT=895.025n

.meas tran vdout1_122ck1780 FIND v(dout1_122) AT=895.025n

.meas tran vdout1_123ck1780 FIND v(dout1_123) AT=895.025n

.meas tran vdout1_124ck1780 FIND v(dout1_124) AT=895.025n

.meas tran vdout1_125ck1780 FIND v(dout1_125) AT=895.025n

.meas tran vdout1_126ck1780 FIND v(dout1_126) AT=895.025n

.meas tran vdout1_127ck1780 FIND v(dout1_127) AT=895.025n

.meas tran vdout1_0ck1840 FIND v(dout1_0) AT=925.025n

.meas tran vdout1_1ck1840 FIND v(dout1_1) AT=925.025n

.meas tran vdout1_2ck1840 FIND v(dout1_2) AT=925.025n

.meas tran vdout1_3ck1840 FIND v(dout1_3) AT=925.025n

.meas tran vdout1_4ck1840 FIND v(dout1_4) AT=925.025n

.meas tran vdout1_5ck1840 FIND v(dout1_5) AT=925.025n

.meas tran vdout1_6ck1840 FIND v(dout1_6) AT=925.025n

.meas tran vdout1_7ck1840 FIND v(dout1_7) AT=925.025n

.meas tran vdout1_8ck1840 FIND v(dout1_8) AT=925.025n

.meas tran vdout1_9ck1840 FIND v(dout1_9) AT=925.025n

.meas tran vdout1_10ck1840 FIND v(dout1_10) AT=925.025n

.meas tran vdout1_11ck1840 FIND v(dout1_11) AT=925.025n

.meas tran vdout1_12ck1840 FIND v(dout1_12) AT=925.025n

.meas tran vdout1_13ck1840 FIND v(dout1_13) AT=925.025n

.meas tran vdout1_14ck1840 FIND v(dout1_14) AT=925.025n

.meas tran vdout1_15ck1840 FIND v(dout1_15) AT=925.025n

.meas tran vdout1_16ck1840 FIND v(dout1_16) AT=925.025n

.meas tran vdout1_17ck1840 FIND v(dout1_17) AT=925.025n

.meas tran vdout1_18ck1840 FIND v(dout1_18) AT=925.025n

.meas tran vdout1_19ck1840 FIND v(dout1_19) AT=925.025n

.meas tran vdout1_20ck1840 FIND v(dout1_20) AT=925.025n

.meas tran vdout1_21ck1840 FIND v(dout1_21) AT=925.025n

.meas tran vdout1_22ck1840 FIND v(dout1_22) AT=925.025n

.meas tran vdout1_23ck1840 FIND v(dout1_23) AT=925.025n

.meas tran vdout1_24ck1840 FIND v(dout1_24) AT=925.025n

.meas tran vdout1_25ck1840 FIND v(dout1_25) AT=925.025n

.meas tran vdout1_26ck1840 FIND v(dout1_26) AT=925.025n

.meas tran vdout1_27ck1840 FIND v(dout1_27) AT=925.025n

.meas tran vdout1_28ck1840 FIND v(dout1_28) AT=925.025n

.meas tran vdout1_29ck1840 FIND v(dout1_29) AT=925.025n

.meas tran vdout1_30ck1840 FIND v(dout1_30) AT=925.025n

.meas tran vdout1_31ck1840 FIND v(dout1_31) AT=925.025n

.meas tran vdout1_32ck1840 FIND v(dout1_32) AT=925.025n

.meas tran vdout1_33ck1840 FIND v(dout1_33) AT=925.025n

.meas tran vdout1_34ck1840 FIND v(dout1_34) AT=925.025n

.meas tran vdout1_35ck1840 FIND v(dout1_35) AT=925.025n

.meas tran vdout1_36ck1840 FIND v(dout1_36) AT=925.025n

.meas tran vdout1_37ck1840 FIND v(dout1_37) AT=925.025n

.meas tran vdout1_38ck1840 FIND v(dout1_38) AT=925.025n

.meas tran vdout1_39ck1840 FIND v(dout1_39) AT=925.025n

.meas tran vdout1_40ck1840 FIND v(dout1_40) AT=925.025n

.meas tran vdout1_41ck1840 FIND v(dout1_41) AT=925.025n

.meas tran vdout1_42ck1840 FIND v(dout1_42) AT=925.025n

.meas tran vdout1_43ck1840 FIND v(dout1_43) AT=925.025n

.meas tran vdout1_44ck1840 FIND v(dout1_44) AT=925.025n

.meas tran vdout1_45ck1840 FIND v(dout1_45) AT=925.025n

.meas tran vdout1_46ck1840 FIND v(dout1_46) AT=925.025n

.meas tran vdout1_47ck1840 FIND v(dout1_47) AT=925.025n

.meas tran vdout1_48ck1840 FIND v(dout1_48) AT=925.025n

.meas tran vdout1_49ck1840 FIND v(dout1_49) AT=925.025n

.meas tran vdout1_50ck1840 FIND v(dout1_50) AT=925.025n

.meas tran vdout1_51ck1840 FIND v(dout1_51) AT=925.025n

.meas tran vdout1_52ck1840 FIND v(dout1_52) AT=925.025n

.meas tran vdout1_53ck1840 FIND v(dout1_53) AT=925.025n

.meas tran vdout1_54ck1840 FIND v(dout1_54) AT=925.025n

.meas tran vdout1_55ck1840 FIND v(dout1_55) AT=925.025n

.meas tran vdout1_56ck1840 FIND v(dout1_56) AT=925.025n

.meas tran vdout1_57ck1840 FIND v(dout1_57) AT=925.025n

.meas tran vdout1_58ck1840 FIND v(dout1_58) AT=925.025n

.meas tran vdout1_59ck1840 FIND v(dout1_59) AT=925.025n

.meas tran vdout1_60ck1840 FIND v(dout1_60) AT=925.025n

.meas tran vdout1_61ck1840 FIND v(dout1_61) AT=925.025n

.meas tran vdout1_62ck1840 FIND v(dout1_62) AT=925.025n

.meas tran vdout1_63ck1840 FIND v(dout1_63) AT=925.025n

.meas tran vdout1_64ck1840 FIND v(dout1_64) AT=925.025n

.meas tran vdout1_65ck1840 FIND v(dout1_65) AT=925.025n

.meas tran vdout1_66ck1840 FIND v(dout1_66) AT=925.025n

.meas tran vdout1_67ck1840 FIND v(dout1_67) AT=925.025n

.meas tran vdout1_68ck1840 FIND v(dout1_68) AT=925.025n

.meas tran vdout1_69ck1840 FIND v(dout1_69) AT=925.025n

.meas tran vdout1_70ck1840 FIND v(dout1_70) AT=925.025n

.meas tran vdout1_71ck1840 FIND v(dout1_71) AT=925.025n

.meas tran vdout1_72ck1840 FIND v(dout1_72) AT=925.025n

.meas tran vdout1_73ck1840 FIND v(dout1_73) AT=925.025n

.meas tran vdout1_74ck1840 FIND v(dout1_74) AT=925.025n

.meas tran vdout1_75ck1840 FIND v(dout1_75) AT=925.025n

.meas tran vdout1_76ck1840 FIND v(dout1_76) AT=925.025n

.meas tran vdout1_77ck1840 FIND v(dout1_77) AT=925.025n

.meas tran vdout1_78ck1840 FIND v(dout1_78) AT=925.025n

.meas tran vdout1_79ck1840 FIND v(dout1_79) AT=925.025n

.meas tran vdout1_80ck1840 FIND v(dout1_80) AT=925.025n

.meas tran vdout1_81ck1840 FIND v(dout1_81) AT=925.025n

.meas tran vdout1_82ck1840 FIND v(dout1_82) AT=925.025n

.meas tran vdout1_83ck1840 FIND v(dout1_83) AT=925.025n

.meas tran vdout1_84ck1840 FIND v(dout1_84) AT=925.025n

.meas tran vdout1_85ck1840 FIND v(dout1_85) AT=925.025n

.meas tran vdout1_86ck1840 FIND v(dout1_86) AT=925.025n

.meas tran vdout1_87ck1840 FIND v(dout1_87) AT=925.025n

.meas tran vdout1_88ck1840 FIND v(dout1_88) AT=925.025n

.meas tran vdout1_89ck1840 FIND v(dout1_89) AT=925.025n

.meas tran vdout1_90ck1840 FIND v(dout1_90) AT=925.025n

.meas tran vdout1_91ck1840 FIND v(dout1_91) AT=925.025n

.meas tran vdout1_92ck1840 FIND v(dout1_92) AT=925.025n

.meas tran vdout1_93ck1840 FIND v(dout1_93) AT=925.025n

.meas tran vdout1_94ck1840 FIND v(dout1_94) AT=925.025n

.meas tran vdout1_95ck1840 FIND v(dout1_95) AT=925.025n

.meas tran vdout1_96ck1840 FIND v(dout1_96) AT=925.025n

.meas tran vdout1_97ck1840 FIND v(dout1_97) AT=925.025n

.meas tran vdout1_98ck1840 FIND v(dout1_98) AT=925.025n

.meas tran vdout1_99ck1840 FIND v(dout1_99) AT=925.025n

.meas tran vdout1_100ck1840 FIND v(dout1_100) AT=925.025n

.meas tran vdout1_101ck1840 FIND v(dout1_101) AT=925.025n

.meas tran vdout1_102ck1840 FIND v(dout1_102) AT=925.025n

.meas tran vdout1_103ck1840 FIND v(dout1_103) AT=925.025n

.meas tran vdout1_104ck1840 FIND v(dout1_104) AT=925.025n

.meas tran vdout1_105ck1840 FIND v(dout1_105) AT=925.025n

.meas tran vdout1_106ck1840 FIND v(dout1_106) AT=925.025n

.meas tran vdout1_107ck1840 FIND v(dout1_107) AT=925.025n

.meas tran vdout1_108ck1840 FIND v(dout1_108) AT=925.025n

.meas tran vdout1_109ck1840 FIND v(dout1_109) AT=925.025n

.meas tran vdout1_110ck1840 FIND v(dout1_110) AT=925.025n

.meas tran vdout1_111ck1840 FIND v(dout1_111) AT=925.025n

.meas tran vdout1_112ck1840 FIND v(dout1_112) AT=925.025n

.meas tran vdout1_113ck1840 FIND v(dout1_113) AT=925.025n

.meas tran vdout1_114ck1840 FIND v(dout1_114) AT=925.025n

.meas tran vdout1_115ck1840 FIND v(dout1_115) AT=925.025n

.meas tran vdout1_116ck1840 FIND v(dout1_116) AT=925.025n

.meas tran vdout1_117ck1840 FIND v(dout1_117) AT=925.025n

.meas tran vdout1_118ck1840 FIND v(dout1_118) AT=925.025n

.meas tran vdout1_119ck1840 FIND v(dout1_119) AT=925.025n

.meas tran vdout1_120ck1840 FIND v(dout1_120) AT=925.025n

.meas tran vdout1_121ck1840 FIND v(dout1_121) AT=925.025n

.meas tran vdout1_122ck1840 FIND v(dout1_122) AT=925.025n

.meas tran vdout1_123ck1840 FIND v(dout1_123) AT=925.025n

.meas tran vdout1_124ck1840 FIND v(dout1_124) AT=925.025n

.meas tran vdout1_125ck1840 FIND v(dout1_125) AT=925.025n

.meas tran vdout1_126ck1840 FIND v(dout1_126) AT=925.025n

.meas tran vdout1_127ck1840 FIND v(dout1_127) AT=925.025n

.meas tran vdout1_0ck1850 FIND v(dout1_0) AT=930.025n

.meas tran vdout1_1ck1850 FIND v(dout1_1) AT=930.025n

.meas tran vdout1_2ck1850 FIND v(dout1_2) AT=930.025n

.meas tran vdout1_3ck1850 FIND v(dout1_3) AT=930.025n

.meas tran vdout1_4ck1850 FIND v(dout1_4) AT=930.025n

.meas tran vdout1_5ck1850 FIND v(dout1_5) AT=930.025n

.meas tran vdout1_6ck1850 FIND v(dout1_6) AT=930.025n

.meas tran vdout1_7ck1850 FIND v(dout1_7) AT=930.025n

.meas tran vdout1_8ck1850 FIND v(dout1_8) AT=930.025n

.meas tran vdout1_9ck1850 FIND v(dout1_9) AT=930.025n

.meas tran vdout1_10ck1850 FIND v(dout1_10) AT=930.025n

.meas tran vdout1_11ck1850 FIND v(dout1_11) AT=930.025n

.meas tran vdout1_12ck1850 FIND v(dout1_12) AT=930.025n

.meas tran vdout1_13ck1850 FIND v(dout1_13) AT=930.025n

.meas tran vdout1_14ck1850 FIND v(dout1_14) AT=930.025n

.meas tran vdout1_15ck1850 FIND v(dout1_15) AT=930.025n

.meas tran vdout1_16ck1850 FIND v(dout1_16) AT=930.025n

.meas tran vdout1_17ck1850 FIND v(dout1_17) AT=930.025n

.meas tran vdout1_18ck1850 FIND v(dout1_18) AT=930.025n

.meas tran vdout1_19ck1850 FIND v(dout1_19) AT=930.025n

.meas tran vdout1_20ck1850 FIND v(dout1_20) AT=930.025n

.meas tran vdout1_21ck1850 FIND v(dout1_21) AT=930.025n

.meas tran vdout1_22ck1850 FIND v(dout1_22) AT=930.025n

.meas tran vdout1_23ck1850 FIND v(dout1_23) AT=930.025n

.meas tran vdout1_24ck1850 FIND v(dout1_24) AT=930.025n

.meas tran vdout1_25ck1850 FIND v(dout1_25) AT=930.025n

.meas tran vdout1_26ck1850 FIND v(dout1_26) AT=930.025n

.meas tran vdout1_27ck1850 FIND v(dout1_27) AT=930.025n

.meas tran vdout1_28ck1850 FIND v(dout1_28) AT=930.025n

.meas tran vdout1_29ck1850 FIND v(dout1_29) AT=930.025n

.meas tran vdout1_30ck1850 FIND v(dout1_30) AT=930.025n

.meas tran vdout1_31ck1850 FIND v(dout1_31) AT=930.025n

.meas tran vdout1_32ck1850 FIND v(dout1_32) AT=930.025n

.meas tran vdout1_33ck1850 FIND v(dout1_33) AT=930.025n

.meas tran vdout1_34ck1850 FIND v(dout1_34) AT=930.025n

.meas tran vdout1_35ck1850 FIND v(dout1_35) AT=930.025n

.meas tran vdout1_36ck1850 FIND v(dout1_36) AT=930.025n

.meas tran vdout1_37ck1850 FIND v(dout1_37) AT=930.025n

.meas tran vdout1_38ck1850 FIND v(dout1_38) AT=930.025n

.meas tran vdout1_39ck1850 FIND v(dout1_39) AT=930.025n

.meas tran vdout1_40ck1850 FIND v(dout1_40) AT=930.025n

.meas tran vdout1_41ck1850 FIND v(dout1_41) AT=930.025n

.meas tran vdout1_42ck1850 FIND v(dout1_42) AT=930.025n

.meas tran vdout1_43ck1850 FIND v(dout1_43) AT=930.025n

.meas tran vdout1_44ck1850 FIND v(dout1_44) AT=930.025n

.meas tran vdout1_45ck1850 FIND v(dout1_45) AT=930.025n

.meas tran vdout1_46ck1850 FIND v(dout1_46) AT=930.025n

.meas tran vdout1_47ck1850 FIND v(dout1_47) AT=930.025n

.meas tran vdout1_48ck1850 FIND v(dout1_48) AT=930.025n

.meas tran vdout1_49ck1850 FIND v(dout1_49) AT=930.025n

.meas tran vdout1_50ck1850 FIND v(dout1_50) AT=930.025n

.meas tran vdout1_51ck1850 FIND v(dout1_51) AT=930.025n

.meas tran vdout1_52ck1850 FIND v(dout1_52) AT=930.025n

.meas tran vdout1_53ck1850 FIND v(dout1_53) AT=930.025n

.meas tran vdout1_54ck1850 FIND v(dout1_54) AT=930.025n

.meas tran vdout1_55ck1850 FIND v(dout1_55) AT=930.025n

.meas tran vdout1_56ck1850 FIND v(dout1_56) AT=930.025n

.meas tran vdout1_57ck1850 FIND v(dout1_57) AT=930.025n

.meas tran vdout1_58ck1850 FIND v(dout1_58) AT=930.025n

.meas tran vdout1_59ck1850 FIND v(dout1_59) AT=930.025n

.meas tran vdout1_60ck1850 FIND v(dout1_60) AT=930.025n

.meas tran vdout1_61ck1850 FIND v(dout1_61) AT=930.025n

.meas tran vdout1_62ck1850 FIND v(dout1_62) AT=930.025n

.meas tran vdout1_63ck1850 FIND v(dout1_63) AT=930.025n

.meas tran vdout1_64ck1850 FIND v(dout1_64) AT=930.025n

.meas tran vdout1_65ck1850 FIND v(dout1_65) AT=930.025n

.meas tran vdout1_66ck1850 FIND v(dout1_66) AT=930.025n

.meas tran vdout1_67ck1850 FIND v(dout1_67) AT=930.025n

.meas tran vdout1_68ck1850 FIND v(dout1_68) AT=930.025n

.meas tran vdout1_69ck1850 FIND v(dout1_69) AT=930.025n

.meas tran vdout1_70ck1850 FIND v(dout1_70) AT=930.025n

.meas tran vdout1_71ck1850 FIND v(dout1_71) AT=930.025n

.meas tran vdout1_72ck1850 FIND v(dout1_72) AT=930.025n

.meas tran vdout1_73ck1850 FIND v(dout1_73) AT=930.025n

.meas tran vdout1_74ck1850 FIND v(dout1_74) AT=930.025n

.meas tran vdout1_75ck1850 FIND v(dout1_75) AT=930.025n

.meas tran vdout1_76ck1850 FIND v(dout1_76) AT=930.025n

.meas tran vdout1_77ck1850 FIND v(dout1_77) AT=930.025n

.meas tran vdout1_78ck1850 FIND v(dout1_78) AT=930.025n

.meas tran vdout1_79ck1850 FIND v(dout1_79) AT=930.025n

.meas tran vdout1_80ck1850 FIND v(dout1_80) AT=930.025n

.meas tran vdout1_81ck1850 FIND v(dout1_81) AT=930.025n

.meas tran vdout1_82ck1850 FIND v(dout1_82) AT=930.025n

.meas tran vdout1_83ck1850 FIND v(dout1_83) AT=930.025n

.meas tran vdout1_84ck1850 FIND v(dout1_84) AT=930.025n

.meas tran vdout1_85ck1850 FIND v(dout1_85) AT=930.025n

.meas tran vdout1_86ck1850 FIND v(dout1_86) AT=930.025n

.meas tran vdout1_87ck1850 FIND v(dout1_87) AT=930.025n

.meas tran vdout1_88ck1850 FIND v(dout1_88) AT=930.025n

.meas tran vdout1_89ck1850 FIND v(dout1_89) AT=930.025n

.meas tran vdout1_90ck1850 FIND v(dout1_90) AT=930.025n

.meas tran vdout1_91ck1850 FIND v(dout1_91) AT=930.025n

.meas tran vdout1_92ck1850 FIND v(dout1_92) AT=930.025n

.meas tran vdout1_93ck1850 FIND v(dout1_93) AT=930.025n

.meas tran vdout1_94ck1850 FIND v(dout1_94) AT=930.025n

.meas tran vdout1_95ck1850 FIND v(dout1_95) AT=930.025n

.meas tran vdout1_96ck1850 FIND v(dout1_96) AT=930.025n

.meas tran vdout1_97ck1850 FIND v(dout1_97) AT=930.025n

.meas tran vdout1_98ck1850 FIND v(dout1_98) AT=930.025n

.meas tran vdout1_99ck1850 FIND v(dout1_99) AT=930.025n

.meas tran vdout1_100ck1850 FIND v(dout1_100) AT=930.025n

.meas tran vdout1_101ck1850 FIND v(dout1_101) AT=930.025n

.meas tran vdout1_102ck1850 FIND v(dout1_102) AT=930.025n

.meas tran vdout1_103ck1850 FIND v(dout1_103) AT=930.025n

.meas tran vdout1_104ck1850 FIND v(dout1_104) AT=930.025n

.meas tran vdout1_105ck1850 FIND v(dout1_105) AT=930.025n

.meas tran vdout1_106ck1850 FIND v(dout1_106) AT=930.025n

.meas tran vdout1_107ck1850 FIND v(dout1_107) AT=930.025n

.meas tran vdout1_108ck1850 FIND v(dout1_108) AT=930.025n

.meas tran vdout1_109ck1850 FIND v(dout1_109) AT=930.025n

.meas tran vdout1_110ck1850 FIND v(dout1_110) AT=930.025n

.meas tran vdout1_111ck1850 FIND v(dout1_111) AT=930.025n

.meas tran vdout1_112ck1850 FIND v(dout1_112) AT=930.025n

.meas tran vdout1_113ck1850 FIND v(dout1_113) AT=930.025n

.meas tran vdout1_114ck1850 FIND v(dout1_114) AT=930.025n

.meas tran vdout1_115ck1850 FIND v(dout1_115) AT=930.025n

.meas tran vdout1_116ck1850 FIND v(dout1_116) AT=930.025n

.meas tran vdout1_117ck1850 FIND v(dout1_117) AT=930.025n

.meas tran vdout1_118ck1850 FIND v(dout1_118) AT=930.025n

.meas tran vdout1_119ck1850 FIND v(dout1_119) AT=930.025n

.meas tran vdout1_120ck1850 FIND v(dout1_120) AT=930.025n

.meas tran vdout1_121ck1850 FIND v(dout1_121) AT=930.025n

.meas tran vdout1_122ck1850 FIND v(dout1_122) AT=930.025n

.meas tran vdout1_123ck1850 FIND v(dout1_123) AT=930.025n

.meas tran vdout1_124ck1850 FIND v(dout1_124) AT=930.025n

.meas tran vdout1_125ck1850 FIND v(dout1_125) AT=930.025n

.meas tran vdout1_126ck1850 FIND v(dout1_126) AT=930.025n

.meas tran vdout1_127ck1850 FIND v(dout1_127) AT=930.025n

.meas tran vdout1_0ck1890 FIND v(dout1_0) AT=950.025n

.meas tran vdout1_1ck1890 FIND v(dout1_1) AT=950.025n

.meas tran vdout1_2ck1890 FIND v(dout1_2) AT=950.025n

.meas tran vdout1_3ck1890 FIND v(dout1_3) AT=950.025n

.meas tran vdout1_4ck1890 FIND v(dout1_4) AT=950.025n

.meas tran vdout1_5ck1890 FIND v(dout1_5) AT=950.025n

.meas tran vdout1_6ck1890 FIND v(dout1_6) AT=950.025n

.meas tran vdout1_7ck1890 FIND v(dout1_7) AT=950.025n

.meas tran vdout1_8ck1890 FIND v(dout1_8) AT=950.025n

.meas tran vdout1_9ck1890 FIND v(dout1_9) AT=950.025n

.meas tran vdout1_10ck1890 FIND v(dout1_10) AT=950.025n

.meas tran vdout1_11ck1890 FIND v(dout1_11) AT=950.025n

.meas tran vdout1_12ck1890 FIND v(dout1_12) AT=950.025n

.meas tran vdout1_13ck1890 FIND v(dout1_13) AT=950.025n

.meas tran vdout1_14ck1890 FIND v(dout1_14) AT=950.025n

.meas tran vdout1_15ck1890 FIND v(dout1_15) AT=950.025n

.meas tran vdout1_16ck1890 FIND v(dout1_16) AT=950.025n

.meas tran vdout1_17ck1890 FIND v(dout1_17) AT=950.025n

.meas tran vdout1_18ck1890 FIND v(dout1_18) AT=950.025n

.meas tran vdout1_19ck1890 FIND v(dout1_19) AT=950.025n

.meas tran vdout1_20ck1890 FIND v(dout1_20) AT=950.025n

.meas tran vdout1_21ck1890 FIND v(dout1_21) AT=950.025n

.meas tran vdout1_22ck1890 FIND v(dout1_22) AT=950.025n

.meas tran vdout1_23ck1890 FIND v(dout1_23) AT=950.025n

.meas tran vdout1_24ck1890 FIND v(dout1_24) AT=950.025n

.meas tran vdout1_25ck1890 FIND v(dout1_25) AT=950.025n

.meas tran vdout1_26ck1890 FIND v(dout1_26) AT=950.025n

.meas tran vdout1_27ck1890 FIND v(dout1_27) AT=950.025n

.meas tran vdout1_28ck1890 FIND v(dout1_28) AT=950.025n

.meas tran vdout1_29ck1890 FIND v(dout1_29) AT=950.025n

.meas tran vdout1_30ck1890 FIND v(dout1_30) AT=950.025n

.meas tran vdout1_31ck1890 FIND v(dout1_31) AT=950.025n

.meas tran vdout1_32ck1890 FIND v(dout1_32) AT=950.025n

.meas tran vdout1_33ck1890 FIND v(dout1_33) AT=950.025n

.meas tran vdout1_34ck1890 FIND v(dout1_34) AT=950.025n

.meas tran vdout1_35ck1890 FIND v(dout1_35) AT=950.025n

.meas tran vdout1_36ck1890 FIND v(dout1_36) AT=950.025n

.meas tran vdout1_37ck1890 FIND v(dout1_37) AT=950.025n

.meas tran vdout1_38ck1890 FIND v(dout1_38) AT=950.025n

.meas tran vdout1_39ck1890 FIND v(dout1_39) AT=950.025n

.meas tran vdout1_40ck1890 FIND v(dout1_40) AT=950.025n

.meas tran vdout1_41ck1890 FIND v(dout1_41) AT=950.025n

.meas tran vdout1_42ck1890 FIND v(dout1_42) AT=950.025n

.meas tran vdout1_43ck1890 FIND v(dout1_43) AT=950.025n

.meas tran vdout1_44ck1890 FIND v(dout1_44) AT=950.025n

.meas tran vdout1_45ck1890 FIND v(dout1_45) AT=950.025n

.meas tran vdout1_46ck1890 FIND v(dout1_46) AT=950.025n

.meas tran vdout1_47ck1890 FIND v(dout1_47) AT=950.025n

.meas tran vdout1_48ck1890 FIND v(dout1_48) AT=950.025n

.meas tran vdout1_49ck1890 FIND v(dout1_49) AT=950.025n

.meas tran vdout1_50ck1890 FIND v(dout1_50) AT=950.025n

.meas tran vdout1_51ck1890 FIND v(dout1_51) AT=950.025n

.meas tran vdout1_52ck1890 FIND v(dout1_52) AT=950.025n

.meas tran vdout1_53ck1890 FIND v(dout1_53) AT=950.025n

.meas tran vdout1_54ck1890 FIND v(dout1_54) AT=950.025n

.meas tran vdout1_55ck1890 FIND v(dout1_55) AT=950.025n

.meas tran vdout1_56ck1890 FIND v(dout1_56) AT=950.025n

.meas tran vdout1_57ck1890 FIND v(dout1_57) AT=950.025n

.meas tran vdout1_58ck1890 FIND v(dout1_58) AT=950.025n

.meas tran vdout1_59ck1890 FIND v(dout1_59) AT=950.025n

.meas tran vdout1_60ck1890 FIND v(dout1_60) AT=950.025n

.meas tran vdout1_61ck1890 FIND v(dout1_61) AT=950.025n

.meas tran vdout1_62ck1890 FIND v(dout1_62) AT=950.025n

.meas tran vdout1_63ck1890 FIND v(dout1_63) AT=950.025n

.meas tran vdout1_64ck1890 FIND v(dout1_64) AT=950.025n

.meas tran vdout1_65ck1890 FIND v(dout1_65) AT=950.025n

.meas tran vdout1_66ck1890 FIND v(dout1_66) AT=950.025n

.meas tran vdout1_67ck1890 FIND v(dout1_67) AT=950.025n

.meas tran vdout1_68ck1890 FIND v(dout1_68) AT=950.025n

.meas tran vdout1_69ck1890 FIND v(dout1_69) AT=950.025n

.meas tran vdout1_70ck1890 FIND v(dout1_70) AT=950.025n

.meas tran vdout1_71ck1890 FIND v(dout1_71) AT=950.025n

.meas tran vdout1_72ck1890 FIND v(dout1_72) AT=950.025n

.meas tran vdout1_73ck1890 FIND v(dout1_73) AT=950.025n

.meas tran vdout1_74ck1890 FIND v(dout1_74) AT=950.025n

.meas tran vdout1_75ck1890 FIND v(dout1_75) AT=950.025n

.meas tran vdout1_76ck1890 FIND v(dout1_76) AT=950.025n

.meas tran vdout1_77ck1890 FIND v(dout1_77) AT=950.025n

.meas tran vdout1_78ck1890 FIND v(dout1_78) AT=950.025n

.meas tran vdout1_79ck1890 FIND v(dout1_79) AT=950.025n

.meas tran vdout1_80ck1890 FIND v(dout1_80) AT=950.025n

.meas tran vdout1_81ck1890 FIND v(dout1_81) AT=950.025n

.meas tran vdout1_82ck1890 FIND v(dout1_82) AT=950.025n

.meas tran vdout1_83ck1890 FIND v(dout1_83) AT=950.025n

.meas tran vdout1_84ck1890 FIND v(dout1_84) AT=950.025n

.meas tran vdout1_85ck1890 FIND v(dout1_85) AT=950.025n

.meas tran vdout1_86ck1890 FIND v(dout1_86) AT=950.025n

.meas tran vdout1_87ck1890 FIND v(dout1_87) AT=950.025n

.meas tran vdout1_88ck1890 FIND v(dout1_88) AT=950.025n

.meas tran vdout1_89ck1890 FIND v(dout1_89) AT=950.025n

.meas tran vdout1_90ck1890 FIND v(dout1_90) AT=950.025n

.meas tran vdout1_91ck1890 FIND v(dout1_91) AT=950.025n

.meas tran vdout1_92ck1890 FIND v(dout1_92) AT=950.025n

.meas tran vdout1_93ck1890 FIND v(dout1_93) AT=950.025n

.meas tran vdout1_94ck1890 FIND v(dout1_94) AT=950.025n

.meas tran vdout1_95ck1890 FIND v(dout1_95) AT=950.025n

.meas tran vdout1_96ck1890 FIND v(dout1_96) AT=950.025n

.meas tran vdout1_97ck1890 FIND v(dout1_97) AT=950.025n

.meas tran vdout1_98ck1890 FIND v(dout1_98) AT=950.025n

.meas tran vdout1_99ck1890 FIND v(dout1_99) AT=950.025n

.meas tran vdout1_100ck1890 FIND v(dout1_100) AT=950.025n

.meas tran vdout1_101ck1890 FIND v(dout1_101) AT=950.025n

.meas tran vdout1_102ck1890 FIND v(dout1_102) AT=950.025n

.meas tran vdout1_103ck1890 FIND v(dout1_103) AT=950.025n

.meas tran vdout1_104ck1890 FIND v(dout1_104) AT=950.025n

.meas tran vdout1_105ck1890 FIND v(dout1_105) AT=950.025n

.meas tran vdout1_106ck1890 FIND v(dout1_106) AT=950.025n

.meas tran vdout1_107ck1890 FIND v(dout1_107) AT=950.025n

.meas tran vdout1_108ck1890 FIND v(dout1_108) AT=950.025n

.meas tran vdout1_109ck1890 FIND v(dout1_109) AT=950.025n

.meas tran vdout1_110ck1890 FIND v(dout1_110) AT=950.025n

.meas tran vdout1_111ck1890 FIND v(dout1_111) AT=950.025n

.meas tran vdout1_112ck1890 FIND v(dout1_112) AT=950.025n

.meas tran vdout1_113ck1890 FIND v(dout1_113) AT=950.025n

.meas tran vdout1_114ck1890 FIND v(dout1_114) AT=950.025n

.meas tran vdout1_115ck1890 FIND v(dout1_115) AT=950.025n

.meas tran vdout1_116ck1890 FIND v(dout1_116) AT=950.025n

.meas tran vdout1_117ck1890 FIND v(dout1_117) AT=950.025n

.meas tran vdout1_118ck1890 FIND v(dout1_118) AT=950.025n

.meas tran vdout1_119ck1890 FIND v(dout1_119) AT=950.025n

.meas tran vdout1_120ck1890 FIND v(dout1_120) AT=950.025n

.meas tran vdout1_121ck1890 FIND v(dout1_121) AT=950.025n

.meas tran vdout1_122ck1890 FIND v(dout1_122) AT=950.025n

.meas tran vdout1_123ck1890 FIND v(dout1_123) AT=950.025n

.meas tran vdout1_124ck1890 FIND v(dout1_124) AT=950.025n

.meas tran vdout1_125ck1890 FIND v(dout1_125) AT=950.025n

.meas tran vdout1_126ck1890 FIND v(dout1_126) AT=950.025n

.meas tran vdout1_127ck1890 FIND v(dout1_127) AT=950.025n

.meas tran vdout1_0ck1940 FIND v(dout1_0) AT=975.025n

.meas tran vdout1_1ck1940 FIND v(dout1_1) AT=975.025n

.meas tran vdout1_2ck1940 FIND v(dout1_2) AT=975.025n

.meas tran vdout1_3ck1940 FIND v(dout1_3) AT=975.025n

.meas tran vdout1_4ck1940 FIND v(dout1_4) AT=975.025n

.meas tran vdout1_5ck1940 FIND v(dout1_5) AT=975.025n

.meas tran vdout1_6ck1940 FIND v(dout1_6) AT=975.025n

.meas tran vdout1_7ck1940 FIND v(dout1_7) AT=975.025n

.meas tran vdout1_8ck1940 FIND v(dout1_8) AT=975.025n

.meas tran vdout1_9ck1940 FIND v(dout1_9) AT=975.025n

.meas tran vdout1_10ck1940 FIND v(dout1_10) AT=975.025n

.meas tran vdout1_11ck1940 FIND v(dout1_11) AT=975.025n

.meas tran vdout1_12ck1940 FIND v(dout1_12) AT=975.025n

.meas tran vdout1_13ck1940 FIND v(dout1_13) AT=975.025n

.meas tran vdout1_14ck1940 FIND v(dout1_14) AT=975.025n

.meas tran vdout1_15ck1940 FIND v(dout1_15) AT=975.025n

.meas tran vdout1_16ck1940 FIND v(dout1_16) AT=975.025n

.meas tran vdout1_17ck1940 FIND v(dout1_17) AT=975.025n

.meas tran vdout1_18ck1940 FIND v(dout1_18) AT=975.025n

.meas tran vdout1_19ck1940 FIND v(dout1_19) AT=975.025n

.meas tran vdout1_20ck1940 FIND v(dout1_20) AT=975.025n

.meas tran vdout1_21ck1940 FIND v(dout1_21) AT=975.025n

.meas tran vdout1_22ck1940 FIND v(dout1_22) AT=975.025n

.meas tran vdout1_23ck1940 FIND v(dout1_23) AT=975.025n

.meas tran vdout1_24ck1940 FIND v(dout1_24) AT=975.025n

.meas tran vdout1_25ck1940 FIND v(dout1_25) AT=975.025n

.meas tran vdout1_26ck1940 FIND v(dout1_26) AT=975.025n

.meas tran vdout1_27ck1940 FIND v(dout1_27) AT=975.025n

.meas tran vdout1_28ck1940 FIND v(dout1_28) AT=975.025n

.meas tran vdout1_29ck1940 FIND v(dout1_29) AT=975.025n

.meas tran vdout1_30ck1940 FIND v(dout1_30) AT=975.025n

.meas tran vdout1_31ck1940 FIND v(dout1_31) AT=975.025n

.meas tran vdout1_32ck1940 FIND v(dout1_32) AT=975.025n

.meas tran vdout1_33ck1940 FIND v(dout1_33) AT=975.025n

.meas tran vdout1_34ck1940 FIND v(dout1_34) AT=975.025n

.meas tran vdout1_35ck1940 FIND v(dout1_35) AT=975.025n

.meas tran vdout1_36ck1940 FIND v(dout1_36) AT=975.025n

.meas tran vdout1_37ck1940 FIND v(dout1_37) AT=975.025n

.meas tran vdout1_38ck1940 FIND v(dout1_38) AT=975.025n

.meas tran vdout1_39ck1940 FIND v(dout1_39) AT=975.025n

.meas tran vdout1_40ck1940 FIND v(dout1_40) AT=975.025n

.meas tran vdout1_41ck1940 FIND v(dout1_41) AT=975.025n

.meas tran vdout1_42ck1940 FIND v(dout1_42) AT=975.025n

.meas tran vdout1_43ck1940 FIND v(dout1_43) AT=975.025n

.meas tran vdout1_44ck1940 FIND v(dout1_44) AT=975.025n

.meas tran vdout1_45ck1940 FIND v(dout1_45) AT=975.025n

.meas tran vdout1_46ck1940 FIND v(dout1_46) AT=975.025n

.meas tran vdout1_47ck1940 FIND v(dout1_47) AT=975.025n

.meas tran vdout1_48ck1940 FIND v(dout1_48) AT=975.025n

.meas tran vdout1_49ck1940 FIND v(dout1_49) AT=975.025n

.meas tran vdout1_50ck1940 FIND v(dout1_50) AT=975.025n

.meas tran vdout1_51ck1940 FIND v(dout1_51) AT=975.025n

.meas tran vdout1_52ck1940 FIND v(dout1_52) AT=975.025n

.meas tran vdout1_53ck1940 FIND v(dout1_53) AT=975.025n

.meas tran vdout1_54ck1940 FIND v(dout1_54) AT=975.025n

.meas tran vdout1_55ck1940 FIND v(dout1_55) AT=975.025n

.meas tran vdout1_56ck1940 FIND v(dout1_56) AT=975.025n

.meas tran vdout1_57ck1940 FIND v(dout1_57) AT=975.025n

.meas tran vdout1_58ck1940 FIND v(dout1_58) AT=975.025n

.meas tran vdout1_59ck1940 FIND v(dout1_59) AT=975.025n

.meas tran vdout1_60ck1940 FIND v(dout1_60) AT=975.025n

.meas tran vdout1_61ck1940 FIND v(dout1_61) AT=975.025n

.meas tran vdout1_62ck1940 FIND v(dout1_62) AT=975.025n

.meas tran vdout1_63ck1940 FIND v(dout1_63) AT=975.025n

.meas tran vdout1_64ck1940 FIND v(dout1_64) AT=975.025n

.meas tran vdout1_65ck1940 FIND v(dout1_65) AT=975.025n

.meas tran vdout1_66ck1940 FIND v(dout1_66) AT=975.025n

.meas tran vdout1_67ck1940 FIND v(dout1_67) AT=975.025n

.meas tran vdout1_68ck1940 FIND v(dout1_68) AT=975.025n

.meas tran vdout1_69ck1940 FIND v(dout1_69) AT=975.025n

.meas tran vdout1_70ck1940 FIND v(dout1_70) AT=975.025n

.meas tran vdout1_71ck1940 FIND v(dout1_71) AT=975.025n

.meas tran vdout1_72ck1940 FIND v(dout1_72) AT=975.025n

.meas tran vdout1_73ck1940 FIND v(dout1_73) AT=975.025n

.meas tran vdout1_74ck1940 FIND v(dout1_74) AT=975.025n

.meas tran vdout1_75ck1940 FIND v(dout1_75) AT=975.025n

.meas tran vdout1_76ck1940 FIND v(dout1_76) AT=975.025n

.meas tran vdout1_77ck1940 FIND v(dout1_77) AT=975.025n

.meas tran vdout1_78ck1940 FIND v(dout1_78) AT=975.025n

.meas tran vdout1_79ck1940 FIND v(dout1_79) AT=975.025n

.meas tran vdout1_80ck1940 FIND v(dout1_80) AT=975.025n

.meas tran vdout1_81ck1940 FIND v(dout1_81) AT=975.025n

.meas tran vdout1_82ck1940 FIND v(dout1_82) AT=975.025n

.meas tran vdout1_83ck1940 FIND v(dout1_83) AT=975.025n

.meas tran vdout1_84ck1940 FIND v(dout1_84) AT=975.025n

.meas tran vdout1_85ck1940 FIND v(dout1_85) AT=975.025n

.meas tran vdout1_86ck1940 FIND v(dout1_86) AT=975.025n

.meas tran vdout1_87ck1940 FIND v(dout1_87) AT=975.025n

.meas tran vdout1_88ck1940 FIND v(dout1_88) AT=975.025n

.meas tran vdout1_89ck1940 FIND v(dout1_89) AT=975.025n

.meas tran vdout1_90ck1940 FIND v(dout1_90) AT=975.025n

.meas tran vdout1_91ck1940 FIND v(dout1_91) AT=975.025n

.meas tran vdout1_92ck1940 FIND v(dout1_92) AT=975.025n

.meas tran vdout1_93ck1940 FIND v(dout1_93) AT=975.025n

.meas tran vdout1_94ck1940 FIND v(dout1_94) AT=975.025n

.meas tran vdout1_95ck1940 FIND v(dout1_95) AT=975.025n

.meas tran vdout1_96ck1940 FIND v(dout1_96) AT=975.025n

.meas tran vdout1_97ck1940 FIND v(dout1_97) AT=975.025n

.meas tran vdout1_98ck1940 FIND v(dout1_98) AT=975.025n

.meas tran vdout1_99ck1940 FIND v(dout1_99) AT=975.025n

.meas tran vdout1_100ck1940 FIND v(dout1_100) AT=975.025n

.meas tran vdout1_101ck1940 FIND v(dout1_101) AT=975.025n

.meas tran vdout1_102ck1940 FIND v(dout1_102) AT=975.025n

.meas tran vdout1_103ck1940 FIND v(dout1_103) AT=975.025n

.meas tran vdout1_104ck1940 FIND v(dout1_104) AT=975.025n

.meas tran vdout1_105ck1940 FIND v(dout1_105) AT=975.025n

.meas tran vdout1_106ck1940 FIND v(dout1_106) AT=975.025n

.meas tran vdout1_107ck1940 FIND v(dout1_107) AT=975.025n

.meas tran vdout1_108ck1940 FIND v(dout1_108) AT=975.025n

.meas tran vdout1_109ck1940 FIND v(dout1_109) AT=975.025n

.meas tran vdout1_110ck1940 FIND v(dout1_110) AT=975.025n

.meas tran vdout1_111ck1940 FIND v(dout1_111) AT=975.025n

.meas tran vdout1_112ck1940 FIND v(dout1_112) AT=975.025n

.meas tran vdout1_113ck1940 FIND v(dout1_113) AT=975.025n

.meas tran vdout1_114ck1940 FIND v(dout1_114) AT=975.025n

.meas tran vdout1_115ck1940 FIND v(dout1_115) AT=975.025n

.meas tran vdout1_116ck1940 FIND v(dout1_116) AT=975.025n

.meas tran vdout1_117ck1940 FIND v(dout1_117) AT=975.025n

.meas tran vdout1_118ck1940 FIND v(dout1_118) AT=975.025n

.meas tran vdout1_119ck1940 FIND v(dout1_119) AT=975.025n

.meas tran vdout1_120ck1940 FIND v(dout1_120) AT=975.025n

.meas tran vdout1_121ck1940 FIND v(dout1_121) AT=975.025n

.meas tran vdout1_122ck1940 FIND v(dout1_122) AT=975.025n

.meas tran vdout1_123ck1940 FIND v(dout1_123) AT=975.025n

.meas tran vdout1_124ck1940 FIND v(dout1_124) AT=975.025n

.meas tran vdout1_125ck1940 FIND v(dout1_125) AT=975.025n

.meas tran vdout1_126ck1940 FIND v(dout1_126) AT=975.025n

.meas tran vdout1_127ck1940 FIND v(dout1_127) AT=975.025n

.meas tran vdout1_0ck1950 FIND v(dout1_0) AT=980.025n

.meas tran vdout1_1ck1950 FIND v(dout1_1) AT=980.025n

.meas tran vdout1_2ck1950 FIND v(dout1_2) AT=980.025n

.meas tran vdout1_3ck1950 FIND v(dout1_3) AT=980.025n

.meas tran vdout1_4ck1950 FIND v(dout1_4) AT=980.025n

.meas tran vdout1_5ck1950 FIND v(dout1_5) AT=980.025n

.meas tran vdout1_6ck1950 FIND v(dout1_6) AT=980.025n

.meas tran vdout1_7ck1950 FIND v(dout1_7) AT=980.025n

.meas tran vdout1_8ck1950 FIND v(dout1_8) AT=980.025n

.meas tran vdout1_9ck1950 FIND v(dout1_9) AT=980.025n

.meas tran vdout1_10ck1950 FIND v(dout1_10) AT=980.025n

.meas tran vdout1_11ck1950 FIND v(dout1_11) AT=980.025n

.meas tran vdout1_12ck1950 FIND v(dout1_12) AT=980.025n

.meas tran vdout1_13ck1950 FIND v(dout1_13) AT=980.025n

.meas tran vdout1_14ck1950 FIND v(dout1_14) AT=980.025n

.meas tran vdout1_15ck1950 FIND v(dout1_15) AT=980.025n

.meas tran vdout1_16ck1950 FIND v(dout1_16) AT=980.025n

.meas tran vdout1_17ck1950 FIND v(dout1_17) AT=980.025n

.meas tran vdout1_18ck1950 FIND v(dout1_18) AT=980.025n

.meas tran vdout1_19ck1950 FIND v(dout1_19) AT=980.025n

.meas tran vdout1_20ck1950 FIND v(dout1_20) AT=980.025n

.meas tran vdout1_21ck1950 FIND v(dout1_21) AT=980.025n

.meas tran vdout1_22ck1950 FIND v(dout1_22) AT=980.025n

.meas tran vdout1_23ck1950 FIND v(dout1_23) AT=980.025n

.meas tran vdout1_24ck1950 FIND v(dout1_24) AT=980.025n

.meas tran vdout1_25ck1950 FIND v(dout1_25) AT=980.025n

.meas tran vdout1_26ck1950 FIND v(dout1_26) AT=980.025n

.meas tran vdout1_27ck1950 FIND v(dout1_27) AT=980.025n

.meas tran vdout1_28ck1950 FIND v(dout1_28) AT=980.025n

.meas tran vdout1_29ck1950 FIND v(dout1_29) AT=980.025n

.meas tran vdout1_30ck1950 FIND v(dout1_30) AT=980.025n

.meas tran vdout1_31ck1950 FIND v(dout1_31) AT=980.025n

.meas tran vdout1_32ck1950 FIND v(dout1_32) AT=980.025n

.meas tran vdout1_33ck1950 FIND v(dout1_33) AT=980.025n

.meas tran vdout1_34ck1950 FIND v(dout1_34) AT=980.025n

.meas tran vdout1_35ck1950 FIND v(dout1_35) AT=980.025n

.meas tran vdout1_36ck1950 FIND v(dout1_36) AT=980.025n

.meas tran vdout1_37ck1950 FIND v(dout1_37) AT=980.025n

.meas tran vdout1_38ck1950 FIND v(dout1_38) AT=980.025n

.meas tran vdout1_39ck1950 FIND v(dout1_39) AT=980.025n

.meas tran vdout1_40ck1950 FIND v(dout1_40) AT=980.025n

.meas tran vdout1_41ck1950 FIND v(dout1_41) AT=980.025n

.meas tran vdout1_42ck1950 FIND v(dout1_42) AT=980.025n

.meas tran vdout1_43ck1950 FIND v(dout1_43) AT=980.025n

.meas tran vdout1_44ck1950 FIND v(dout1_44) AT=980.025n

.meas tran vdout1_45ck1950 FIND v(dout1_45) AT=980.025n

.meas tran vdout1_46ck1950 FIND v(dout1_46) AT=980.025n

.meas tran vdout1_47ck1950 FIND v(dout1_47) AT=980.025n

.meas tran vdout1_48ck1950 FIND v(dout1_48) AT=980.025n

.meas tran vdout1_49ck1950 FIND v(dout1_49) AT=980.025n

.meas tran vdout1_50ck1950 FIND v(dout1_50) AT=980.025n

.meas tran vdout1_51ck1950 FIND v(dout1_51) AT=980.025n

.meas tran vdout1_52ck1950 FIND v(dout1_52) AT=980.025n

.meas tran vdout1_53ck1950 FIND v(dout1_53) AT=980.025n

.meas tran vdout1_54ck1950 FIND v(dout1_54) AT=980.025n

.meas tran vdout1_55ck1950 FIND v(dout1_55) AT=980.025n

.meas tran vdout1_56ck1950 FIND v(dout1_56) AT=980.025n

.meas tran vdout1_57ck1950 FIND v(dout1_57) AT=980.025n

.meas tran vdout1_58ck1950 FIND v(dout1_58) AT=980.025n

.meas tran vdout1_59ck1950 FIND v(dout1_59) AT=980.025n

.meas tran vdout1_60ck1950 FIND v(dout1_60) AT=980.025n

.meas tran vdout1_61ck1950 FIND v(dout1_61) AT=980.025n

.meas tran vdout1_62ck1950 FIND v(dout1_62) AT=980.025n

.meas tran vdout1_63ck1950 FIND v(dout1_63) AT=980.025n

.meas tran vdout1_64ck1950 FIND v(dout1_64) AT=980.025n

.meas tran vdout1_65ck1950 FIND v(dout1_65) AT=980.025n

.meas tran vdout1_66ck1950 FIND v(dout1_66) AT=980.025n

.meas tran vdout1_67ck1950 FIND v(dout1_67) AT=980.025n

.meas tran vdout1_68ck1950 FIND v(dout1_68) AT=980.025n

.meas tran vdout1_69ck1950 FIND v(dout1_69) AT=980.025n

.meas tran vdout1_70ck1950 FIND v(dout1_70) AT=980.025n

.meas tran vdout1_71ck1950 FIND v(dout1_71) AT=980.025n

.meas tran vdout1_72ck1950 FIND v(dout1_72) AT=980.025n

.meas tran vdout1_73ck1950 FIND v(dout1_73) AT=980.025n

.meas tran vdout1_74ck1950 FIND v(dout1_74) AT=980.025n

.meas tran vdout1_75ck1950 FIND v(dout1_75) AT=980.025n

.meas tran vdout1_76ck1950 FIND v(dout1_76) AT=980.025n

.meas tran vdout1_77ck1950 FIND v(dout1_77) AT=980.025n

.meas tran vdout1_78ck1950 FIND v(dout1_78) AT=980.025n

.meas tran vdout1_79ck1950 FIND v(dout1_79) AT=980.025n

.meas tran vdout1_80ck1950 FIND v(dout1_80) AT=980.025n

.meas tran vdout1_81ck1950 FIND v(dout1_81) AT=980.025n

.meas tran vdout1_82ck1950 FIND v(dout1_82) AT=980.025n

.meas tran vdout1_83ck1950 FIND v(dout1_83) AT=980.025n

.meas tran vdout1_84ck1950 FIND v(dout1_84) AT=980.025n

.meas tran vdout1_85ck1950 FIND v(dout1_85) AT=980.025n

.meas tran vdout1_86ck1950 FIND v(dout1_86) AT=980.025n

.meas tran vdout1_87ck1950 FIND v(dout1_87) AT=980.025n

.meas tran vdout1_88ck1950 FIND v(dout1_88) AT=980.025n

.meas tran vdout1_89ck1950 FIND v(dout1_89) AT=980.025n

.meas tran vdout1_90ck1950 FIND v(dout1_90) AT=980.025n

.meas tran vdout1_91ck1950 FIND v(dout1_91) AT=980.025n

.meas tran vdout1_92ck1950 FIND v(dout1_92) AT=980.025n

.meas tran vdout1_93ck1950 FIND v(dout1_93) AT=980.025n

.meas tran vdout1_94ck1950 FIND v(dout1_94) AT=980.025n

.meas tran vdout1_95ck1950 FIND v(dout1_95) AT=980.025n

.meas tran vdout1_96ck1950 FIND v(dout1_96) AT=980.025n

.meas tran vdout1_97ck1950 FIND v(dout1_97) AT=980.025n

.meas tran vdout1_98ck1950 FIND v(dout1_98) AT=980.025n

.meas tran vdout1_99ck1950 FIND v(dout1_99) AT=980.025n

.meas tran vdout1_100ck1950 FIND v(dout1_100) AT=980.025n

.meas tran vdout1_101ck1950 FIND v(dout1_101) AT=980.025n

.meas tran vdout1_102ck1950 FIND v(dout1_102) AT=980.025n

.meas tran vdout1_103ck1950 FIND v(dout1_103) AT=980.025n

.meas tran vdout1_104ck1950 FIND v(dout1_104) AT=980.025n

.meas tran vdout1_105ck1950 FIND v(dout1_105) AT=980.025n

.meas tran vdout1_106ck1950 FIND v(dout1_106) AT=980.025n

.meas tran vdout1_107ck1950 FIND v(dout1_107) AT=980.025n

.meas tran vdout1_108ck1950 FIND v(dout1_108) AT=980.025n

.meas tran vdout1_109ck1950 FIND v(dout1_109) AT=980.025n

.meas tran vdout1_110ck1950 FIND v(dout1_110) AT=980.025n

.meas tran vdout1_111ck1950 FIND v(dout1_111) AT=980.025n

.meas tran vdout1_112ck1950 FIND v(dout1_112) AT=980.025n

.meas tran vdout1_113ck1950 FIND v(dout1_113) AT=980.025n

.meas tran vdout1_114ck1950 FIND v(dout1_114) AT=980.025n

.meas tran vdout1_115ck1950 FIND v(dout1_115) AT=980.025n

.meas tran vdout1_116ck1950 FIND v(dout1_116) AT=980.025n

.meas tran vdout1_117ck1950 FIND v(dout1_117) AT=980.025n

.meas tran vdout1_118ck1950 FIND v(dout1_118) AT=980.025n

.meas tran vdout1_119ck1950 FIND v(dout1_119) AT=980.025n

.meas tran vdout1_120ck1950 FIND v(dout1_120) AT=980.025n

.meas tran vdout1_121ck1950 FIND v(dout1_121) AT=980.025n

.meas tran vdout1_122ck1950 FIND v(dout1_122) AT=980.025n

.meas tran vdout1_123ck1950 FIND v(dout1_123) AT=980.025n

.meas tran vdout1_124ck1950 FIND v(dout1_124) AT=980.025n

.meas tran vdout1_125ck1950 FIND v(dout1_125) AT=980.025n

.meas tran vdout1_126ck1950 FIND v(dout1_126) AT=980.025n

.meas tran vdout1_127ck1950 FIND v(dout1_127) AT=980.025n

.meas tran vdout1_0ck1990 FIND v(dout1_0) AT=1000.025n

.meas tran vdout1_1ck1990 FIND v(dout1_1) AT=1000.025n

.meas tran vdout1_2ck1990 FIND v(dout1_2) AT=1000.025n

.meas tran vdout1_3ck1990 FIND v(dout1_3) AT=1000.025n

.meas tran vdout1_4ck1990 FIND v(dout1_4) AT=1000.025n

.meas tran vdout1_5ck1990 FIND v(dout1_5) AT=1000.025n

.meas tran vdout1_6ck1990 FIND v(dout1_6) AT=1000.025n

.meas tran vdout1_7ck1990 FIND v(dout1_7) AT=1000.025n

.meas tran vdout1_8ck1990 FIND v(dout1_8) AT=1000.025n

.meas tran vdout1_9ck1990 FIND v(dout1_9) AT=1000.025n

.meas tran vdout1_10ck1990 FIND v(dout1_10) AT=1000.025n

.meas tran vdout1_11ck1990 FIND v(dout1_11) AT=1000.025n

.meas tran vdout1_12ck1990 FIND v(dout1_12) AT=1000.025n

.meas tran vdout1_13ck1990 FIND v(dout1_13) AT=1000.025n

.meas tran vdout1_14ck1990 FIND v(dout1_14) AT=1000.025n

.meas tran vdout1_15ck1990 FIND v(dout1_15) AT=1000.025n

.meas tran vdout1_16ck1990 FIND v(dout1_16) AT=1000.025n

.meas tran vdout1_17ck1990 FIND v(dout1_17) AT=1000.025n

.meas tran vdout1_18ck1990 FIND v(dout1_18) AT=1000.025n

.meas tran vdout1_19ck1990 FIND v(dout1_19) AT=1000.025n

.meas tran vdout1_20ck1990 FIND v(dout1_20) AT=1000.025n

.meas tran vdout1_21ck1990 FIND v(dout1_21) AT=1000.025n

.meas tran vdout1_22ck1990 FIND v(dout1_22) AT=1000.025n

.meas tran vdout1_23ck1990 FIND v(dout1_23) AT=1000.025n

.meas tran vdout1_24ck1990 FIND v(dout1_24) AT=1000.025n

.meas tran vdout1_25ck1990 FIND v(dout1_25) AT=1000.025n

.meas tran vdout1_26ck1990 FIND v(dout1_26) AT=1000.025n

.meas tran vdout1_27ck1990 FIND v(dout1_27) AT=1000.025n

.meas tran vdout1_28ck1990 FIND v(dout1_28) AT=1000.025n

.meas tran vdout1_29ck1990 FIND v(dout1_29) AT=1000.025n

.meas tran vdout1_30ck1990 FIND v(dout1_30) AT=1000.025n

.meas tran vdout1_31ck1990 FIND v(dout1_31) AT=1000.025n

.meas tran vdout1_32ck1990 FIND v(dout1_32) AT=1000.025n

.meas tran vdout1_33ck1990 FIND v(dout1_33) AT=1000.025n

.meas tran vdout1_34ck1990 FIND v(dout1_34) AT=1000.025n

.meas tran vdout1_35ck1990 FIND v(dout1_35) AT=1000.025n

.meas tran vdout1_36ck1990 FIND v(dout1_36) AT=1000.025n

.meas tran vdout1_37ck1990 FIND v(dout1_37) AT=1000.025n

.meas tran vdout1_38ck1990 FIND v(dout1_38) AT=1000.025n

.meas tran vdout1_39ck1990 FIND v(dout1_39) AT=1000.025n

.meas tran vdout1_40ck1990 FIND v(dout1_40) AT=1000.025n

.meas tran vdout1_41ck1990 FIND v(dout1_41) AT=1000.025n

.meas tran vdout1_42ck1990 FIND v(dout1_42) AT=1000.025n

.meas tran vdout1_43ck1990 FIND v(dout1_43) AT=1000.025n

.meas tran vdout1_44ck1990 FIND v(dout1_44) AT=1000.025n

.meas tran vdout1_45ck1990 FIND v(dout1_45) AT=1000.025n

.meas tran vdout1_46ck1990 FIND v(dout1_46) AT=1000.025n

.meas tran vdout1_47ck1990 FIND v(dout1_47) AT=1000.025n

.meas tran vdout1_48ck1990 FIND v(dout1_48) AT=1000.025n

.meas tran vdout1_49ck1990 FIND v(dout1_49) AT=1000.025n

.meas tran vdout1_50ck1990 FIND v(dout1_50) AT=1000.025n

.meas tran vdout1_51ck1990 FIND v(dout1_51) AT=1000.025n

.meas tran vdout1_52ck1990 FIND v(dout1_52) AT=1000.025n

.meas tran vdout1_53ck1990 FIND v(dout1_53) AT=1000.025n

.meas tran vdout1_54ck1990 FIND v(dout1_54) AT=1000.025n

.meas tran vdout1_55ck1990 FIND v(dout1_55) AT=1000.025n

.meas tran vdout1_56ck1990 FIND v(dout1_56) AT=1000.025n

.meas tran vdout1_57ck1990 FIND v(dout1_57) AT=1000.025n

.meas tran vdout1_58ck1990 FIND v(dout1_58) AT=1000.025n

.meas tran vdout1_59ck1990 FIND v(dout1_59) AT=1000.025n

.meas tran vdout1_60ck1990 FIND v(dout1_60) AT=1000.025n

.meas tran vdout1_61ck1990 FIND v(dout1_61) AT=1000.025n

.meas tran vdout1_62ck1990 FIND v(dout1_62) AT=1000.025n

.meas tran vdout1_63ck1990 FIND v(dout1_63) AT=1000.025n

.meas tran vdout1_64ck1990 FIND v(dout1_64) AT=1000.025n

.meas tran vdout1_65ck1990 FIND v(dout1_65) AT=1000.025n

.meas tran vdout1_66ck1990 FIND v(dout1_66) AT=1000.025n

.meas tran vdout1_67ck1990 FIND v(dout1_67) AT=1000.025n

.meas tran vdout1_68ck1990 FIND v(dout1_68) AT=1000.025n

.meas tran vdout1_69ck1990 FIND v(dout1_69) AT=1000.025n

.meas tran vdout1_70ck1990 FIND v(dout1_70) AT=1000.025n

.meas tran vdout1_71ck1990 FIND v(dout1_71) AT=1000.025n

.meas tran vdout1_72ck1990 FIND v(dout1_72) AT=1000.025n

.meas tran vdout1_73ck1990 FIND v(dout1_73) AT=1000.025n

.meas tran vdout1_74ck1990 FIND v(dout1_74) AT=1000.025n

.meas tran vdout1_75ck1990 FIND v(dout1_75) AT=1000.025n

.meas tran vdout1_76ck1990 FIND v(dout1_76) AT=1000.025n

.meas tran vdout1_77ck1990 FIND v(dout1_77) AT=1000.025n

.meas tran vdout1_78ck1990 FIND v(dout1_78) AT=1000.025n

.meas tran vdout1_79ck1990 FIND v(dout1_79) AT=1000.025n

.meas tran vdout1_80ck1990 FIND v(dout1_80) AT=1000.025n

.meas tran vdout1_81ck1990 FIND v(dout1_81) AT=1000.025n

.meas tran vdout1_82ck1990 FIND v(dout1_82) AT=1000.025n

.meas tran vdout1_83ck1990 FIND v(dout1_83) AT=1000.025n

.meas tran vdout1_84ck1990 FIND v(dout1_84) AT=1000.025n

.meas tran vdout1_85ck1990 FIND v(dout1_85) AT=1000.025n

.meas tran vdout1_86ck1990 FIND v(dout1_86) AT=1000.025n

.meas tran vdout1_87ck1990 FIND v(dout1_87) AT=1000.025n

.meas tran vdout1_88ck1990 FIND v(dout1_88) AT=1000.025n

.meas tran vdout1_89ck1990 FIND v(dout1_89) AT=1000.025n

.meas tran vdout1_90ck1990 FIND v(dout1_90) AT=1000.025n

.meas tran vdout1_91ck1990 FIND v(dout1_91) AT=1000.025n

.meas tran vdout1_92ck1990 FIND v(dout1_92) AT=1000.025n

.meas tran vdout1_93ck1990 FIND v(dout1_93) AT=1000.025n

.meas tran vdout1_94ck1990 FIND v(dout1_94) AT=1000.025n

.meas tran vdout1_95ck1990 FIND v(dout1_95) AT=1000.025n

.meas tran vdout1_96ck1990 FIND v(dout1_96) AT=1000.025n

.meas tran vdout1_97ck1990 FIND v(dout1_97) AT=1000.025n

.meas tran vdout1_98ck1990 FIND v(dout1_98) AT=1000.025n

.meas tran vdout1_99ck1990 FIND v(dout1_99) AT=1000.025n

.meas tran vdout1_100ck1990 FIND v(dout1_100) AT=1000.025n

.meas tran vdout1_101ck1990 FIND v(dout1_101) AT=1000.025n

.meas tran vdout1_102ck1990 FIND v(dout1_102) AT=1000.025n

.meas tran vdout1_103ck1990 FIND v(dout1_103) AT=1000.025n

.meas tran vdout1_104ck1990 FIND v(dout1_104) AT=1000.025n

.meas tran vdout1_105ck1990 FIND v(dout1_105) AT=1000.025n

.meas tran vdout1_106ck1990 FIND v(dout1_106) AT=1000.025n

.meas tran vdout1_107ck1990 FIND v(dout1_107) AT=1000.025n

.meas tran vdout1_108ck1990 FIND v(dout1_108) AT=1000.025n

.meas tran vdout1_109ck1990 FIND v(dout1_109) AT=1000.025n

.meas tran vdout1_110ck1990 FIND v(dout1_110) AT=1000.025n

.meas tran vdout1_111ck1990 FIND v(dout1_111) AT=1000.025n

.meas tran vdout1_112ck1990 FIND v(dout1_112) AT=1000.025n

.meas tran vdout1_113ck1990 FIND v(dout1_113) AT=1000.025n

.meas tran vdout1_114ck1990 FIND v(dout1_114) AT=1000.025n

.meas tran vdout1_115ck1990 FIND v(dout1_115) AT=1000.025n

.meas tran vdout1_116ck1990 FIND v(dout1_116) AT=1000.025n

.meas tran vdout1_117ck1990 FIND v(dout1_117) AT=1000.025n

.meas tran vdout1_118ck1990 FIND v(dout1_118) AT=1000.025n

.meas tran vdout1_119ck1990 FIND v(dout1_119) AT=1000.025n

.meas tran vdout1_120ck1990 FIND v(dout1_120) AT=1000.025n

.meas tran vdout1_121ck1990 FIND v(dout1_121) AT=1000.025n

.meas tran vdout1_122ck1990 FIND v(dout1_122) AT=1000.025n

.meas tran vdout1_123ck1990 FIND v(dout1_123) AT=1000.025n

.meas tran vdout1_124ck1990 FIND v(dout1_124) AT=1000.025n

.meas tran vdout1_125ck1990 FIND v(dout1_125) AT=1000.025n

.meas tran vdout1_126ck1990 FIND v(dout1_126) AT=1000.025n

.meas tran vdout1_127ck1990 FIND v(dout1_127) AT=1000.025n
