.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_16ck40 FIND v(dout1_16) AT=25.025n

.meas tran vdout1_0ck80 FIND v(dout1_0) AT=45.025n

.meas tran vdout1_1ck80 FIND v(dout1_1) AT=45.025n

.meas tran vdout1_2ck80 FIND v(dout1_2) AT=45.025n

.meas tran vdout1_3ck80 FIND v(dout1_3) AT=45.025n

.meas tran vdout1_4ck80 FIND v(dout1_4) AT=45.025n

.meas tran vdout1_5ck80 FIND v(dout1_5) AT=45.025n

.meas tran vdout1_6ck80 FIND v(dout1_6) AT=45.025n

.meas tran vdout1_7ck80 FIND v(dout1_7) AT=45.025n

.meas tran vdout1_8ck80 FIND v(dout1_8) AT=45.025n

.meas tran vdout1_9ck80 FIND v(dout1_9) AT=45.025n

.meas tran vdout1_10ck80 FIND v(dout1_10) AT=45.025n

.meas tran vdout1_11ck80 FIND v(dout1_11) AT=45.025n

.meas tran vdout1_12ck80 FIND v(dout1_12) AT=45.025n

.meas tran vdout1_13ck80 FIND v(dout1_13) AT=45.025n

.meas tran vdout1_14ck80 FIND v(dout1_14) AT=45.025n

.meas tran vdout1_15ck80 FIND v(dout1_15) AT=45.025n

.meas tran vdout1_16ck80 FIND v(dout1_16) AT=45.025n

.meas tran vdout1_0ck90 FIND v(dout1_0) AT=50.025n

.meas tran vdout1_1ck90 FIND v(dout1_1) AT=50.025n

.meas tran vdout1_2ck90 FIND v(dout1_2) AT=50.025n

.meas tran vdout1_3ck90 FIND v(dout1_3) AT=50.025n

.meas tran vdout1_4ck90 FIND v(dout1_4) AT=50.025n

.meas tran vdout1_5ck90 FIND v(dout1_5) AT=50.025n

.meas tran vdout1_6ck90 FIND v(dout1_6) AT=50.025n

.meas tran vdout1_7ck90 FIND v(dout1_7) AT=50.025n

.meas tran vdout1_8ck90 FIND v(dout1_8) AT=50.025n

.meas tran vdout1_9ck90 FIND v(dout1_9) AT=50.025n

.meas tran vdout1_10ck90 FIND v(dout1_10) AT=50.025n

.meas tran vdout1_11ck90 FIND v(dout1_11) AT=50.025n

.meas tran vdout1_12ck90 FIND v(dout1_12) AT=50.025n

.meas tran vdout1_13ck90 FIND v(dout1_13) AT=50.025n

.meas tran vdout1_14ck90 FIND v(dout1_14) AT=50.025n

.meas tran vdout1_15ck90 FIND v(dout1_15) AT=50.025n

.meas tran vdout1_16ck90 FIND v(dout1_16) AT=50.025n

.meas tran vdout1_0ck100 FIND v(dout1_0) AT=55.025n

.meas tran vdout1_1ck100 FIND v(dout1_1) AT=55.025n

.meas tran vdout1_2ck100 FIND v(dout1_2) AT=55.025n

.meas tran vdout1_3ck100 FIND v(dout1_3) AT=55.025n

.meas tran vdout1_4ck100 FIND v(dout1_4) AT=55.025n

.meas tran vdout1_5ck100 FIND v(dout1_5) AT=55.025n

.meas tran vdout1_6ck100 FIND v(dout1_6) AT=55.025n

.meas tran vdout1_7ck100 FIND v(dout1_7) AT=55.025n

.meas tran vdout1_8ck100 FIND v(dout1_8) AT=55.025n

.meas tran vdout1_9ck100 FIND v(dout1_9) AT=55.025n

.meas tran vdout1_10ck100 FIND v(dout1_10) AT=55.025n

.meas tran vdout1_11ck100 FIND v(dout1_11) AT=55.025n

.meas tran vdout1_12ck100 FIND v(dout1_12) AT=55.025n

.meas tran vdout1_13ck100 FIND v(dout1_13) AT=55.025n

.meas tran vdout1_14ck100 FIND v(dout1_14) AT=55.025n

.meas tran vdout1_15ck100 FIND v(dout1_15) AT=55.025n

.meas tran vdout1_16ck100 FIND v(dout1_16) AT=55.025n

.meas tran vdout1_0ck110 FIND v(dout1_0) AT=60.025n

.meas tran vdout1_1ck110 FIND v(dout1_1) AT=60.025n

.meas tran vdout1_2ck110 FIND v(dout1_2) AT=60.025n

.meas tran vdout1_3ck110 FIND v(dout1_3) AT=60.025n

.meas tran vdout1_4ck110 FIND v(dout1_4) AT=60.025n

.meas tran vdout1_5ck110 FIND v(dout1_5) AT=60.025n

.meas tran vdout1_6ck110 FIND v(dout1_6) AT=60.025n

.meas tran vdout1_7ck110 FIND v(dout1_7) AT=60.025n

.meas tran vdout1_8ck110 FIND v(dout1_8) AT=60.025n

.meas tran vdout1_9ck110 FIND v(dout1_9) AT=60.025n

.meas tran vdout1_10ck110 FIND v(dout1_10) AT=60.025n

.meas tran vdout1_11ck110 FIND v(dout1_11) AT=60.025n

.meas tran vdout1_12ck110 FIND v(dout1_12) AT=60.025n

.meas tran vdout1_13ck110 FIND v(dout1_13) AT=60.025n

.meas tran vdout1_14ck110 FIND v(dout1_14) AT=60.025n

.meas tran vdout1_15ck110 FIND v(dout1_15) AT=60.025n

.meas tran vdout1_16ck110 FIND v(dout1_16) AT=60.025n

.meas tran vdout1_0ck130 FIND v(dout1_0) AT=70.025n

.meas tran vdout1_1ck130 FIND v(dout1_1) AT=70.025n

.meas tran vdout1_2ck130 FIND v(dout1_2) AT=70.025n

.meas tran vdout1_3ck130 FIND v(dout1_3) AT=70.025n

.meas tran vdout1_4ck130 FIND v(dout1_4) AT=70.025n

.meas tran vdout1_5ck130 FIND v(dout1_5) AT=70.025n

.meas tran vdout1_6ck130 FIND v(dout1_6) AT=70.025n

.meas tran vdout1_7ck130 FIND v(dout1_7) AT=70.025n

.meas tran vdout1_8ck130 FIND v(dout1_8) AT=70.025n

.meas tran vdout1_9ck130 FIND v(dout1_9) AT=70.025n

.meas tran vdout1_10ck130 FIND v(dout1_10) AT=70.025n

.meas tran vdout1_11ck130 FIND v(dout1_11) AT=70.025n

.meas tran vdout1_12ck130 FIND v(dout1_12) AT=70.025n

.meas tran vdout1_13ck130 FIND v(dout1_13) AT=70.025n

.meas tran vdout1_14ck130 FIND v(dout1_14) AT=70.025n

.meas tran vdout1_15ck130 FIND v(dout1_15) AT=70.025n

.meas tran vdout1_16ck130 FIND v(dout1_16) AT=70.025n

.meas tran vdout1_0ck140 FIND v(dout1_0) AT=75.025n

.meas tran vdout1_1ck140 FIND v(dout1_1) AT=75.025n

.meas tran vdout1_2ck140 FIND v(dout1_2) AT=75.025n

.meas tran vdout1_3ck140 FIND v(dout1_3) AT=75.025n

.meas tran vdout1_4ck140 FIND v(dout1_4) AT=75.025n

.meas tran vdout1_5ck140 FIND v(dout1_5) AT=75.025n

.meas tran vdout1_6ck140 FIND v(dout1_6) AT=75.025n

.meas tran vdout1_7ck140 FIND v(dout1_7) AT=75.025n

.meas tran vdout1_8ck140 FIND v(dout1_8) AT=75.025n

.meas tran vdout1_9ck140 FIND v(dout1_9) AT=75.025n

.meas tran vdout1_10ck140 FIND v(dout1_10) AT=75.025n

.meas tran vdout1_11ck140 FIND v(dout1_11) AT=75.025n

.meas tran vdout1_12ck140 FIND v(dout1_12) AT=75.025n

.meas tran vdout1_13ck140 FIND v(dout1_13) AT=75.025n

.meas tran vdout1_14ck140 FIND v(dout1_14) AT=75.025n

.meas tran vdout1_15ck140 FIND v(dout1_15) AT=75.025n

.meas tran vdout1_16ck140 FIND v(dout1_16) AT=75.025n

.meas tran vdout1_0ck150 FIND v(dout1_0) AT=80.025n

.meas tran vdout1_1ck150 FIND v(dout1_1) AT=80.025n

.meas tran vdout1_2ck150 FIND v(dout1_2) AT=80.025n

.meas tran vdout1_3ck150 FIND v(dout1_3) AT=80.025n

.meas tran vdout1_4ck150 FIND v(dout1_4) AT=80.025n

.meas tran vdout1_5ck150 FIND v(dout1_5) AT=80.025n

.meas tran vdout1_6ck150 FIND v(dout1_6) AT=80.025n

.meas tran vdout1_7ck150 FIND v(dout1_7) AT=80.025n

.meas tran vdout1_8ck150 FIND v(dout1_8) AT=80.025n

.meas tran vdout1_9ck150 FIND v(dout1_9) AT=80.025n

.meas tran vdout1_10ck150 FIND v(dout1_10) AT=80.025n

.meas tran vdout1_11ck150 FIND v(dout1_11) AT=80.025n

.meas tran vdout1_12ck150 FIND v(dout1_12) AT=80.025n

.meas tran vdout1_13ck150 FIND v(dout1_13) AT=80.025n

.meas tran vdout1_14ck150 FIND v(dout1_14) AT=80.025n

.meas tran vdout1_15ck150 FIND v(dout1_15) AT=80.025n

.meas tran vdout1_16ck150 FIND v(dout1_16) AT=80.025n

.meas tran vdout1_0ck160 FIND v(dout1_0) AT=85.025n

.meas tran vdout1_1ck160 FIND v(dout1_1) AT=85.025n

.meas tran vdout1_2ck160 FIND v(dout1_2) AT=85.025n

.meas tran vdout1_3ck160 FIND v(dout1_3) AT=85.025n

.meas tran vdout1_4ck160 FIND v(dout1_4) AT=85.025n

.meas tran vdout1_5ck160 FIND v(dout1_5) AT=85.025n

.meas tran vdout1_6ck160 FIND v(dout1_6) AT=85.025n

.meas tran vdout1_7ck160 FIND v(dout1_7) AT=85.025n

.meas tran vdout1_8ck160 FIND v(dout1_8) AT=85.025n

.meas tran vdout1_9ck160 FIND v(dout1_9) AT=85.025n

.meas tran vdout1_10ck160 FIND v(dout1_10) AT=85.025n

.meas tran vdout1_11ck160 FIND v(dout1_11) AT=85.025n

.meas tran vdout1_12ck160 FIND v(dout1_12) AT=85.025n

.meas tran vdout1_13ck160 FIND v(dout1_13) AT=85.025n

.meas tran vdout1_14ck160 FIND v(dout1_14) AT=85.025n

.meas tran vdout1_15ck160 FIND v(dout1_15) AT=85.025n

.meas tran vdout1_16ck160 FIND v(dout1_16) AT=85.025n

.meas tran vdout1_0ck170 FIND v(dout1_0) AT=90.025n

.meas tran vdout1_1ck170 FIND v(dout1_1) AT=90.025n

.meas tran vdout1_2ck170 FIND v(dout1_2) AT=90.025n

.meas tran vdout1_3ck170 FIND v(dout1_3) AT=90.025n

.meas tran vdout1_4ck170 FIND v(dout1_4) AT=90.025n

.meas tran vdout1_5ck170 FIND v(dout1_5) AT=90.025n

.meas tran vdout1_6ck170 FIND v(dout1_6) AT=90.025n

.meas tran vdout1_7ck170 FIND v(dout1_7) AT=90.025n

.meas tran vdout1_8ck170 FIND v(dout1_8) AT=90.025n

.meas tran vdout1_9ck170 FIND v(dout1_9) AT=90.025n

.meas tran vdout1_10ck170 FIND v(dout1_10) AT=90.025n

.meas tran vdout1_11ck170 FIND v(dout1_11) AT=90.025n

.meas tran vdout1_12ck170 FIND v(dout1_12) AT=90.025n

.meas tran vdout1_13ck170 FIND v(dout1_13) AT=90.025n

.meas tran vdout1_14ck170 FIND v(dout1_14) AT=90.025n

.meas tran vdout1_15ck170 FIND v(dout1_15) AT=90.025n

.meas tran vdout1_16ck170 FIND v(dout1_16) AT=90.025n

.meas tran vdout1_0ck180 FIND v(dout1_0) AT=95.025n

.meas tran vdout1_1ck180 FIND v(dout1_1) AT=95.025n

.meas tran vdout1_2ck180 FIND v(dout1_2) AT=95.025n

.meas tran vdout1_3ck180 FIND v(dout1_3) AT=95.025n

.meas tran vdout1_4ck180 FIND v(dout1_4) AT=95.025n

.meas tran vdout1_5ck180 FIND v(dout1_5) AT=95.025n

.meas tran vdout1_6ck180 FIND v(dout1_6) AT=95.025n

.meas tran vdout1_7ck180 FIND v(dout1_7) AT=95.025n

.meas tran vdout1_8ck180 FIND v(dout1_8) AT=95.025n

.meas tran vdout1_9ck180 FIND v(dout1_9) AT=95.025n

.meas tran vdout1_10ck180 FIND v(dout1_10) AT=95.025n

.meas tran vdout1_11ck180 FIND v(dout1_11) AT=95.025n

.meas tran vdout1_12ck180 FIND v(dout1_12) AT=95.025n

.meas tran vdout1_13ck180 FIND v(dout1_13) AT=95.025n

.meas tran vdout1_14ck180 FIND v(dout1_14) AT=95.025n

.meas tran vdout1_15ck180 FIND v(dout1_15) AT=95.025n

.meas tran vdout1_16ck180 FIND v(dout1_16) AT=95.025n

.meas tran vdout1_0ck190 FIND v(dout1_0) AT=100.025n

.meas tran vdout1_1ck190 FIND v(dout1_1) AT=100.025n

.meas tran vdout1_2ck190 FIND v(dout1_2) AT=100.025n

.meas tran vdout1_3ck190 FIND v(dout1_3) AT=100.025n

.meas tran vdout1_4ck190 FIND v(dout1_4) AT=100.025n

.meas tran vdout1_5ck190 FIND v(dout1_5) AT=100.025n

.meas tran vdout1_6ck190 FIND v(dout1_6) AT=100.025n

.meas tran vdout1_7ck190 FIND v(dout1_7) AT=100.025n

.meas tran vdout1_8ck190 FIND v(dout1_8) AT=100.025n

.meas tran vdout1_9ck190 FIND v(dout1_9) AT=100.025n

.meas tran vdout1_10ck190 FIND v(dout1_10) AT=100.025n

.meas tran vdout1_11ck190 FIND v(dout1_11) AT=100.025n

.meas tran vdout1_12ck190 FIND v(dout1_12) AT=100.025n

.meas tran vdout1_13ck190 FIND v(dout1_13) AT=100.025n

.meas tran vdout1_14ck190 FIND v(dout1_14) AT=100.025n

.meas tran vdout1_15ck190 FIND v(dout1_15) AT=100.025n

.meas tran vdout1_16ck190 FIND v(dout1_16) AT=100.025n

.meas tran vdout1_0ck230 FIND v(dout1_0) AT=120.025n

.meas tran vdout1_1ck230 FIND v(dout1_1) AT=120.025n

.meas tran vdout1_2ck230 FIND v(dout1_2) AT=120.025n

.meas tran vdout1_3ck230 FIND v(dout1_3) AT=120.025n

.meas tran vdout1_4ck230 FIND v(dout1_4) AT=120.025n

.meas tran vdout1_5ck230 FIND v(dout1_5) AT=120.025n

.meas tran vdout1_6ck230 FIND v(dout1_6) AT=120.025n

.meas tran vdout1_7ck230 FIND v(dout1_7) AT=120.025n

.meas tran vdout1_8ck230 FIND v(dout1_8) AT=120.025n

.meas tran vdout1_9ck230 FIND v(dout1_9) AT=120.025n

.meas tran vdout1_10ck230 FIND v(dout1_10) AT=120.025n

.meas tran vdout1_11ck230 FIND v(dout1_11) AT=120.025n

.meas tran vdout1_12ck230 FIND v(dout1_12) AT=120.025n

.meas tran vdout1_13ck230 FIND v(dout1_13) AT=120.025n

.meas tran vdout1_14ck230 FIND v(dout1_14) AT=120.025n

.meas tran vdout1_15ck230 FIND v(dout1_15) AT=120.025n

.meas tran vdout1_16ck230 FIND v(dout1_16) AT=120.025n

.meas tran vdout1_0ck240 FIND v(dout1_0) AT=125.025n

.meas tran vdout1_1ck240 FIND v(dout1_1) AT=125.025n

.meas tran vdout1_2ck240 FIND v(dout1_2) AT=125.025n

.meas tran vdout1_3ck240 FIND v(dout1_3) AT=125.025n

.meas tran vdout1_4ck240 FIND v(dout1_4) AT=125.025n

.meas tran vdout1_5ck240 FIND v(dout1_5) AT=125.025n

.meas tran vdout1_6ck240 FIND v(dout1_6) AT=125.025n

.meas tran vdout1_7ck240 FIND v(dout1_7) AT=125.025n

.meas tran vdout1_8ck240 FIND v(dout1_8) AT=125.025n

.meas tran vdout1_9ck240 FIND v(dout1_9) AT=125.025n

.meas tran vdout1_10ck240 FIND v(dout1_10) AT=125.025n

.meas tran vdout1_11ck240 FIND v(dout1_11) AT=125.025n

.meas tran vdout1_12ck240 FIND v(dout1_12) AT=125.025n

.meas tran vdout1_13ck240 FIND v(dout1_13) AT=125.025n

.meas tran vdout1_14ck240 FIND v(dout1_14) AT=125.025n

.meas tran vdout1_15ck240 FIND v(dout1_15) AT=125.025n

.meas tran vdout1_16ck240 FIND v(dout1_16) AT=125.025n

.meas tran vdout1_0ck250 FIND v(dout1_0) AT=130.025n

.meas tran vdout1_1ck250 FIND v(dout1_1) AT=130.025n

.meas tran vdout1_2ck250 FIND v(dout1_2) AT=130.025n

.meas tran vdout1_3ck250 FIND v(dout1_3) AT=130.025n

.meas tran vdout1_4ck250 FIND v(dout1_4) AT=130.025n

.meas tran vdout1_5ck250 FIND v(dout1_5) AT=130.025n

.meas tran vdout1_6ck250 FIND v(dout1_6) AT=130.025n

.meas tran vdout1_7ck250 FIND v(dout1_7) AT=130.025n

.meas tran vdout1_8ck250 FIND v(dout1_8) AT=130.025n

.meas tran vdout1_9ck250 FIND v(dout1_9) AT=130.025n

.meas tran vdout1_10ck250 FIND v(dout1_10) AT=130.025n

.meas tran vdout1_11ck250 FIND v(dout1_11) AT=130.025n

.meas tran vdout1_12ck250 FIND v(dout1_12) AT=130.025n

.meas tran vdout1_13ck250 FIND v(dout1_13) AT=130.025n

.meas tran vdout1_14ck250 FIND v(dout1_14) AT=130.025n

.meas tran vdout1_15ck250 FIND v(dout1_15) AT=130.025n

.meas tran vdout1_16ck250 FIND v(dout1_16) AT=130.025n

.meas tran vdout1_0ck290 FIND v(dout1_0) AT=150.025n

.meas tran vdout1_1ck290 FIND v(dout1_1) AT=150.025n

.meas tran vdout1_2ck290 FIND v(dout1_2) AT=150.025n

.meas tran vdout1_3ck290 FIND v(dout1_3) AT=150.025n

.meas tran vdout1_4ck290 FIND v(dout1_4) AT=150.025n

.meas tran vdout1_5ck290 FIND v(dout1_5) AT=150.025n

.meas tran vdout1_6ck290 FIND v(dout1_6) AT=150.025n

.meas tran vdout1_7ck290 FIND v(dout1_7) AT=150.025n

.meas tran vdout1_8ck290 FIND v(dout1_8) AT=150.025n

.meas tran vdout1_9ck290 FIND v(dout1_9) AT=150.025n

.meas tran vdout1_10ck290 FIND v(dout1_10) AT=150.025n

.meas tran vdout1_11ck290 FIND v(dout1_11) AT=150.025n

.meas tran vdout1_12ck290 FIND v(dout1_12) AT=150.025n

.meas tran vdout1_13ck290 FIND v(dout1_13) AT=150.025n

.meas tran vdout1_14ck290 FIND v(dout1_14) AT=150.025n

.meas tran vdout1_15ck290 FIND v(dout1_15) AT=150.025n

.meas tran vdout1_16ck290 FIND v(dout1_16) AT=150.025n

.meas tran vdout1_0ck310 FIND v(dout1_0) AT=160.025n

.meas tran vdout1_1ck310 FIND v(dout1_1) AT=160.025n

.meas tran vdout1_2ck310 FIND v(dout1_2) AT=160.025n

.meas tran vdout1_3ck310 FIND v(dout1_3) AT=160.025n

.meas tran vdout1_4ck310 FIND v(dout1_4) AT=160.025n

.meas tran vdout1_5ck310 FIND v(dout1_5) AT=160.025n

.meas tran vdout1_6ck310 FIND v(dout1_6) AT=160.025n

.meas tran vdout1_7ck310 FIND v(dout1_7) AT=160.025n

.meas tran vdout1_8ck310 FIND v(dout1_8) AT=160.025n

.meas tran vdout1_9ck310 FIND v(dout1_9) AT=160.025n

.meas tran vdout1_10ck310 FIND v(dout1_10) AT=160.025n

.meas tran vdout1_11ck310 FIND v(dout1_11) AT=160.025n

.meas tran vdout1_12ck310 FIND v(dout1_12) AT=160.025n

.meas tran vdout1_13ck310 FIND v(dout1_13) AT=160.025n

.meas tran vdout1_14ck310 FIND v(dout1_14) AT=160.025n

.meas tran vdout1_15ck310 FIND v(dout1_15) AT=160.025n

.meas tran vdout1_16ck310 FIND v(dout1_16) AT=160.025n

.meas tran vdout1_0ck320 FIND v(dout1_0) AT=165.025n

.meas tran vdout1_1ck320 FIND v(dout1_1) AT=165.025n

.meas tran vdout1_2ck320 FIND v(dout1_2) AT=165.025n

.meas tran vdout1_3ck320 FIND v(dout1_3) AT=165.025n

.meas tran vdout1_4ck320 FIND v(dout1_4) AT=165.025n

.meas tran vdout1_5ck320 FIND v(dout1_5) AT=165.025n

.meas tran vdout1_6ck320 FIND v(dout1_6) AT=165.025n

.meas tran vdout1_7ck320 FIND v(dout1_7) AT=165.025n

.meas tran vdout1_8ck320 FIND v(dout1_8) AT=165.025n

.meas tran vdout1_9ck320 FIND v(dout1_9) AT=165.025n

.meas tran vdout1_10ck320 FIND v(dout1_10) AT=165.025n

.meas tran vdout1_11ck320 FIND v(dout1_11) AT=165.025n

.meas tran vdout1_12ck320 FIND v(dout1_12) AT=165.025n

.meas tran vdout1_13ck320 FIND v(dout1_13) AT=165.025n

.meas tran vdout1_14ck320 FIND v(dout1_14) AT=165.025n

.meas tran vdout1_15ck320 FIND v(dout1_15) AT=165.025n

.meas tran vdout1_16ck320 FIND v(dout1_16) AT=165.025n

.meas tran vdout1_0ck330 FIND v(dout1_0) AT=170.025n

.meas tran vdout1_1ck330 FIND v(dout1_1) AT=170.025n

.meas tran vdout1_2ck330 FIND v(dout1_2) AT=170.025n

.meas tran vdout1_3ck330 FIND v(dout1_3) AT=170.025n

.meas tran vdout1_4ck330 FIND v(dout1_4) AT=170.025n

.meas tran vdout1_5ck330 FIND v(dout1_5) AT=170.025n

.meas tran vdout1_6ck330 FIND v(dout1_6) AT=170.025n

.meas tran vdout1_7ck330 FIND v(dout1_7) AT=170.025n

.meas tran vdout1_8ck330 FIND v(dout1_8) AT=170.025n

.meas tran vdout1_9ck330 FIND v(dout1_9) AT=170.025n

.meas tran vdout1_10ck330 FIND v(dout1_10) AT=170.025n

.meas tran vdout1_11ck330 FIND v(dout1_11) AT=170.025n

.meas tran vdout1_12ck330 FIND v(dout1_12) AT=170.025n

.meas tran vdout1_13ck330 FIND v(dout1_13) AT=170.025n

.meas tran vdout1_14ck330 FIND v(dout1_14) AT=170.025n

.meas tran vdout1_15ck330 FIND v(dout1_15) AT=170.025n

.meas tran vdout1_16ck330 FIND v(dout1_16) AT=170.025n

.meas tran vdout1_0ck360 FIND v(dout1_0) AT=185.025n

.meas tran vdout1_1ck360 FIND v(dout1_1) AT=185.025n

.meas tran vdout1_2ck360 FIND v(dout1_2) AT=185.025n

.meas tran vdout1_3ck360 FIND v(dout1_3) AT=185.025n

.meas tran vdout1_4ck360 FIND v(dout1_4) AT=185.025n

.meas tran vdout1_5ck360 FIND v(dout1_5) AT=185.025n

.meas tran vdout1_6ck360 FIND v(dout1_6) AT=185.025n

.meas tran vdout1_7ck360 FIND v(dout1_7) AT=185.025n

.meas tran vdout1_8ck360 FIND v(dout1_8) AT=185.025n

.meas tran vdout1_9ck360 FIND v(dout1_9) AT=185.025n

.meas tran vdout1_10ck360 FIND v(dout1_10) AT=185.025n

.meas tran vdout1_11ck360 FIND v(dout1_11) AT=185.025n

.meas tran vdout1_12ck360 FIND v(dout1_12) AT=185.025n

.meas tran vdout1_13ck360 FIND v(dout1_13) AT=185.025n

.meas tran vdout1_14ck360 FIND v(dout1_14) AT=185.025n

.meas tran vdout1_15ck360 FIND v(dout1_15) AT=185.025n

.meas tran vdout1_16ck360 FIND v(dout1_16) AT=185.025n

.meas tran vdout1_0ck400 FIND v(dout1_0) AT=205.025n

.meas tran vdout1_1ck400 FIND v(dout1_1) AT=205.025n

.meas tran vdout1_2ck400 FIND v(dout1_2) AT=205.025n

.meas tran vdout1_3ck400 FIND v(dout1_3) AT=205.025n

.meas tran vdout1_4ck400 FIND v(dout1_4) AT=205.025n

.meas tran vdout1_5ck400 FIND v(dout1_5) AT=205.025n

.meas tran vdout1_6ck400 FIND v(dout1_6) AT=205.025n

.meas tran vdout1_7ck400 FIND v(dout1_7) AT=205.025n

.meas tran vdout1_8ck400 FIND v(dout1_8) AT=205.025n

.meas tran vdout1_9ck400 FIND v(dout1_9) AT=205.025n

.meas tran vdout1_10ck400 FIND v(dout1_10) AT=205.025n

.meas tran vdout1_11ck400 FIND v(dout1_11) AT=205.025n

.meas tran vdout1_12ck400 FIND v(dout1_12) AT=205.025n

.meas tran vdout1_13ck400 FIND v(dout1_13) AT=205.025n

.meas tran vdout1_14ck400 FIND v(dout1_14) AT=205.025n

.meas tran vdout1_15ck400 FIND v(dout1_15) AT=205.025n

.meas tran vdout1_16ck400 FIND v(dout1_16) AT=205.025n

.meas tran vdout1_0ck410 FIND v(dout1_0) AT=210.025n

.meas tran vdout1_1ck410 FIND v(dout1_1) AT=210.025n

.meas tran vdout1_2ck410 FIND v(dout1_2) AT=210.025n

.meas tran vdout1_3ck410 FIND v(dout1_3) AT=210.025n

.meas tran vdout1_4ck410 FIND v(dout1_4) AT=210.025n

.meas tran vdout1_5ck410 FIND v(dout1_5) AT=210.025n

.meas tran vdout1_6ck410 FIND v(dout1_6) AT=210.025n

.meas tran vdout1_7ck410 FIND v(dout1_7) AT=210.025n

.meas tran vdout1_8ck410 FIND v(dout1_8) AT=210.025n

.meas tran vdout1_9ck410 FIND v(dout1_9) AT=210.025n

.meas tran vdout1_10ck410 FIND v(dout1_10) AT=210.025n

.meas tran vdout1_11ck410 FIND v(dout1_11) AT=210.025n

.meas tran vdout1_12ck410 FIND v(dout1_12) AT=210.025n

.meas tran vdout1_13ck410 FIND v(dout1_13) AT=210.025n

.meas tran vdout1_14ck410 FIND v(dout1_14) AT=210.025n

.meas tran vdout1_15ck410 FIND v(dout1_15) AT=210.025n

.meas tran vdout1_16ck410 FIND v(dout1_16) AT=210.025n

.meas tran vdout1_0ck420 FIND v(dout1_0) AT=215.025n

.meas tran vdout1_1ck420 FIND v(dout1_1) AT=215.025n

.meas tran vdout1_2ck420 FIND v(dout1_2) AT=215.025n

.meas tran vdout1_3ck420 FIND v(dout1_3) AT=215.025n

.meas tran vdout1_4ck420 FIND v(dout1_4) AT=215.025n

.meas tran vdout1_5ck420 FIND v(dout1_5) AT=215.025n

.meas tran vdout1_6ck420 FIND v(dout1_6) AT=215.025n

.meas tran vdout1_7ck420 FIND v(dout1_7) AT=215.025n

.meas tran vdout1_8ck420 FIND v(dout1_8) AT=215.025n

.meas tran vdout1_9ck420 FIND v(dout1_9) AT=215.025n

.meas tran vdout1_10ck420 FIND v(dout1_10) AT=215.025n

.meas tran vdout1_11ck420 FIND v(dout1_11) AT=215.025n

.meas tran vdout1_12ck420 FIND v(dout1_12) AT=215.025n

.meas tran vdout1_13ck420 FIND v(dout1_13) AT=215.025n

.meas tran vdout1_14ck420 FIND v(dout1_14) AT=215.025n

.meas tran vdout1_15ck420 FIND v(dout1_15) AT=215.025n

.meas tran vdout1_16ck420 FIND v(dout1_16) AT=215.025n

.meas tran vdout1_0ck430 FIND v(dout1_0) AT=220.025n

.meas tran vdout1_1ck430 FIND v(dout1_1) AT=220.025n

.meas tran vdout1_2ck430 FIND v(dout1_2) AT=220.025n

.meas tran vdout1_3ck430 FIND v(dout1_3) AT=220.025n

.meas tran vdout1_4ck430 FIND v(dout1_4) AT=220.025n

.meas tran vdout1_5ck430 FIND v(dout1_5) AT=220.025n

.meas tran vdout1_6ck430 FIND v(dout1_6) AT=220.025n

.meas tran vdout1_7ck430 FIND v(dout1_7) AT=220.025n

.meas tran vdout1_8ck430 FIND v(dout1_8) AT=220.025n

.meas tran vdout1_9ck430 FIND v(dout1_9) AT=220.025n

.meas tran vdout1_10ck430 FIND v(dout1_10) AT=220.025n

.meas tran vdout1_11ck430 FIND v(dout1_11) AT=220.025n

.meas tran vdout1_12ck430 FIND v(dout1_12) AT=220.025n

.meas tran vdout1_13ck430 FIND v(dout1_13) AT=220.025n

.meas tran vdout1_14ck430 FIND v(dout1_14) AT=220.025n

.meas tran vdout1_15ck430 FIND v(dout1_15) AT=220.025n

.meas tran vdout1_16ck430 FIND v(dout1_16) AT=220.025n

.meas tran vdout1_0ck450 FIND v(dout1_0) AT=230.025n

.meas tran vdout1_1ck450 FIND v(dout1_1) AT=230.025n

.meas tran vdout1_2ck450 FIND v(dout1_2) AT=230.025n

.meas tran vdout1_3ck450 FIND v(dout1_3) AT=230.025n

.meas tran vdout1_4ck450 FIND v(dout1_4) AT=230.025n

.meas tran vdout1_5ck450 FIND v(dout1_5) AT=230.025n

.meas tran vdout1_6ck450 FIND v(dout1_6) AT=230.025n

.meas tran vdout1_7ck450 FIND v(dout1_7) AT=230.025n

.meas tran vdout1_8ck450 FIND v(dout1_8) AT=230.025n

.meas tran vdout1_9ck450 FIND v(dout1_9) AT=230.025n

.meas tran vdout1_10ck450 FIND v(dout1_10) AT=230.025n

.meas tran vdout1_11ck450 FIND v(dout1_11) AT=230.025n

.meas tran vdout1_12ck450 FIND v(dout1_12) AT=230.025n

.meas tran vdout1_13ck450 FIND v(dout1_13) AT=230.025n

.meas tran vdout1_14ck450 FIND v(dout1_14) AT=230.025n

.meas tran vdout1_15ck450 FIND v(dout1_15) AT=230.025n

.meas tran vdout1_16ck450 FIND v(dout1_16) AT=230.025n

.meas tran vdout1_0ck460 FIND v(dout1_0) AT=235.025n

.meas tran vdout1_1ck460 FIND v(dout1_1) AT=235.025n

.meas tran vdout1_2ck460 FIND v(dout1_2) AT=235.025n

.meas tran vdout1_3ck460 FIND v(dout1_3) AT=235.025n

.meas tran vdout1_4ck460 FIND v(dout1_4) AT=235.025n

.meas tran vdout1_5ck460 FIND v(dout1_5) AT=235.025n

.meas tran vdout1_6ck460 FIND v(dout1_6) AT=235.025n

.meas tran vdout1_7ck460 FIND v(dout1_7) AT=235.025n

.meas tran vdout1_8ck460 FIND v(dout1_8) AT=235.025n

.meas tran vdout1_9ck460 FIND v(dout1_9) AT=235.025n

.meas tran vdout1_10ck460 FIND v(dout1_10) AT=235.025n

.meas tran vdout1_11ck460 FIND v(dout1_11) AT=235.025n

.meas tran vdout1_12ck460 FIND v(dout1_12) AT=235.025n

.meas tran vdout1_13ck460 FIND v(dout1_13) AT=235.025n

.meas tran vdout1_14ck460 FIND v(dout1_14) AT=235.025n

.meas tran vdout1_15ck460 FIND v(dout1_15) AT=235.025n

.meas tran vdout1_16ck460 FIND v(dout1_16) AT=235.025n

.meas tran vdout1_0ck530 FIND v(dout1_0) AT=270.025n

.meas tran vdout1_1ck530 FIND v(dout1_1) AT=270.025n

.meas tran vdout1_2ck530 FIND v(dout1_2) AT=270.025n

.meas tran vdout1_3ck530 FIND v(dout1_3) AT=270.025n

.meas tran vdout1_4ck530 FIND v(dout1_4) AT=270.025n

.meas tran vdout1_5ck530 FIND v(dout1_5) AT=270.025n

.meas tran vdout1_6ck530 FIND v(dout1_6) AT=270.025n

.meas tran vdout1_7ck530 FIND v(dout1_7) AT=270.025n

.meas tran vdout1_8ck530 FIND v(dout1_8) AT=270.025n

.meas tran vdout1_9ck530 FIND v(dout1_9) AT=270.025n

.meas tran vdout1_10ck530 FIND v(dout1_10) AT=270.025n

.meas tran vdout1_11ck530 FIND v(dout1_11) AT=270.025n

.meas tran vdout1_12ck530 FIND v(dout1_12) AT=270.025n

.meas tran vdout1_13ck530 FIND v(dout1_13) AT=270.025n

.meas tran vdout1_14ck530 FIND v(dout1_14) AT=270.025n

.meas tran vdout1_15ck530 FIND v(dout1_15) AT=270.025n

.meas tran vdout1_16ck530 FIND v(dout1_16) AT=270.025n

.meas tran vdout1_0ck540 FIND v(dout1_0) AT=275.025n

.meas tran vdout1_1ck540 FIND v(dout1_1) AT=275.025n

.meas tran vdout1_2ck540 FIND v(dout1_2) AT=275.025n

.meas tran vdout1_3ck540 FIND v(dout1_3) AT=275.025n

.meas tran vdout1_4ck540 FIND v(dout1_4) AT=275.025n

.meas tran vdout1_5ck540 FIND v(dout1_5) AT=275.025n

.meas tran vdout1_6ck540 FIND v(dout1_6) AT=275.025n

.meas tran vdout1_7ck540 FIND v(dout1_7) AT=275.025n

.meas tran vdout1_8ck540 FIND v(dout1_8) AT=275.025n

.meas tran vdout1_9ck540 FIND v(dout1_9) AT=275.025n

.meas tran vdout1_10ck540 FIND v(dout1_10) AT=275.025n

.meas tran vdout1_11ck540 FIND v(dout1_11) AT=275.025n

.meas tran vdout1_12ck540 FIND v(dout1_12) AT=275.025n

.meas tran vdout1_13ck540 FIND v(dout1_13) AT=275.025n

.meas tran vdout1_14ck540 FIND v(dout1_14) AT=275.025n

.meas tran vdout1_15ck540 FIND v(dout1_15) AT=275.025n

.meas tran vdout1_16ck540 FIND v(dout1_16) AT=275.025n

.meas tran vdout1_0ck570 FIND v(dout1_0) AT=290.025n

.meas tran vdout1_1ck570 FIND v(dout1_1) AT=290.025n

.meas tran vdout1_2ck570 FIND v(dout1_2) AT=290.025n

.meas tran vdout1_3ck570 FIND v(dout1_3) AT=290.025n

.meas tran vdout1_4ck570 FIND v(dout1_4) AT=290.025n

.meas tran vdout1_5ck570 FIND v(dout1_5) AT=290.025n

.meas tran vdout1_6ck570 FIND v(dout1_6) AT=290.025n

.meas tran vdout1_7ck570 FIND v(dout1_7) AT=290.025n

.meas tran vdout1_8ck570 FIND v(dout1_8) AT=290.025n

.meas tran vdout1_9ck570 FIND v(dout1_9) AT=290.025n

.meas tran vdout1_10ck570 FIND v(dout1_10) AT=290.025n

.meas tran vdout1_11ck570 FIND v(dout1_11) AT=290.025n

.meas tran vdout1_12ck570 FIND v(dout1_12) AT=290.025n

.meas tran vdout1_13ck570 FIND v(dout1_13) AT=290.025n

.meas tran vdout1_14ck570 FIND v(dout1_14) AT=290.025n

.meas tran vdout1_15ck570 FIND v(dout1_15) AT=290.025n

.meas tran vdout1_16ck570 FIND v(dout1_16) AT=290.025n

.meas tran vdout1_0ck580 FIND v(dout1_0) AT=295.025n

.meas tran vdout1_1ck580 FIND v(dout1_1) AT=295.025n

.meas tran vdout1_2ck580 FIND v(dout1_2) AT=295.025n

.meas tran vdout1_3ck580 FIND v(dout1_3) AT=295.025n

.meas tran vdout1_4ck580 FIND v(dout1_4) AT=295.025n

.meas tran vdout1_5ck580 FIND v(dout1_5) AT=295.025n

.meas tran vdout1_6ck580 FIND v(dout1_6) AT=295.025n

.meas tran vdout1_7ck580 FIND v(dout1_7) AT=295.025n

.meas tran vdout1_8ck580 FIND v(dout1_8) AT=295.025n

.meas tran vdout1_9ck580 FIND v(dout1_9) AT=295.025n

.meas tran vdout1_10ck580 FIND v(dout1_10) AT=295.025n

.meas tran vdout1_11ck580 FIND v(dout1_11) AT=295.025n

.meas tran vdout1_12ck580 FIND v(dout1_12) AT=295.025n

.meas tran vdout1_13ck580 FIND v(dout1_13) AT=295.025n

.meas tran vdout1_14ck580 FIND v(dout1_14) AT=295.025n

.meas tran vdout1_15ck580 FIND v(dout1_15) AT=295.025n

.meas tran vdout1_16ck580 FIND v(dout1_16) AT=295.025n

.meas tran vdout1_0ck590 FIND v(dout1_0) AT=300.025n

.meas tran vdout1_1ck590 FIND v(dout1_1) AT=300.025n

.meas tran vdout1_2ck590 FIND v(dout1_2) AT=300.025n

.meas tran vdout1_3ck590 FIND v(dout1_3) AT=300.025n

.meas tran vdout1_4ck590 FIND v(dout1_4) AT=300.025n

.meas tran vdout1_5ck590 FIND v(dout1_5) AT=300.025n

.meas tran vdout1_6ck590 FIND v(dout1_6) AT=300.025n

.meas tran vdout1_7ck590 FIND v(dout1_7) AT=300.025n

.meas tran vdout1_8ck590 FIND v(dout1_8) AT=300.025n

.meas tran vdout1_9ck590 FIND v(dout1_9) AT=300.025n

.meas tran vdout1_10ck590 FIND v(dout1_10) AT=300.025n

.meas tran vdout1_11ck590 FIND v(dout1_11) AT=300.025n

.meas tran vdout1_12ck590 FIND v(dout1_12) AT=300.025n

.meas tran vdout1_13ck590 FIND v(dout1_13) AT=300.025n

.meas tran vdout1_14ck590 FIND v(dout1_14) AT=300.025n

.meas tran vdout1_15ck590 FIND v(dout1_15) AT=300.025n

.meas tran vdout1_16ck590 FIND v(dout1_16) AT=300.025n

.meas tran vdout1_0ck610 FIND v(dout1_0) AT=310.025n

.meas tran vdout1_1ck610 FIND v(dout1_1) AT=310.025n

.meas tran vdout1_2ck610 FIND v(dout1_2) AT=310.025n

.meas tran vdout1_3ck610 FIND v(dout1_3) AT=310.025n

.meas tran vdout1_4ck610 FIND v(dout1_4) AT=310.025n

.meas tran vdout1_5ck610 FIND v(dout1_5) AT=310.025n

.meas tran vdout1_6ck610 FIND v(dout1_6) AT=310.025n

.meas tran vdout1_7ck610 FIND v(dout1_7) AT=310.025n

.meas tran vdout1_8ck610 FIND v(dout1_8) AT=310.025n

.meas tran vdout1_9ck610 FIND v(dout1_9) AT=310.025n

.meas tran vdout1_10ck610 FIND v(dout1_10) AT=310.025n

.meas tran vdout1_11ck610 FIND v(dout1_11) AT=310.025n

.meas tran vdout1_12ck610 FIND v(dout1_12) AT=310.025n

.meas tran vdout1_13ck610 FIND v(dout1_13) AT=310.025n

.meas tran vdout1_14ck610 FIND v(dout1_14) AT=310.025n

.meas tran vdout1_15ck610 FIND v(dout1_15) AT=310.025n

.meas tran vdout1_16ck610 FIND v(dout1_16) AT=310.025n

.meas tran vdout1_0ck670 FIND v(dout1_0) AT=340.025n

.meas tran vdout1_1ck670 FIND v(dout1_1) AT=340.025n

.meas tran vdout1_2ck670 FIND v(dout1_2) AT=340.025n

.meas tran vdout1_3ck670 FIND v(dout1_3) AT=340.025n

.meas tran vdout1_4ck670 FIND v(dout1_4) AT=340.025n

.meas tran vdout1_5ck670 FIND v(dout1_5) AT=340.025n

.meas tran vdout1_6ck670 FIND v(dout1_6) AT=340.025n

.meas tran vdout1_7ck670 FIND v(dout1_7) AT=340.025n

.meas tran vdout1_8ck670 FIND v(dout1_8) AT=340.025n

.meas tran vdout1_9ck670 FIND v(dout1_9) AT=340.025n

.meas tran vdout1_10ck670 FIND v(dout1_10) AT=340.025n

.meas tran vdout1_11ck670 FIND v(dout1_11) AT=340.025n

.meas tran vdout1_12ck670 FIND v(dout1_12) AT=340.025n

.meas tran vdout1_13ck670 FIND v(dout1_13) AT=340.025n

.meas tran vdout1_14ck670 FIND v(dout1_14) AT=340.025n

.meas tran vdout1_15ck670 FIND v(dout1_15) AT=340.025n

.meas tran vdout1_16ck670 FIND v(dout1_16) AT=340.025n

.meas tran vdout1_0ck700 FIND v(dout1_0) AT=355.025n

.meas tran vdout1_1ck700 FIND v(dout1_1) AT=355.025n

.meas tran vdout1_2ck700 FIND v(dout1_2) AT=355.025n

.meas tran vdout1_3ck700 FIND v(dout1_3) AT=355.025n

.meas tran vdout1_4ck700 FIND v(dout1_4) AT=355.025n

.meas tran vdout1_5ck700 FIND v(dout1_5) AT=355.025n

.meas tran vdout1_6ck700 FIND v(dout1_6) AT=355.025n

.meas tran vdout1_7ck700 FIND v(dout1_7) AT=355.025n

.meas tran vdout1_8ck700 FIND v(dout1_8) AT=355.025n

.meas tran vdout1_9ck700 FIND v(dout1_9) AT=355.025n

.meas tran vdout1_10ck700 FIND v(dout1_10) AT=355.025n

.meas tran vdout1_11ck700 FIND v(dout1_11) AT=355.025n

.meas tran vdout1_12ck700 FIND v(dout1_12) AT=355.025n

.meas tran vdout1_13ck700 FIND v(dout1_13) AT=355.025n

.meas tran vdout1_14ck700 FIND v(dout1_14) AT=355.025n

.meas tran vdout1_15ck700 FIND v(dout1_15) AT=355.025n

.meas tran vdout1_16ck700 FIND v(dout1_16) AT=355.025n

.meas tran vdout1_0ck730 FIND v(dout1_0) AT=370.025n

.meas tran vdout1_1ck730 FIND v(dout1_1) AT=370.025n

.meas tran vdout1_2ck730 FIND v(dout1_2) AT=370.025n

.meas tran vdout1_3ck730 FIND v(dout1_3) AT=370.025n

.meas tran vdout1_4ck730 FIND v(dout1_4) AT=370.025n

.meas tran vdout1_5ck730 FIND v(dout1_5) AT=370.025n

.meas tran vdout1_6ck730 FIND v(dout1_6) AT=370.025n

.meas tran vdout1_7ck730 FIND v(dout1_7) AT=370.025n

.meas tran vdout1_8ck730 FIND v(dout1_8) AT=370.025n

.meas tran vdout1_9ck730 FIND v(dout1_9) AT=370.025n

.meas tran vdout1_10ck730 FIND v(dout1_10) AT=370.025n

.meas tran vdout1_11ck730 FIND v(dout1_11) AT=370.025n

.meas tran vdout1_12ck730 FIND v(dout1_12) AT=370.025n

.meas tran vdout1_13ck730 FIND v(dout1_13) AT=370.025n

.meas tran vdout1_14ck730 FIND v(dout1_14) AT=370.025n

.meas tran vdout1_15ck730 FIND v(dout1_15) AT=370.025n

.meas tran vdout1_16ck730 FIND v(dout1_16) AT=370.025n

.meas tran vdout1_0ck760 FIND v(dout1_0) AT=385.025n

.meas tran vdout1_1ck760 FIND v(dout1_1) AT=385.025n

.meas tran vdout1_2ck760 FIND v(dout1_2) AT=385.025n

.meas tran vdout1_3ck760 FIND v(dout1_3) AT=385.025n

.meas tran vdout1_4ck760 FIND v(dout1_4) AT=385.025n

.meas tran vdout1_5ck760 FIND v(dout1_5) AT=385.025n

.meas tran vdout1_6ck760 FIND v(dout1_6) AT=385.025n

.meas tran vdout1_7ck760 FIND v(dout1_7) AT=385.025n

.meas tran vdout1_8ck760 FIND v(dout1_8) AT=385.025n

.meas tran vdout1_9ck760 FIND v(dout1_9) AT=385.025n

.meas tran vdout1_10ck760 FIND v(dout1_10) AT=385.025n

.meas tran vdout1_11ck760 FIND v(dout1_11) AT=385.025n

.meas tran vdout1_12ck760 FIND v(dout1_12) AT=385.025n

.meas tran vdout1_13ck760 FIND v(dout1_13) AT=385.025n

.meas tran vdout1_14ck760 FIND v(dout1_14) AT=385.025n

.meas tran vdout1_15ck760 FIND v(dout1_15) AT=385.025n

.meas tran vdout1_16ck760 FIND v(dout1_16) AT=385.025n

.meas tran vdout1_0ck770 FIND v(dout1_0) AT=390.025n

.meas tran vdout1_1ck770 FIND v(dout1_1) AT=390.025n

.meas tran vdout1_2ck770 FIND v(dout1_2) AT=390.025n

.meas tran vdout1_3ck770 FIND v(dout1_3) AT=390.025n

.meas tran vdout1_4ck770 FIND v(dout1_4) AT=390.025n

.meas tran vdout1_5ck770 FIND v(dout1_5) AT=390.025n

.meas tran vdout1_6ck770 FIND v(dout1_6) AT=390.025n

.meas tran vdout1_7ck770 FIND v(dout1_7) AT=390.025n

.meas tran vdout1_8ck770 FIND v(dout1_8) AT=390.025n

.meas tran vdout1_9ck770 FIND v(dout1_9) AT=390.025n

.meas tran vdout1_10ck770 FIND v(dout1_10) AT=390.025n

.meas tran vdout1_11ck770 FIND v(dout1_11) AT=390.025n

.meas tran vdout1_12ck770 FIND v(dout1_12) AT=390.025n

.meas tran vdout1_13ck770 FIND v(dout1_13) AT=390.025n

.meas tran vdout1_14ck770 FIND v(dout1_14) AT=390.025n

.meas tran vdout1_15ck770 FIND v(dout1_15) AT=390.025n

.meas tran vdout1_16ck770 FIND v(dout1_16) AT=390.025n

.meas tran vdout1_0ck790 FIND v(dout1_0) AT=400.025n

.meas tran vdout1_1ck790 FIND v(dout1_1) AT=400.025n

.meas tran vdout1_2ck790 FIND v(dout1_2) AT=400.025n

.meas tran vdout1_3ck790 FIND v(dout1_3) AT=400.025n

.meas tran vdout1_4ck790 FIND v(dout1_4) AT=400.025n

.meas tran vdout1_5ck790 FIND v(dout1_5) AT=400.025n

.meas tran vdout1_6ck790 FIND v(dout1_6) AT=400.025n

.meas tran vdout1_7ck790 FIND v(dout1_7) AT=400.025n

.meas tran vdout1_8ck790 FIND v(dout1_8) AT=400.025n

.meas tran vdout1_9ck790 FIND v(dout1_9) AT=400.025n

.meas tran vdout1_10ck790 FIND v(dout1_10) AT=400.025n

.meas tran vdout1_11ck790 FIND v(dout1_11) AT=400.025n

.meas tran vdout1_12ck790 FIND v(dout1_12) AT=400.025n

.meas tran vdout1_13ck790 FIND v(dout1_13) AT=400.025n

.meas tran vdout1_14ck790 FIND v(dout1_14) AT=400.025n

.meas tran vdout1_15ck790 FIND v(dout1_15) AT=400.025n

.meas tran vdout1_16ck790 FIND v(dout1_16) AT=400.025n

.meas tran vdout1_0ck800 FIND v(dout1_0) AT=405.025n

.meas tran vdout1_1ck800 FIND v(dout1_1) AT=405.025n

.meas tran vdout1_2ck800 FIND v(dout1_2) AT=405.025n

.meas tran vdout1_3ck800 FIND v(dout1_3) AT=405.025n

.meas tran vdout1_4ck800 FIND v(dout1_4) AT=405.025n

.meas tran vdout1_5ck800 FIND v(dout1_5) AT=405.025n

.meas tran vdout1_6ck800 FIND v(dout1_6) AT=405.025n

.meas tran vdout1_7ck800 FIND v(dout1_7) AT=405.025n

.meas tran vdout1_8ck800 FIND v(dout1_8) AT=405.025n

.meas tran vdout1_9ck800 FIND v(dout1_9) AT=405.025n

.meas tran vdout1_10ck800 FIND v(dout1_10) AT=405.025n

.meas tran vdout1_11ck800 FIND v(dout1_11) AT=405.025n

.meas tran vdout1_12ck800 FIND v(dout1_12) AT=405.025n

.meas tran vdout1_13ck800 FIND v(dout1_13) AT=405.025n

.meas tran vdout1_14ck800 FIND v(dout1_14) AT=405.025n

.meas tran vdout1_15ck800 FIND v(dout1_15) AT=405.025n

.meas tran vdout1_16ck800 FIND v(dout1_16) AT=405.025n

.meas tran vdout1_0ck870 FIND v(dout1_0) AT=440.025n

.meas tran vdout1_1ck870 FIND v(dout1_1) AT=440.025n

.meas tran vdout1_2ck870 FIND v(dout1_2) AT=440.025n

.meas tran vdout1_3ck870 FIND v(dout1_3) AT=440.025n

.meas tran vdout1_4ck870 FIND v(dout1_4) AT=440.025n

.meas tran vdout1_5ck870 FIND v(dout1_5) AT=440.025n

.meas tran vdout1_6ck870 FIND v(dout1_6) AT=440.025n

.meas tran vdout1_7ck870 FIND v(dout1_7) AT=440.025n

.meas tran vdout1_8ck870 FIND v(dout1_8) AT=440.025n

.meas tran vdout1_9ck870 FIND v(dout1_9) AT=440.025n

.meas tran vdout1_10ck870 FIND v(dout1_10) AT=440.025n

.meas tran vdout1_11ck870 FIND v(dout1_11) AT=440.025n

.meas tran vdout1_12ck870 FIND v(dout1_12) AT=440.025n

.meas tran vdout1_13ck870 FIND v(dout1_13) AT=440.025n

.meas tran vdout1_14ck870 FIND v(dout1_14) AT=440.025n

.meas tran vdout1_15ck870 FIND v(dout1_15) AT=440.025n

.meas tran vdout1_16ck870 FIND v(dout1_16) AT=440.025n

.meas tran vdout1_0ck890 FIND v(dout1_0) AT=450.025n

.meas tran vdout1_1ck890 FIND v(dout1_1) AT=450.025n

.meas tran vdout1_2ck890 FIND v(dout1_2) AT=450.025n

.meas tran vdout1_3ck890 FIND v(dout1_3) AT=450.025n

.meas tran vdout1_4ck890 FIND v(dout1_4) AT=450.025n

.meas tran vdout1_5ck890 FIND v(dout1_5) AT=450.025n

.meas tran vdout1_6ck890 FIND v(dout1_6) AT=450.025n

.meas tran vdout1_7ck890 FIND v(dout1_7) AT=450.025n

.meas tran vdout1_8ck890 FIND v(dout1_8) AT=450.025n

.meas tran vdout1_9ck890 FIND v(dout1_9) AT=450.025n

.meas tran vdout1_10ck890 FIND v(dout1_10) AT=450.025n

.meas tran vdout1_11ck890 FIND v(dout1_11) AT=450.025n

.meas tran vdout1_12ck890 FIND v(dout1_12) AT=450.025n

.meas tran vdout1_13ck890 FIND v(dout1_13) AT=450.025n

.meas tran vdout1_14ck890 FIND v(dout1_14) AT=450.025n

.meas tran vdout1_15ck890 FIND v(dout1_15) AT=450.025n

.meas tran vdout1_16ck890 FIND v(dout1_16) AT=450.025n

.meas tran vdout1_0ck900 FIND v(dout1_0) AT=455.025n

.meas tran vdout1_1ck900 FIND v(dout1_1) AT=455.025n

.meas tran vdout1_2ck900 FIND v(dout1_2) AT=455.025n

.meas tran vdout1_3ck900 FIND v(dout1_3) AT=455.025n

.meas tran vdout1_4ck900 FIND v(dout1_4) AT=455.025n

.meas tran vdout1_5ck900 FIND v(dout1_5) AT=455.025n

.meas tran vdout1_6ck900 FIND v(dout1_6) AT=455.025n

.meas tran vdout1_7ck900 FIND v(dout1_7) AT=455.025n

.meas tran vdout1_8ck900 FIND v(dout1_8) AT=455.025n

.meas tran vdout1_9ck900 FIND v(dout1_9) AT=455.025n

.meas tran vdout1_10ck900 FIND v(dout1_10) AT=455.025n

.meas tran vdout1_11ck900 FIND v(dout1_11) AT=455.025n

.meas tran vdout1_12ck900 FIND v(dout1_12) AT=455.025n

.meas tran vdout1_13ck900 FIND v(dout1_13) AT=455.025n

.meas tran vdout1_14ck900 FIND v(dout1_14) AT=455.025n

.meas tran vdout1_15ck900 FIND v(dout1_15) AT=455.025n

.meas tran vdout1_16ck900 FIND v(dout1_16) AT=455.025n

.meas tran vdout1_0ck930 FIND v(dout1_0) AT=470.025n

.meas tran vdout1_1ck930 FIND v(dout1_1) AT=470.025n

.meas tran vdout1_2ck930 FIND v(dout1_2) AT=470.025n

.meas tran vdout1_3ck930 FIND v(dout1_3) AT=470.025n

.meas tran vdout1_4ck930 FIND v(dout1_4) AT=470.025n

.meas tran vdout1_5ck930 FIND v(dout1_5) AT=470.025n

.meas tran vdout1_6ck930 FIND v(dout1_6) AT=470.025n

.meas tran vdout1_7ck930 FIND v(dout1_7) AT=470.025n

.meas tran vdout1_8ck930 FIND v(dout1_8) AT=470.025n

.meas tran vdout1_9ck930 FIND v(dout1_9) AT=470.025n

.meas tran vdout1_10ck930 FIND v(dout1_10) AT=470.025n

.meas tran vdout1_11ck930 FIND v(dout1_11) AT=470.025n

.meas tran vdout1_12ck930 FIND v(dout1_12) AT=470.025n

.meas tran vdout1_13ck930 FIND v(dout1_13) AT=470.025n

.meas tran vdout1_14ck930 FIND v(dout1_14) AT=470.025n

.meas tran vdout1_15ck930 FIND v(dout1_15) AT=470.025n

.meas tran vdout1_16ck930 FIND v(dout1_16) AT=470.025n

.meas tran vdout1_0ck990 FIND v(dout1_0) AT=500.025n

.meas tran vdout1_1ck990 FIND v(dout1_1) AT=500.025n

.meas tran vdout1_2ck990 FIND v(dout1_2) AT=500.025n

.meas tran vdout1_3ck990 FIND v(dout1_3) AT=500.025n

.meas tran vdout1_4ck990 FIND v(dout1_4) AT=500.025n

.meas tran vdout1_5ck990 FIND v(dout1_5) AT=500.025n

.meas tran vdout1_6ck990 FIND v(dout1_6) AT=500.025n

.meas tran vdout1_7ck990 FIND v(dout1_7) AT=500.025n

.meas tran vdout1_8ck990 FIND v(dout1_8) AT=500.025n

.meas tran vdout1_9ck990 FIND v(dout1_9) AT=500.025n

.meas tran vdout1_10ck990 FIND v(dout1_10) AT=500.025n

.meas tran vdout1_11ck990 FIND v(dout1_11) AT=500.025n

.meas tran vdout1_12ck990 FIND v(dout1_12) AT=500.025n

.meas tran vdout1_13ck990 FIND v(dout1_13) AT=500.025n

.meas tran vdout1_14ck990 FIND v(dout1_14) AT=500.025n

.meas tran vdout1_15ck990 FIND v(dout1_15) AT=500.025n

.meas tran vdout1_16ck990 FIND v(dout1_16) AT=500.025n

.meas tran vdout1_0ck1000 FIND v(dout1_0) AT=505.025n

.meas tran vdout1_1ck1000 FIND v(dout1_1) AT=505.025n

.meas tran vdout1_2ck1000 FIND v(dout1_2) AT=505.025n

.meas tran vdout1_3ck1000 FIND v(dout1_3) AT=505.025n

.meas tran vdout1_4ck1000 FIND v(dout1_4) AT=505.025n

.meas tran vdout1_5ck1000 FIND v(dout1_5) AT=505.025n

.meas tran vdout1_6ck1000 FIND v(dout1_6) AT=505.025n

.meas tran vdout1_7ck1000 FIND v(dout1_7) AT=505.025n

.meas tran vdout1_8ck1000 FIND v(dout1_8) AT=505.025n

.meas tran vdout1_9ck1000 FIND v(dout1_9) AT=505.025n

.meas tran vdout1_10ck1000 FIND v(dout1_10) AT=505.025n

.meas tran vdout1_11ck1000 FIND v(dout1_11) AT=505.025n

.meas tran vdout1_12ck1000 FIND v(dout1_12) AT=505.025n

.meas tran vdout1_13ck1000 FIND v(dout1_13) AT=505.025n

.meas tran vdout1_14ck1000 FIND v(dout1_14) AT=505.025n

.meas tran vdout1_15ck1000 FIND v(dout1_15) AT=505.025n

.meas tran vdout1_16ck1000 FIND v(dout1_16) AT=505.025n

.meas tran vdout1_0ck1010 FIND v(dout1_0) AT=510.025n

.meas tran vdout1_1ck1010 FIND v(dout1_1) AT=510.025n

.meas tran vdout1_2ck1010 FIND v(dout1_2) AT=510.025n

.meas tran vdout1_3ck1010 FIND v(dout1_3) AT=510.025n

.meas tran vdout1_4ck1010 FIND v(dout1_4) AT=510.025n

.meas tran vdout1_5ck1010 FIND v(dout1_5) AT=510.025n

.meas tran vdout1_6ck1010 FIND v(dout1_6) AT=510.025n

.meas tran vdout1_7ck1010 FIND v(dout1_7) AT=510.025n

.meas tran vdout1_8ck1010 FIND v(dout1_8) AT=510.025n

.meas tran vdout1_9ck1010 FIND v(dout1_9) AT=510.025n

.meas tran vdout1_10ck1010 FIND v(dout1_10) AT=510.025n

.meas tran vdout1_11ck1010 FIND v(dout1_11) AT=510.025n

.meas tran vdout1_12ck1010 FIND v(dout1_12) AT=510.025n

.meas tran vdout1_13ck1010 FIND v(dout1_13) AT=510.025n

.meas tran vdout1_14ck1010 FIND v(dout1_14) AT=510.025n

.meas tran vdout1_15ck1010 FIND v(dout1_15) AT=510.025n

.meas tran vdout1_16ck1010 FIND v(dout1_16) AT=510.025n

.meas tran vdout1_0ck1020 FIND v(dout1_0) AT=515.025n

.meas tran vdout1_1ck1020 FIND v(dout1_1) AT=515.025n

.meas tran vdout1_2ck1020 FIND v(dout1_2) AT=515.025n

.meas tran vdout1_3ck1020 FIND v(dout1_3) AT=515.025n

.meas tran vdout1_4ck1020 FIND v(dout1_4) AT=515.025n

.meas tran vdout1_5ck1020 FIND v(dout1_5) AT=515.025n

.meas tran vdout1_6ck1020 FIND v(dout1_6) AT=515.025n

.meas tran vdout1_7ck1020 FIND v(dout1_7) AT=515.025n

.meas tran vdout1_8ck1020 FIND v(dout1_8) AT=515.025n

.meas tran vdout1_9ck1020 FIND v(dout1_9) AT=515.025n

.meas tran vdout1_10ck1020 FIND v(dout1_10) AT=515.025n

.meas tran vdout1_11ck1020 FIND v(dout1_11) AT=515.025n

.meas tran vdout1_12ck1020 FIND v(dout1_12) AT=515.025n

.meas tran vdout1_13ck1020 FIND v(dout1_13) AT=515.025n

.meas tran vdout1_14ck1020 FIND v(dout1_14) AT=515.025n

.meas tran vdout1_15ck1020 FIND v(dout1_15) AT=515.025n

.meas tran vdout1_16ck1020 FIND v(dout1_16) AT=515.025n

.meas tran vdout1_0ck1030 FIND v(dout1_0) AT=520.025n

.meas tran vdout1_1ck1030 FIND v(dout1_1) AT=520.025n

.meas tran vdout1_2ck1030 FIND v(dout1_2) AT=520.025n

.meas tran vdout1_3ck1030 FIND v(dout1_3) AT=520.025n

.meas tran vdout1_4ck1030 FIND v(dout1_4) AT=520.025n

.meas tran vdout1_5ck1030 FIND v(dout1_5) AT=520.025n

.meas tran vdout1_6ck1030 FIND v(dout1_6) AT=520.025n

.meas tran vdout1_7ck1030 FIND v(dout1_7) AT=520.025n

.meas tran vdout1_8ck1030 FIND v(dout1_8) AT=520.025n

.meas tran vdout1_9ck1030 FIND v(dout1_9) AT=520.025n

.meas tran vdout1_10ck1030 FIND v(dout1_10) AT=520.025n

.meas tran vdout1_11ck1030 FIND v(dout1_11) AT=520.025n

.meas tran vdout1_12ck1030 FIND v(dout1_12) AT=520.025n

.meas tran vdout1_13ck1030 FIND v(dout1_13) AT=520.025n

.meas tran vdout1_14ck1030 FIND v(dout1_14) AT=520.025n

.meas tran vdout1_15ck1030 FIND v(dout1_15) AT=520.025n

.meas tran vdout1_16ck1030 FIND v(dout1_16) AT=520.025n

.meas tran vdout1_0ck1050 FIND v(dout1_0) AT=530.025n

.meas tran vdout1_1ck1050 FIND v(dout1_1) AT=530.025n

.meas tran vdout1_2ck1050 FIND v(dout1_2) AT=530.025n

.meas tran vdout1_3ck1050 FIND v(dout1_3) AT=530.025n

.meas tran vdout1_4ck1050 FIND v(dout1_4) AT=530.025n

.meas tran vdout1_5ck1050 FIND v(dout1_5) AT=530.025n

.meas tran vdout1_6ck1050 FIND v(dout1_6) AT=530.025n

.meas tran vdout1_7ck1050 FIND v(dout1_7) AT=530.025n

.meas tran vdout1_8ck1050 FIND v(dout1_8) AT=530.025n

.meas tran vdout1_9ck1050 FIND v(dout1_9) AT=530.025n

.meas tran vdout1_10ck1050 FIND v(dout1_10) AT=530.025n

.meas tran vdout1_11ck1050 FIND v(dout1_11) AT=530.025n

.meas tran vdout1_12ck1050 FIND v(dout1_12) AT=530.025n

.meas tran vdout1_13ck1050 FIND v(dout1_13) AT=530.025n

.meas tran vdout1_14ck1050 FIND v(dout1_14) AT=530.025n

.meas tran vdout1_15ck1050 FIND v(dout1_15) AT=530.025n

.meas tran vdout1_16ck1050 FIND v(dout1_16) AT=530.025n

.meas tran vdout1_0ck1120 FIND v(dout1_0) AT=565.025n

.meas tran vdout1_1ck1120 FIND v(dout1_1) AT=565.025n

.meas tran vdout1_2ck1120 FIND v(dout1_2) AT=565.025n

.meas tran vdout1_3ck1120 FIND v(dout1_3) AT=565.025n

.meas tran vdout1_4ck1120 FIND v(dout1_4) AT=565.025n

.meas tran vdout1_5ck1120 FIND v(dout1_5) AT=565.025n

.meas tran vdout1_6ck1120 FIND v(dout1_6) AT=565.025n

.meas tran vdout1_7ck1120 FIND v(dout1_7) AT=565.025n

.meas tran vdout1_8ck1120 FIND v(dout1_8) AT=565.025n

.meas tran vdout1_9ck1120 FIND v(dout1_9) AT=565.025n

.meas tran vdout1_10ck1120 FIND v(dout1_10) AT=565.025n

.meas tran vdout1_11ck1120 FIND v(dout1_11) AT=565.025n

.meas tran vdout1_12ck1120 FIND v(dout1_12) AT=565.025n

.meas tran vdout1_13ck1120 FIND v(dout1_13) AT=565.025n

.meas tran vdout1_14ck1120 FIND v(dout1_14) AT=565.025n

.meas tran vdout1_15ck1120 FIND v(dout1_15) AT=565.025n

.meas tran vdout1_16ck1120 FIND v(dout1_16) AT=565.025n

.meas tran vdout1_0ck1160 FIND v(dout1_0) AT=585.025n

.meas tran vdout1_1ck1160 FIND v(dout1_1) AT=585.025n

.meas tran vdout1_2ck1160 FIND v(dout1_2) AT=585.025n

.meas tran vdout1_3ck1160 FIND v(dout1_3) AT=585.025n

.meas tran vdout1_4ck1160 FIND v(dout1_4) AT=585.025n

.meas tran vdout1_5ck1160 FIND v(dout1_5) AT=585.025n

.meas tran vdout1_6ck1160 FIND v(dout1_6) AT=585.025n

.meas tran vdout1_7ck1160 FIND v(dout1_7) AT=585.025n

.meas tran vdout1_8ck1160 FIND v(dout1_8) AT=585.025n

.meas tran vdout1_9ck1160 FIND v(dout1_9) AT=585.025n

.meas tran vdout1_10ck1160 FIND v(dout1_10) AT=585.025n

.meas tran vdout1_11ck1160 FIND v(dout1_11) AT=585.025n

.meas tran vdout1_12ck1160 FIND v(dout1_12) AT=585.025n

.meas tran vdout1_13ck1160 FIND v(dout1_13) AT=585.025n

.meas tran vdout1_14ck1160 FIND v(dout1_14) AT=585.025n

.meas tran vdout1_15ck1160 FIND v(dout1_15) AT=585.025n

.meas tran vdout1_16ck1160 FIND v(dout1_16) AT=585.025n

.meas tran vdout1_0ck1220 FIND v(dout1_0) AT=615.025n

.meas tran vdout1_1ck1220 FIND v(dout1_1) AT=615.025n

.meas tran vdout1_2ck1220 FIND v(dout1_2) AT=615.025n

.meas tran vdout1_3ck1220 FIND v(dout1_3) AT=615.025n

.meas tran vdout1_4ck1220 FIND v(dout1_4) AT=615.025n

.meas tran vdout1_5ck1220 FIND v(dout1_5) AT=615.025n

.meas tran vdout1_6ck1220 FIND v(dout1_6) AT=615.025n

.meas tran vdout1_7ck1220 FIND v(dout1_7) AT=615.025n

.meas tran vdout1_8ck1220 FIND v(dout1_8) AT=615.025n

.meas tran vdout1_9ck1220 FIND v(dout1_9) AT=615.025n

.meas tran vdout1_10ck1220 FIND v(dout1_10) AT=615.025n

.meas tran vdout1_11ck1220 FIND v(dout1_11) AT=615.025n

.meas tran vdout1_12ck1220 FIND v(dout1_12) AT=615.025n

.meas tran vdout1_13ck1220 FIND v(dout1_13) AT=615.025n

.meas tran vdout1_14ck1220 FIND v(dout1_14) AT=615.025n

.meas tran vdout1_15ck1220 FIND v(dout1_15) AT=615.025n

.meas tran vdout1_16ck1220 FIND v(dout1_16) AT=615.025n

.meas tran vdout1_0ck1230 FIND v(dout1_0) AT=620.025n

.meas tran vdout1_1ck1230 FIND v(dout1_1) AT=620.025n

.meas tran vdout1_2ck1230 FIND v(dout1_2) AT=620.025n

.meas tran vdout1_3ck1230 FIND v(dout1_3) AT=620.025n

.meas tran vdout1_4ck1230 FIND v(dout1_4) AT=620.025n

.meas tran vdout1_5ck1230 FIND v(dout1_5) AT=620.025n

.meas tran vdout1_6ck1230 FIND v(dout1_6) AT=620.025n

.meas tran vdout1_7ck1230 FIND v(dout1_7) AT=620.025n

.meas tran vdout1_8ck1230 FIND v(dout1_8) AT=620.025n

.meas tran vdout1_9ck1230 FIND v(dout1_9) AT=620.025n

.meas tran vdout1_10ck1230 FIND v(dout1_10) AT=620.025n

.meas tran vdout1_11ck1230 FIND v(dout1_11) AT=620.025n

.meas tran vdout1_12ck1230 FIND v(dout1_12) AT=620.025n

.meas tran vdout1_13ck1230 FIND v(dout1_13) AT=620.025n

.meas tran vdout1_14ck1230 FIND v(dout1_14) AT=620.025n

.meas tran vdout1_15ck1230 FIND v(dout1_15) AT=620.025n

.meas tran vdout1_16ck1230 FIND v(dout1_16) AT=620.025n

.meas tran vdout1_0ck1240 FIND v(dout1_0) AT=625.025n

.meas tran vdout1_1ck1240 FIND v(dout1_1) AT=625.025n

.meas tran vdout1_2ck1240 FIND v(dout1_2) AT=625.025n

.meas tran vdout1_3ck1240 FIND v(dout1_3) AT=625.025n

.meas tran vdout1_4ck1240 FIND v(dout1_4) AT=625.025n

.meas tran vdout1_5ck1240 FIND v(dout1_5) AT=625.025n

.meas tran vdout1_6ck1240 FIND v(dout1_6) AT=625.025n

.meas tran vdout1_7ck1240 FIND v(dout1_7) AT=625.025n

.meas tran vdout1_8ck1240 FIND v(dout1_8) AT=625.025n

.meas tran vdout1_9ck1240 FIND v(dout1_9) AT=625.025n

.meas tran vdout1_10ck1240 FIND v(dout1_10) AT=625.025n

.meas tran vdout1_11ck1240 FIND v(dout1_11) AT=625.025n

.meas tran vdout1_12ck1240 FIND v(dout1_12) AT=625.025n

.meas tran vdout1_13ck1240 FIND v(dout1_13) AT=625.025n

.meas tran vdout1_14ck1240 FIND v(dout1_14) AT=625.025n

.meas tran vdout1_15ck1240 FIND v(dout1_15) AT=625.025n

.meas tran vdout1_16ck1240 FIND v(dout1_16) AT=625.025n

.meas tran vdout1_0ck1250 FIND v(dout1_0) AT=630.025n

.meas tran vdout1_1ck1250 FIND v(dout1_1) AT=630.025n

.meas tran vdout1_2ck1250 FIND v(dout1_2) AT=630.025n

.meas tran vdout1_3ck1250 FIND v(dout1_3) AT=630.025n

.meas tran vdout1_4ck1250 FIND v(dout1_4) AT=630.025n

.meas tran vdout1_5ck1250 FIND v(dout1_5) AT=630.025n

.meas tran vdout1_6ck1250 FIND v(dout1_6) AT=630.025n

.meas tran vdout1_7ck1250 FIND v(dout1_7) AT=630.025n

.meas tran vdout1_8ck1250 FIND v(dout1_8) AT=630.025n

.meas tran vdout1_9ck1250 FIND v(dout1_9) AT=630.025n

.meas tran vdout1_10ck1250 FIND v(dout1_10) AT=630.025n

.meas tran vdout1_11ck1250 FIND v(dout1_11) AT=630.025n

.meas tran vdout1_12ck1250 FIND v(dout1_12) AT=630.025n

.meas tran vdout1_13ck1250 FIND v(dout1_13) AT=630.025n

.meas tran vdout1_14ck1250 FIND v(dout1_14) AT=630.025n

.meas tran vdout1_15ck1250 FIND v(dout1_15) AT=630.025n

.meas tran vdout1_16ck1250 FIND v(dout1_16) AT=630.025n

.meas tran vdout1_0ck1260 FIND v(dout1_0) AT=635.025n

.meas tran vdout1_1ck1260 FIND v(dout1_1) AT=635.025n

.meas tran vdout1_2ck1260 FIND v(dout1_2) AT=635.025n

.meas tran vdout1_3ck1260 FIND v(dout1_3) AT=635.025n

.meas tran vdout1_4ck1260 FIND v(dout1_4) AT=635.025n

.meas tran vdout1_5ck1260 FIND v(dout1_5) AT=635.025n

.meas tran vdout1_6ck1260 FIND v(dout1_6) AT=635.025n

.meas tran vdout1_7ck1260 FIND v(dout1_7) AT=635.025n

.meas tran vdout1_8ck1260 FIND v(dout1_8) AT=635.025n

.meas tran vdout1_9ck1260 FIND v(dout1_9) AT=635.025n

.meas tran vdout1_10ck1260 FIND v(dout1_10) AT=635.025n

.meas tran vdout1_11ck1260 FIND v(dout1_11) AT=635.025n

.meas tran vdout1_12ck1260 FIND v(dout1_12) AT=635.025n

.meas tran vdout1_13ck1260 FIND v(dout1_13) AT=635.025n

.meas tran vdout1_14ck1260 FIND v(dout1_14) AT=635.025n

.meas tran vdout1_15ck1260 FIND v(dout1_15) AT=635.025n

.meas tran vdout1_16ck1260 FIND v(dout1_16) AT=635.025n

.meas tran vdout1_0ck1270 FIND v(dout1_0) AT=640.025n

.meas tran vdout1_1ck1270 FIND v(dout1_1) AT=640.025n

.meas tran vdout1_2ck1270 FIND v(dout1_2) AT=640.025n

.meas tran vdout1_3ck1270 FIND v(dout1_3) AT=640.025n

.meas tran vdout1_4ck1270 FIND v(dout1_4) AT=640.025n

.meas tran vdout1_5ck1270 FIND v(dout1_5) AT=640.025n

.meas tran vdout1_6ck1270 FIND v(dout1_6) AT=640.025n

.meas tran vdout1_7ck1270 FIND v(dout1_7) AT=640.025n

.meas tran vdout1_8ck1270 FIND v(dout1_8) AT=640.025n

.meas tran vdout1_9ck1270 FIND v(dout1_9) AT=640.025n

.meas tran vdout1_10ck1270 FIND v(dout1_10) AT=640.025n

.meas tran vdout1_11ck1270 FIND v(dout1_11) AT=640.025n

.meas tran vdout1_12ck1270 FIND v(dout1_12) AT=640.025n

.meas tran vdout1_13ck1270 FIND v(dout1_13) AT=640.025n

.meas tran vdout1_14ck1270 FIND v(dout1_14) AT=640.025n

.meas tran vdout1_15ck1270 FIND v(dout1_15) AT=640.025n

.meas tran vdout1_16ck1270 FIND v(dout1_16) AT=640.025n

.meas tran vdout1_0ck1290 FIND v(dout1_0) AT=650.025n

.meas tran vdout1_1ck1290 FIND v(dout1_1) AT=650.025n

.meas tran vdout1_2ck1290 FIND v(dout1_2) AT=650.025n

.meas tran vdout1_3ck1290 FIND v(dout1_3) AT=650.025n

.meas tran vdout1_4ck1290 FIND v(dout1_4) AT=650.025n

.meas tran vdout1_5ck1290 FIND v(dout1_5) AT=650.025n

.meas tran vdout1_6ck1290 FIND v(dout1_6) AT=650.025n

.meas tran vdout1_7ck1290 FIND v(dout1_7) AT=650.025n

.meas tran vdout1_8ck1290 FIND v(dout1_8) AT=650.025n

.meas tran vdout1_9ck1290 FIND v(dout1_9) AT=650.025n

.meas tran vdout1_10ck1290 FIND v(dout1_10) AT=650.025n

.meas tran vdout1_11ck1290 FIND v(dout1_11) AT=650.025n

.meas tran vdout1_12ck1290 FIND v(dout1_12) AT=650.025n

.meas tran vdout1_13ck1290 FIND v(dout1_13) AT=650.025n

.meas tran vdout1_14ck1290 FIND v(dout1_14) AT=650.025n

.meas tran vdout1_15ck1290 FIND v(dout1_15) AT=650.025n

.meas tran vdout1_16ck1290 FIND v(dout1_16) AT=650.025n

.meas tran vdout1_0ck1300 FIND v(dout1_0) AT=655.025n

.meas tran vdout1_1ck1300 FIND v(dout1_1) AT=655.025n

.meas tran vdout1_2ck1300 FIND v(dout1_2) AT=655.025n

.meas tran vdout1_3ck1300 FIND v(dout1_3) AT=655.025n

.meas tran vdout1_4ck1300 FIND v(dout1_4) AT=655.025n

.meas tran vdout1_5ck1300 FIND v(dout1_5) AT=655.025n

.meas tran vdout1_6ck1300 FIND v(dout1_6) AT=655.025n

.meas tran vdout1_7ck1300 FIND v(dout1_7) AT=655.025n

.meas tran vdout1_8ck1300 FIND v(dout1_8) AT=655.025n

.meas tran vdout1_9ck1300 FIND v(dout1_9) AT=655.025n

.meas tran vdout1_10ck1300 FIND v(dout1_10) AT=655.025n

.meas tran vdout1_11ck1300 FIND v(dout1_11) AT=655.025n

.meas tran vdout1_12ck1300 FIND v(dout1_12) AT=655.025n

.meas tran vdout1_13ck1300 FIND v(dout1_13) AT=655.025n

.meas tran vdout1_14ck1300 FIND v(dout1_14) AT=655.025n

.meas tran vdout1_15ck1300 FIND v(dout1_15) AT=655.025n

.meas tran vdout1_16ck1300 FIND v(dout1_16) AT=655.025n

.meas tran vdout1_0ck1310 FIND v(dout1_0) AT=660.025n

.meas tran vdout1_1ck1310 FIND v(dout1_1) AT=660.025n

.meas tran vdout1_2ck1310 FIND v(dout1_2) AT=660.025n

.meas tran vdout1_3ck1310 FIND v(dout1_3) AT=660.025n

.meas tran vdout1_4ck1310 FIND v(dout1_4) AT=660.025n

.meas tran vdout1_5ck1310 FIND v(dout1_5) AT=660.025n

.meas tran vdout1_6ck1310 FIND v(dout1_6) AT=660.025n

.meas tran vdout1_7ck1310 FIND v(dout1_7) AT=660.025n

.meas tran vdout1_8ck1310 FIND v(dout1_8) AT=660.025n

.meas tran vdout1_9ck1310 FIND v(dout1_9) AT=660.025n

.meas tran vdout1_10ck1310 FIND v(dout1_10) AT=660.025n

.meas tran vdout1_11ck1310 FIND v(dout1_11) AT=660.025n

.meas tran vdout1_12ck1310 FIND v(dout1_12) AT=660.025n

.meas tran vdout1_13ck1310 FIND v(dout1_13) AT=660.025n

.meas tran vdout1_14ck1310 FIND v(dout1_14) AT=660.025n

.meas tran vdout1_15ck1310 FIND v(dout1_15) AT=660.025n

.meas tran vdout1_16ck1310 FIND v(dout1_16) AT=660.025n

.meas tran vdout1_0ck1320 FIND v(dout1_0) AT=665.025n

.meas tran vdout1_1ck1320 FIND v(dout1_1) AT=665.025n

.meas tran vdout1_2ck1320 FIND v(dout1_2) AT=665.025n

.meas tran vdout1_3ck1320 FIND v(dout1_3) AT=665.025n

.meas tran vdout1_4ck1320 FIND v(dout1_4) AT=665.025n

.meas tran vdout1_5ck1320 FIND v(dout1_5) AT=665.025n

.meas tran vdout1_6ck1320 FIND v(dout1_6) AT=665.025n

.meas tran vdout1_7ck1320 FIND v(dout1_7) AT=665.025n

.meas tran vdout1_8ck1320 FIND v(dout1_8) AT=665.025n

.meas tran vdout1_9ck1320 FIND v(dout1_9) AT=665.025n

.meas tran vdout1_10ck1320 FIND v(dout1_10) AT=665.025n

.meas tran vdout1_11ck1320 FIND v(dout1_11) AT=665.025n

.meas tran vdout1_12ck1320 FIND v(dout1_12) AT=665.025n

.meas tran vdout1_13ck1320 FIND v(dout1_13) AT=665.025n

.meas tran vdout1_14ck1320 FIND v(dout1_14) AT=665.025n

.meas tran vdout1_15ck1320 FIND v(dout1_15) AT=665.025n

.meas tran vdout1_16ck1320 FIND v(dout1_16) AT=665.025n

.meas tran vdout1_0ck1340 FIND v(dout1_0) AT=675.025n

.meas tran vdout1_1ck1340 FIND v(dout1_1) AT=675.025n

.meas tran vdout1_2ck1340 FIND v(dout1_2) AT=675.025n

.meas tran vdout1_3ck1340 FIND v(dout1_3) AT=675.025n

.meas tran vdout1_4ck1340 FIND v(dout1_4) AT=675.025n

.meas tran vdout1_5ck1340 FIND v(dout1_5) AT=675.025n

.meas tran vdout1_6ck1340 FIND v(dout1_6) AT=675.025n

.meas tran vdout1_7ck1340 FIND v(dout1_7) AT=675.025n

.meas tran vdout1_8ck1340 FIND v(dout1_8) AT=675.025n

.meas tran vdout1_9ck1340 FIND v(dout1_9) AT=675.025n

.meas tran vdout1_10ck1340 FIND v(dout1_10) AT=675.025n

.meas tran vdout1_11ck1340 FIND v(dout1_11) AT=675.025n

.meas tran vdout1_12ck1340 FIND v(dout1_12) AT=675.025n

.meas tran vdout1_13ck1340 FIND v(dout1_13) AT=675.025n

.meas tran vdout1_14ck1340 FIND v(dout1_14) AT=675.025n

.meas tran vdout1_15ck1340 FIND v(dout1_15) AT=675.025n

.meas tran vdout1_16ck1340 FIND v(dout1_16) AT=675.025n

.meas tran vdout1_0ck1350 FIND v(dout1_0) AT=680.025n

.meas tran vdout1_1ck1350 FIND v(dout1_1) AT=680.025n

.meas tran vdout1_2ck1350 FIND v(dout1_2) AT=680.025n

.meas tran vdout1_3ck1350 FIND v(dout1_3) AT=680.025n

.meas tran vdout1_4ck1350 FIND v(dout1_4) AT=680.025n

.meas tran vdout1_5ck1350 FIND v(dout1_5) AT=680.025n

.meas tran vdout1_6ck1350 FIND v(dout1_6) AT=680.025n

.meas tran vdout1_7ck1350 FIND v(dout1_7) AT=680.025n

.meas tran vdout1_8ck1350 FIND v(dout1_8) AT=680.025n

.meas tran vdout1_9ck1350 FIND v(dout1_9) AT=680.025n

.meas tran vdout1_10ck1350 FIND v(dout1_10) AT=680.025n

.meas tran vdout1_11ck1350 FIND v(dout1_11) AT=680.025n

.meas tran vdout1_12ck1350 FIND v(dout1_12) AT=680.025n

.meas tran vdout1_13ck1350 FIND v(dout1_13) AT=680.025n

.meas tran vdout1_14ck1350 FIND v(dout1_14) AT=680.025n

.meas tran vdout1_15ck1350 FIND v(dout1_15) AT=680.025n

.meas tran vdout1_16ck1350 FIND v(dout1_16) AT=680.025n

.meas tran vdout1_0ck1360 FIND v(dout1_0) AT=685.025n

.meas tran vdout1_1ck1360 FIND v(dout1_1) AT=685.025n

.meas tran vdout1_2ck1360 FIND v(dout1_2) AT=685.025n

.meas tran vdout1_3ck1360 FIND v(dout1_3) AT=685.025n

.meas tran vdout1_4ck1360 FIND v(dout1_4) AT=685.025n

.meas tran vdout1_5ck1360 FIND v(dout1_5) AT=685.025n

.meas tran vdout1_6ck1360 FIND v(dout1_6) AT=685.025n

.meas tran vdout1_7ck1360 FIND v(dout1_7) AT=685.025n

.meas tran vdout1_8ck1360 FIND v(dout1_8) AT=685.025n

.meas tran vdout1_9ck1360 FIND v(dout1_9) AT=685.025n

.meas tran vdout1_10ck1360 FIND v(dout1_10) AT=685.025n

.meas tran vdout1_11ck1360 FIND v(dout1_11) AT=685.025n

.meas tran vdout1_12ck1360 FIND v(dout1_12) AT=685.025n

.meas tran vdout1_13ck1360 FIND v(dout1_13) AT=685.025n

.meas tran vdout1_14ck1360 FIND v(dout1_14) AT=685.025n

.meas tran vdout1_15ck1360 FIND v(dout1_15) AT=685.025n

.meas tran vdout1_16ck1360 FIND v(dout1_16) AT=685.025n

.meas tran vdout1_0ck1370 FIND v(dout1_0) AT=690.025n

.meas tran vdout1_1ck1370 FIND v(dout1_1) AT=690.025n

.meas tran vdout1_2ck1370 FIND v(dout1_2) AT=690.025n

.meas tran vdout1_3ck1370 FIND v(dout1_3) AT=690.025n

.meas tran vdout1_4ck1370 FIND v(dout1_4) AT=690.025n

.meas tran vdout1_5ck1370 FIND v(dout1_5) AT=690.025n

.meas tran vdout1_6ck1370 FIND v(dout1_6) AT=690.025n

.meas tran vdout1_7ck1370 FIND v(dout1_7) AT=690.025n

.meas tran vdout1_8ck1370 FIND v(dout1_8) AT=690.025n

.meas tran vdout1_9ck1370 FIND v(dout1_9) AT=690.025n

.meas tran vdout1_10ck1370 FIND v(dout1_10) AT=690.025n

.meas tran vdout1_11ck1370 FIND v(dout1_11) AT=690.025n

.meas tran vdout1_12ck1370 FIND v(dout1_12) AT=690.025n

.meas tran vdout1_13ck1370 FIND v(dout1_13) AT=690.025n

.meas tran vdout1_14ck1370 FIND v(dout1_14) AT=690.025n

.meas tran vdout1_15ck1370 FIND v(dout1_15) AT=690.025n

.meas tran vdout1_16ck1370 FIND v(dout1_16) AT=690.025n

.meas tran vdout1_0ck1390 FIND v(dout1_0) AT=700.025n

.meas tran vdout1_1ck1390 FIND v(dout1_1) AT=700.025n

.meas tran vdout1_2ck1390 FIND v(dout1_2) AT=700.025n

.meas tran vdout1_3ck1390 FIND v(dout1_3) AT=700.025n

.meas tran vdout1_4ck1390 FIND v(dout1_4) AT=700.025n

.meas tran vdout1_5ck1390 FIND v(dout1_5) AT=700.025n

.meas tran vdout1_6ck1390 FIND v(dout1_6) AT=700.025n

.meas tran vdout1_7ck1390 FIND v(dout1_7) AT=700.025n

.meas tran vdout1_8ck1390 FIND v(dout1_8) AT=700.025n

.meas tran vdout1_9ck1390 FIND v(dout1_9) AT=700.025n

.meas tran vdout1_10ck1390 FIND v(dout1_10) AT=700.025n

.meas tran vdout1_11ck1390 FIND v(dout1_11) AT=700.025n

.meas tran vdout1_12ck1390 FIND v(dout1_12) AT=700.025n

.meas tran vdout1_13ck1390 FIND v(dout1_13) AT=700.025n

.meas tran vdout1_14ck1390 FIND v(dout1_14) AT=700.025n

.meas tran vdout1_15ck1390 FIND v(dout1_15) AT=700.025n

.meas tran vdout1_16ck1390 FIND v(dout1_16) AT=700.025n

.meas tran vdout1_0ck1420 FIND v(dout1_0) AT=715.025n

.meas tran vdout1_1ck1420 FIND v(dout1_1) AT=715.025n

.meas tran vdout1_2ck1420 FIND v(dout1_2) AT=715.025n

.meas tran vdout1_3ck1420 FIND v(dout1_3) AT=715.025n

.meas tran vdout1_4ck1420 FIND v(dout1_4) AT=715.025n

.meas tran vdout1_5ck1420 FIND v(dout1_5) AT=715.025n

.meas tran vdout1_6ck1420 FIND v(dout1_6) AT=715.025n

.meas tran vdout1_7ck1420 FIND v(dout1_7) AT=715.025n

.meas tran vdout1_8ck1420 FIND v(dout1_8) AT=715.025n

.meas tran vdout1_9ck1420 FIND v(dout1_9) AT=715.025n

.meas tran vdout1_10ck1420 FIND v(dout1_10) AT=715.025n

.meas tran vdout1_11ck1420 FIND v(dout1_11) AT=715.025n

.meas tran vdout1_12ck1420 FIND v(dout1_12) AT=715.025n

.meas tran vdout1_13ck1420 FIND v(dout1_13) AT=715.025n

.meas tran vdout1_14ck1420 FIND v(dout1_14) AT=715.025n

.meas tran vdout1_15ck1420 FIND v(dout1_15) AT=715.025n

.meas tran vdout1_16ck1420 FIND v(dout1_16) AT=715.025n

.meas tran vdout1_0ck1450 FIND v(dout1_0) AT=730.025n

.meas tran vdout1_1ck1450 FIND v(dout1_1) AT=730.025n

.meas tran vdout1_2ck1450 FIND v(dout1_2) AT=730.025n

.meas tran vdout1_3ck1450 FIND v(dout1_3) AT=730.025n

.meas tran vdout1_4ck1450 FIND v(dout1_4) AT=730.025n

.meas tran vdout1_5ck1450 FIND v(dout1_5) AT=730.025n

.meas tran vdout1_6ck1450 FIND v(dout1_6) AT=730.025n

.meas tran vdout1_7ck1450 FIND v(dout1_7) AT=730.025n

.meas tran vdout1_8ck1450 FIND v(dout1_8) AT=730.025n

.meas tran vdout1_9ck1450 FIND v(dout1_9) AT=730.025n

.meas tran vdout1_10ck1450 FIND v(dout1_10) AT=730.025n

.meas tran vdout1_11ck1450 FIND v(dout1_11) AT=730.025n

.meas tran vdout1_12ck1450 FIND v(dout1_12) AT=730.025n

.meas tran vdout1_13ck1450 FIND v(dout1_13) AT=730.025n

.meas tran vdout1_14ck1450 FIND v(dout1_14) AT=730.025n

.meas tran vdout1_15ck1450 FIND v(dout1_15) AT=730.025n

.meas tran vdout1_16ck1450 FIND v(dout1_16) AT=730.025n

.meas tran vdout1_0ck1460 FIND v(dout1_0) AT=735.025n

.meas tran vdout1_1ck1460 FIND v(dout1_1) AT=735.025n

.meas tran vdout1_2ck1460 FIND v(dout1_2) AT=735.025n

.meas tran vdout1_3ck1460 FIND v(dout1_3) AT=735.025n

.meas tran vdout1_4ck1460 FIND v(dout1_4) AT=735.025n

.meas tran vdout1_5ck1460 FIND v(dout1_5) AT=735.025n

.meas tran vdout1_6ck1460 FIND v(dout1_6) AT=735.025n

.meas tran vdout1_7ck1460 FIND v(dout1_7) AT=735.025n

.meas tran vdout1_8ck1460 FIND v(dout1_8) AT=735.025n

.meas tran vdout1_9ck1460 FIND v(dout1_9) AT=735.025n

.meas tran vdout1_10ck1460 FIND v(dout1_10) AT=735.025n

.meas tran vdout1_11ck1460 FIND v(dout1_11) AT=735.025n

.meas tran vdout1_12ck1460 FIND v(dout1_12) AT=735.025n

.meas tran vdout1_13ck1460 FIND v(dout1_13) AT=735.025n

.meas tran vdout1_14ck1460 FIND v(dout1_14) AT=735.025n

.meas tran vdout1_15ck1460 FIND v(dout1_15) AT=735.025n

.meas tran vdout1_16ck1460 FIND v(dout1_16) AT=735.025n

.meas tran vdout1_0ck1470 FIND v(dout1_0) AT=740.025n

.meas tran vdout1_1ck1470 FIND v(dout1_1) AT=740.025n

.meas tran vdout1_2ck1470 FIND v(dout1_2) AT=740.025n

.meas tran vdout1_3ck1470 FIND v(dout1_3) AT=740.025n

.meas tran vdout1_4ck1470 FIND v(dout1_4) AT=740.025n

.meas tran vdout1_5ck1470 FIND v(dout1_5) AT=740.025n

.meas tran vdout1_6ck1470 FIND v(dout1_6) AT=740.025n

.meas tran vdout1_7ck1470 FIND v(dout1_7) AT=740.025n

.meas tran vdout1_8ck1470 FIND v(dout1_8) AT=740.025n

.meas tran vdout1_9ck1470 FIND v(dout1_9) AT=740.025n

.meas tran vdout1_10ck1470 FIND v(dout1_10) AT=740.025n

.meas tran vdout1_11ck1470 FIND v(dout1_11) AT=740.025n

.meas tran vdout1_12ck1470 FIND v(dout1_12) AT=740.025n

.meas tran vdout1_13ck1470 FIND v(dout1_13) AT=740.025n

.meas tran vdout1_14ck1470 FIND v(dout1_14) AT=740.025n

.meas tran vdout1_15ck1470 FIND v(dout1_15) AT=740.025n

.meas tran vdout1_16ck1470 FIND v(dout1_16) AT=740.025n

.meas tran vdout1_0ck1480 FIND v(dout1_0) AT=745.025n

.meas tran vdout1_1ck1480 FIND v(dout1_1) AT=745.025n

.meas tran vdout1_2ck1480 FIND v(dout1_2) AT=745.025n

.meas tran vdout1_3ck1480 FIND v(dout1_3) AT=745.025n

.meas tran vdout1_4ck1480 FIND v(dout1_4) AT=745.025n

.meas tran vdout1_5ck1480 FIND v(dout1_5) AT=745.025n

.meas tran vdout1_6ck1480 FIND v(dout1_6) AT=745.025n

.meas tran vdout1_7ck1480 FIND v(dout1_7) AT=745.025n

.meas tran vdout1_8ck1480 FIND v(dout1_8) AT=745.025n

.meas tran vdout1_9ck1480 FIND v(dout1_9) AT=745.025n

.meas tran vdout1_10ck1480 FIND v(dout1_10) AT=745.025n

.meas tran vdout1_11ck1480 FIND v(dout1_11) AT=745.025n

.meas tran vdout1_12ck1480 FIND v(dout1_12) AT=745.025n

.meas tran vdout1_13ck1480 FIND v(dout1_13) AT=745.025n

.meas tran vdout1_14ck1480 FIND v(dout1_14) AT=745.025n

.meas tran vdout1_15ck1480 FIND v(dout1_15) AT=745.025n

.meas tran vdout1_16ck1480 FIND v(dout1_16) AT=745.025n

.meas tran vdout1_0ck1490 FIND v(dout1_0) AT=750.025n

.meas tran vdout1_1ck1490 FIND v(dout1_1) AT=750.025n

.meas tran vdout1_2ck1490 FIND v(dout1_2) AT=750.025n

.meas tran vdout1_3ck1490 FIND v(dout1_3) AT=750.025n

.meas tran vdout1_4ck1490 FIND v(dout1_4) AT=750.025n

.meas tran vdout1_5ck1490 FIND v(dout1_5) AT=750.025n

.meas tran vdout1_6ck1490 FIND v(dout1_6) AT=750.025n

.meas tran vdout1_7ck1490 FIND v(dout1_7) AT=750.025n

.meas tran vdout1_8ck1490 FIND v(dout1_8) AT=750.025n

.meas tran vdout1_9ck1490 FIND v(dout1_9) AT=750.025n

.meas tran vdout1_10ck1490 FIND v(dout1_10) AT=750.025n

.meas tran vdout1_11ck1490 FIND v(dout1_11) AT=750.025n

.meas tran vdout1_12ck1490 FIND v(dout1_12) AT=750.025n

.meas tran vdout1_13ck1490 FIND v(dout1_13) AT=750.025n

.meas tran vdout1_14ck1490 FIND v(dout1_14) AT=750.025n

.meas tran vdout1_15ck1490 FIND v(dout1_15) AT=750.025n

.meas tran vdout1_16ck1490 FIND v(dout1_16) AT=750.025n

.meas tran vdout1_0ck1540 FIND v(dout1_0) AT=775.025n

.meas tran vdout1_1ck1540 FIND v(dout1_1) AT=775.025n

.meas tran vdout1_2ck1540 FIND v(dout1_2) AT=775.025n

.meas tran vdout1_3ck1540 FIND v(dout1_3) AT=775.025n

.meas tran vdout1_4ck1540 FIND v(dout1_4) AT=775.025n

.meas tran vdout1_5ck1540 FIND v(dout1_5) AT=775.025n

.meas tran vdout1_6ck1540 FIND v(dout1_6) AT=775.025n

.meas tran vdout1_7ck1540 FIND v(dout1_7) AT=775.025n

.meas tran vdout1_8ck1540 FIND v(dout1_8) AT=775.025n

.meas tran vdout1_9ck1540 FIND v(dout1_9) AT=775.025n

.meas tran vdout1_10ck1540 FIND v(dout1_10) AT=775.025n

.meas tran vdout1_11ck1540 FIND v(dout1_11) AT=775.025n

.meas tran vdout1_12ck1540 FIND v(dout1_12) AT=775.025n

.meas tran vdout1_13ck1540 FIND v(dout1_13) AT=775.025n

.meas tran vdout1_14ck1540 FIND v(dout1_14) AT=775.025n

.meas tran vdout1_15ck1540 FIND v(dout1_15) AT=775.025n

.meas tran vdout1_16ck1540 FIND v(dout1_16) AT=775.025n

.meas tran vdout1_0ck1560 FIND v(dout1_0) AT=785.025n

.meas tran vdout1_1ck1560 FIND v(dout1_1) AT=785.025n

.meas tran vdout1_2ck1560 FIND v(dout1_2) AT=785.025n

.meas tran vdout1_3ck1560 FIND v(dout1_3) AT=785.025n

.meas tran vdout1_4ck1560 FIND v(dout1_4) AT=785.025n

.meas tran vdout1_5ck1560 FIND v(dout1_5) AT=785.025n

.meas tran vdout1_6ck1560 FIND v(dout1_6) AT=785.025n

.meas tran vdout1_7ck1560 FIND v(dout1_7) AT=785.025n

.meas tran vdout1_8ck1560 FIND v(dout1_8) AT=785.025n

.meas tran vdout1_9ck1560 FIND v(dout1_9) AT=785.025n

.meas tran vdout1_10ck1560 FIND v(dout1_10) AT=785.025n

.meas tran vdout1_11ck1560 FIND v(dout1_11) AT=785.025n

.meas tran vdout1_12ck1560 FIND v(dout1_12) AT=785.025n

.meas tran vdout1_13ck1560 FIND v(dout1_13) AT=785.025n

.meas tran vdout1_14ck1560 FIND v(dout1_14) AT=785.025n

.meas tran vdout1_15ck1560 FIND v(dout1_15) AT=785.025n

.meas tran vdout1_16ck1560 FIND v(dout1_16) AT=785.025n

.meas tran vdout1_0ck1570 FIND v(dout1_0) AT=790.025n

.meas tran vdout1_1ck1570 FIND v(dout1_1) AT=790.025n

.meas tran vdout1_2ck1570 FIND v(dout1_2) AT=790.025n

.meas tran vdout1_3ck1570 FIND v(dout1_3) AT=790.025n

.meas tran vdout1_4ck1570 FIND v(dout1_4) AT=790.025n

.meas tran vdout1_5ck1570 FIND v(dout1_5) AT=790.025n

.meas tran vdout1_6ck1570 FIND v(dout1_6) AT=790.025n

.meas tran vdout1_7ck1570 FIND v(dout1_7) AT=790.025n

.meas tran vdout1_8ck1570 FIND v(dout1_8) AT=790.025n

.meas tran vdout1_9ck1570 FIND v(dout1_9) AT=790.025n

.meas tran vdout1_10ck1570 FIND v(dout1_10) AT=790.025n

.meas tran vdout1_11ck1570 FIND v(dout1_11) AT=790.025n

.meas tran vdout1_12ck1570 FIND v(dout1_12) AT=790.025n

.meas tran vdout1_13ck1570 FIND v(dout1_13) AT=790.025n

.meas tran vdout1_14ck1570 FIND v(dout1_14) AT=790.025n

.meas tran vdout1_15ck1570 FIND v(dout1_15) AT=790.025n

.meas tran vdout1_16ck1570 FIND v(dout1_16) AT=790.025n

.meas tran vdout1_0ck1580 FIND v(dout1_0) AT=795.025n

.meas tran vdout1_1ck1580 FIND v(dout1_1) AT=795.025n

.meas tran vdout1_2ck1580 FIND v(dout1_2) AT=795.025n

.meas tran vdout1_3ck1580 FIND v(dout1_3) AT=795.025n

.meas tran vdout1_4ck1580 FIND v(dout1_4) AT=795.025n

.meas tran vdout1_5ck1580 FIND v(dout1_5) AT=795.025n

.meas tran vdout1_6ck1580 FIND v(dout1_6) AT=795.025n

.meas tran vdout1_7ck1580 FIND v(dout1_7) AT=795.025n

.meas tran vdout1_8ck1580 FIND v(dout1_8) AT=795.025n

.meas tran vdout1_9ck1580 FIND v(dout1_9) AT=795.025n

.meas tran vdout1_10ck1580 FIND v(dout1_10) AT=795.025n

.meas tran vdout1_11ck1580 FIND v(dout1_11) AT=795.025n

.meas tran vdout1_12ck1580 FIND v(dout1_12) AT=795.025n

.meas tran vdout1_13ck1580 FIND v(dout1_13) AT=795.025n

.meas tran vdout1_14ck1580 FIND v(dout1_14) AT=795.025n

.meas tran vdout1_15ck1580 FIND v(dout1_15) AT=795.025n

.meas tran vdout1_16ck1580 FIND v(dout1_16) AT=795.025n

.meas tran vdout1_0ck1590 FIND v(dout1_0) AT=800.025n

.meas tran vdout1_1ck1590 FIND v(dout1_1) AT=800.025n

.meas tran vdout1_2ck1590 FIND v(dout1_2) AT=800.025n

.meas tran vdout1_3ck1590 FIND v(dout1_3) AT=800.025n

.meas tran vdout1_4ck1590 FIND v(dout1_4) AT=800.025n

.meas tran vdout1_5ck1590 FIND v(dout1_5) AT=800.025n

.meas tran vdout1_6ck1590 FIND v(dout1_6) AT=800.025n

.meas tran vdout1_7ck1590 FIND v(dout1_7) AT=800.025n

.meas tran vdout1_8ck1590 FIND v(dout1_8) AT=800.025n

.meas tran vdout1_9ck1590 FIND v(dout1_9) AT=800.025n

.meas tran vdout1_10ck1590 FIND v(dout1_10) AT=800.025n

.meas tran vdout1_11ck1590 FIND v(dout1_11) AT=800.025n

.meas tran vdout1_12ck1590 FIND v(dout1_12) AT=800.025n

.meas tran vdout1_13ck1590 FIND v(dout1_13) AT=800.025n

.meas tran vdout1_14ck1590 FIND v(dout1_14) AT=800.025n

.meas tran vdout1_15ck1590 FIND v(dout1_15) AT=800.025n

.meas tran vdout1_16ck1590 FIND v(dout1_16) AT=800.025n

.meas tran vdout1_0ck1600 FIND v(dout1_0) AT=805.025n

.meas tran vdout1_1ck1600 FIND v(dout1_1) AT=805.025n

.meas tran vdout1_2ck1600 FIND v(dout1_2) AT=805.025n

.meas tran vdout1_3ck1600 FIND v(dout1_3) AT=805.025n

.meas tran vdout1_4ck1600 FIND v(dout1_4) AT=805.025n

.meas tran vdout1_5ck1600 FIND v(dout1_5) AT=805.025n

.meas tran vdout1_6ck1600 FIND v(dout1_6) AT=805.025n

.meas tran vdout1_7ck1600 FIND v(dout1_7) AT=805.025n

.meas tran vdout1_8ck1600 FIND v(dout1_8) AT=805.025n

.meas tran vdout1_9ck1600 FIND v(dout1_9) AT=805.025n

.meas tran vdout1_10ck1600 FIND v(dout1_10) AT=805.025n

.meas tran vdout1_11ck1600 FIND v(dout1_11) AT=805.025n

.meas tran vdout1_12ck1600 FIND v(dout1_12) AT=805.025n

.meas tran vdout1_13ck1600 FIND v(dout1_13) AT=805.025n

.meas tran vdout1_14ck1600 FIND v(dout1_14) AT=805.025n

.meas tran vdout1_15ck1600 FIND v(dout1_15) AT=805.025n

.meas tran vdout1_16ck1600 FIND v(dout1_16) AT=805.025n

.meas tran vdout1_0ck1640 FIND v(dout1_0) AT=825.025n

.meas tran vdout1_1ck1640 FIND v(dout1_1) AT=825.025n

.meas tran vdout1_2ck1640 FIND v(dout1_2) AT=825.025n

.meas tran vdout1_3ck1640 FIND v(dout1_3) AT=825.025n

.meas tran vdout1_4ck1640 FIND v(dout1_4) AT=825.025n

.meas tran vdout1_5ck1640 FIND v(dout1_5) AT=825.025n

.meas tran vdout1_6ck1640 FIND v(dout1_6) AT=825.025n

.meas tran vdout1_7ck1640 FIND v(dout1_7) AT=825.025n

.meas tran vdout1_8ck1640 FIND v(dout1_8) AT=825.025n

.meas tran vdout1_9ck1640 FIND v(dout1_9) AT=825.025n

.meas tran vdout1_10ck1640 FIND v(dout1_10) AT=825.025n

.meas tran vdout1_11ck1640 FIND v(dout1_11) AT=825.025n

.meas tran vdout1_12ck1640 FIND v(dout1_12) AT=825.025n

.meas tran vdout1_13ck1640 FIND v(dout1_13) AT=825.025n

.meas tran vdout1_14ck1640 FIND v(dout1_14) AT=825.025n

.meas tran vdout1_15ck1640 FIND v(dout1_15) AT=825.025n

.meas tran vdout1_16ck1640 FIND v(dout1_16) AT=825.025n

.meas tran vdout1_0ck1650 FIND v(dout1_0) AT=830.025n

.meas tran vdout1_1ck1650 FIND v(dout1_1) AT=830.025n

.meas tran vdout1_2ck1650 FIND v(dout1_2) AT=830.025n

.meas tran vdout1_3ck1650 FIND v(dout1_3) AT=830.025n

.meas tran vdout1_4ck1650 FIND v(dout1_4) AT=830.025n

.meas tran vdout1_5ck1650 FIND v(dout1_5) AT=830.025n

.meas tran vdout1_6ck1650 FIND v(dout1_6) AT=830.025n

.meas tran vdout1_7ck1650 FIND v(dout1_7) AT=830.025n

.meas tran vdout1_8ck1650 FIND v(dout1_8) AT=830.025n

.meas tran vdout1_9ck1650 FIND v(dout1_9) AT=830.025n

.meas tran vdout1_10ck1650 FIND v(dout1_10) AT=830.025n

.meas tran vdout1_11ck1650 FIND v(dout1_11) AT=830.025n

.meas tran vdout1_12ck1650 FIND v(dout1_12) AT=830.025n

.meas tran vdout1_13ck1650 FIND v(dout1_13) AT=830.025n

.meas tran vdout1_14ck1650 FIND v(dout1_14) AT=830.025n

.meas tran vdout1_15ck1650 FIND v(dout1_15) AT=830.025n

.meas tran vdout1_16ck1650 FIND v(dout1_16) AT=830.025n

.meas tran vdout1_0ck1660 FIND v(dout1_0) AT=835.025n

.meas tran vdout1_1ck1660 FIND v(dout1_1) AT=835.025n

.meas tran vdout1_2ck1660 FIND v(dout1_2) AT=835.025n

.meas tran vdout1_3ck1660 FIND v(dout1_3) AT=835.025n

.meas tran vdout1_4ck1660 FIND v(dout1_4) AT=835.025n

.meas tran vdout1_5ck1660 FIND v(dout1_5) AT=835.025n

.meas tran vdout1_6ck1660 FIND v(dout1_6) AT=835.025n

.meas tran vdout1_7ck1660 FIND v(dout1_7) AT=835.025n

.meas tran vdout1_8ck1660 FIND v(dout1_8) AT=835.025n

.meas tran vdout1_9ck1660 FIND v(dout1_9) AT=835.025n

.meas tran vdout1_10ck1660 FIND v(dout1_10) AT=835.025n

.meas tran vdout1_11ck1660 FIND v(dout1_11) AT=835.025n

.meas tran vdout1_12ck1660 FIND v(dout1_12) AT=835.025n

.meas tran vdout1_13ck1660 FIND v(dout1_13) AT=835.025n

.meas tran vdout1_14ck1660 FIND v(dout1_14) AT=835.025n

.meas tran vdout1_15ck1660 FIND v(dout1_15) AT=835.025n

.meas tran vdout1_16ck1660 FIND v(dout1_16) AT=835.025n

.meas tran vdout1_0ck1680 FIND v(dout1_0) AT=845.025n

.meas tran vdout1_1ck1680 FIND v(dout1_1) AT=845.025n

.meas tran vdout1_2ck1680 FIND v(dout1_2) AT=845.025n

.meas tran vdout1_3ck1680 FIND v(dout1_3) AT=845.025n

.meas tran vdout1_4ck1680 FIND v(dout1_4) AT=845.025n

.meas tran vdout1_5ck1680 FIND v(dout1_5) AT=845.025n

.meas tran vdout1_6ck1680 FIND v(dout1_6) AT=845.025n

.meas tran vdout1_7ck1680 FIND v(dout1_7) AT=845.025n

.meas tran vdout1_8ck1680 FIND v(dout1_8) AT=845.025n

.meas tran vdout1_9ck1680 FIND v(dout1_9) AT=845.025n

.meas tran vdout1_10ck1680 FIND v(dout1_10) AT=845.025n

.meas tran vdout1_11ck1680 FIND v(dout1_11) AT=845.025n

.meas tran vdout1_12ck1680 FIND v(dout1_12) AT=845.025n

.meas tran vdout1_13ck1680 FIND v(dout1_13) AT=845.025n

.meas tran vdout1_14ck1680 FIND v(dout1_14) AT=845.025n

.meas tran vdout1_15ck1680 FIND v(dout1_15) AT=845.025n

.meas tran vdout1_16ck1680 FIND v(dout1_16) AT=845.025n

.meas tran vdout1_0ck1690 FIND v(dout1_0) AT=850.025n

.meas tran vdout1_1ck1690 FIND v(dout1_1) AT=850.025n

.meas tran vdout1_2ck1690 FIND v(dout1_2) AT=850.025n

.meas tran vdout1_3ck1690 FIND v(dout1_3) AT=850.025n

.meas tran vdout1_4ck1690 FIND v(dout1_4) AT=850.025n

.meas tran vdout1_5ck1690 FIND v(dout1_5) AT=850.025n

.meas tran vdout1_6ck1690 FIND v(dout1_6) AT=850.025n

.meas tran vdout1_7ck1690 FIND v(dout1_7) AT=850.025n

.meas tran vdout1_8ck1690 FIND v(dout1_8) AT=850.025n

.meas tran vdout1_9ck1690 FIND v(dout1_9) AT=850.025n

.meas tran vdout1_10ck1690 FIND v(dout1_10) AT=850.025n

.meas tran vdout1_11ck1690 FIND v(dout1_11) AT=850.025n

.meas tran vdout1_12ck1690 FIND v(dout1_12) AT=850.025n

.meas tran vdout1_13ck1690 FIND v(dout1_13) AT=850.025n

.meas tran vdout1_14ck1690 FIND v(dout1_14) AT=850.025n

.meas tran vdout1_15ck1690 FIND v(dout1_15) AT=850.025n

.meas tran vdout1_16ck1690 FIND v(dout1_16) AT=850.025n

.meas tran vdout1_0ck1700 FIND v(dout1_0) AT=855.025n

.meas tran vdout1_1ck1700 FIND v(dout1_1) AT=855.025n

.meas tran vdout1_2ck1700 FIND v(dout1_2) AT=855.025n

.meas tran vdout1_3ck1700 FIND v(dout1_3) AT=855.025n

.meas tran vdout1_4ck1700 FIND v(dout1_4) AT=855.025n

.meas tran vdout1_5ck1700 FIND v(dout1_5) AT=855.025n

.meas tran vdout1_6ck1700 FIND v(dout1_6) AT=855.025n

.meas tran vdout1_7ck1700 FIND v(dout1_7) AT=855.025n

.meas tran vdout1_8ck1700 FIND v(dout1_8) AT=855.025n

.meas tran vdout1_9ck1700 FIND v(dout1_9) AT=855.025n

.meas tran vdout1_10ck1700 FIND v(dout1_10) AT=855.025n

.meas tran vdout1_11ck1700 FIND v(dout1_11) AT=855.025n

.meas tran vdout1_12ck1700 FIND v(dout1_12) AT=855.025n

.meas tran vdout1_13ck1700 FIND v(dout1_13) AT=855.025n

.meas tran vdout1_14ck1700 FIND v(dout1_14) AT=855.025n

.meas tran vdout1_15ck1700 FIND v(dout1_15) AT=855.025n

.meas tran vdout1_16ck1700 FIND v(dout1_16) AT=855.025n

.meas tran vdout1_0ck1710 FIND v(dout1_0) AT=860.025n

.meas tran vdout1_1ck1710 FIND v(dout1_1) AT=860.025n

.meas tran vdout1_2ck1710 FIND v(dout1_2) AT=860.025n

.meas tran vdout1_3ck1710 FIND v(dout1_3) AT=860.025n

.meas tran vdout1_4ck1710 FIND v(dout1_4) AT=860.025n

.meas tran vdout1_5ck1710 FIND v(dout1_5) AT=860.025n

.meas tran vdout1_6ck1710 FIND v(dout1_6) AT=860.025n

.meas tran vdout1_7ck1710 FIND v(dout1_7) AT=860.025n

.meas tran vdout1_8ck1710 FIND v(dout1_8) AT=860.025n

.meas tran vdout1_9ck1710 FIND v(dout1_9) AT=860.025n

.meas tran vdout1_10ck1710 FIND v(dout1_10) AT=860.025n

.meas tran vdout1_11ck1710 FIND v(dout1_11) AT=860.025n

.meas tran vdout1_12ck1710 FIND v(dout1_12) AT=860.025n

.meas tran vdout1_13ck1710 FIND v(dout1_13) AT=860.025n

.meas tran vdout1_14ck1710 FIND v(dout1_14) AT=860.025n

.meas tran vdout1_15ck1710 FIND v(dout1_15) AT=860.025n

.meas tran vdout1_16ck1710 FIND v(dout1_16) AT=860.025n

.meas tran vdout1_0ck1720 FIND v(dout1_0) AT=865.025n

.meas tran vdout1_1ck1720 FIND v(dout1_1) AT=865.025n

.meas tran vdout1_2ck1720 FIND v(dout1_2) AT=865.025n

.meas tran vdout1_3ck1720 FIND v(dout1_3) AT=865.025n

.meas tran vdout1_4ck1720 FIND v(dout1_4) AT=865.025n

.meas tran vdout1_5ck1720 FIND v(dout1_5) AT=865.025n

.meas tran vdout1_6ck1720 FIND v(dout1_6) AT=865.025n

.meas tran vdout1_7ck1720 FIND v(dout1_7) AT=865.025n

.meas tran vdout1_8ck1720 FIND v(dout1_8) AT=865.025n

.meas tran vdout1_9ck1720 FIND v(dout1_9) AT=865.025n

.meas tran vdout1_10ck1720 FIND v(dout1_10) AT=865.025n

.meas tran vdout1_11ck1720 FIND v(dout1_11) AT=865.025n

.meas tran vdout1_12ck1720 FIND v(dout1_12) AT=865.025n

.meas tran vdout1_13ck1720 FIND v(dout1_13) AT=865.025n

.meas tran vdout1_14ck1720 FIND v(dout1_14) AT=865.025n

.meas tran vdout1_15ck1720 FIND v(dout1_15) AT=865.025n

.meas tran vdout1_16ck1720 FIND v(dout1_16) AT=865.025n

.meas tran vdout1_0ck1730 FIND v(dout1_0) AT=870.025n

.meas tran vdout1_1ck1730 FIND v(dout1_1) AT=870.025n

.meas tran vdout1_2ck1730 FIND v(dout1_2) AT=870.025n

.meas tran vdout1_3ck1730 FIND v(dout1_3) AT=870.025n

.meas tran vdout1_4ck1730 FIND v(dout1_4) AT=870.025n

.meas tran vdout1_5ck1730 FIND v(dout1_5) AT=870.025n

.meas tran vdout1_6ck1730 FIND v(dout1_6) AT=870.025n

.meas tran vdout1_7ck1730 FIND v(dout1_7) AT=870.025n

.meas tran vdout1_8ck1730 FIND v(dout1_8) AT=870.025n

.meas tran vdout1_9ck1730 FIND v(dout1_9) AT=870.025n

.meas tran vdout1_10ck1730 FIND v(dout1_10) AT=870.025n

.meas tran vdout1_11ck1730 FIND v(dout1_11) AT=870.025n

.meas tran vdout1_12ck1730 FIND v(dout1_12) AT=870.025n

.meas tran vdout1_13ck1730 FIND v(dout1_13) AT=870.025n

.meas tran vdout1_14ck1730 FIND v(dout1_14) AT=870.025n

.meas tran vdout1_15ck1730 FIND v(dout1_15) AT=870.025n

.meas tran vdout1_16ck1730 FIND v(dout1_16) AT=870.025n

.meas tran vdout1_0ck1760 FIND v(dout1_0) AT=885.025n

.meas tran vdout1_1ck1760 FIND v(dout1_1) AT=885.025n

.meas tran vdout1_2ck1760 FIND v(dout1_2) AT=885.025n

.meas tran vdout1_3ck1760 FIND v(dout1_3) AT=885.025n

.meas tran vdout1_4ck1760 FIND v(dout1_4) AT=885.025n

.meas tran vdout1_5ck1760 FIND v(dout1_5) AT=885.025n

.meas tran vdout1_6ck1760 FIND v(dout1_6) AT=885.025n

.meas tran vdout1_7ck1760 FIND v(dout1_7) AT=885.025n

.meas tran vdout1_8ck1760 FIND v(dout1_8) AT=885.025n

.meas tran vdout1_9ck1760 FIND v(dout1_9) AT=885.025n

.meas tran vdout1_10ck1760 FIND v(dout1_10) AT=885.025n

.meas tran vdout1_11ck1760 FIND v(dout1_11) AT=885.025n

.meas tran vdout1_12ck1760 FIND v(dout1_12) AT=885.025n

.meas tran vdout1_13ck1760 FIND v(dout1_13) AT=885.025n

.meas tran vdout1_14ck1760 FIND v(dout1_14) AT=885.025n

.meas tran vdout1_15ck1760 FIND v(dout1_15) AT=885.025n

.meas tran vdout1_16ck1760 FIND v(dout1_16) AT=885.025n

.meas tran vdout1_0ck1790 FIND v(dout1_0) AT=900.025n

.meas tran vdout1_1ck1790 FIND v(dout1_1) AT=900.025n

.meas tran vdout1_2ck1790 FIND v(dout1_2) AT=900.025n

.meas tran vdout1_3ck1790 FIND v(dout1_3) AT=900.025n

.meas tran vdout1_4ck1790 FIND v(dout1_4) AT=900.025n

.meas tran vdout1_5ck1790 FIND v(dout1_5) AT=900.025n

.meas tran vdout1_6ck1790 FIND v(dout1_6) AT=900.025n

.meas tran vdout1_7ck1790 FIND v(dout1_7) AT=900.025n

.meas tran vdout1_8ck1790 FIND v(dout1_8) AT=900.025n

.meas tran vdout1_9ck1790 FIND v(dout1_9) AT=900.025n

.meas tran vdout1_10ck1790 FIND v(dout1_10) AT=900.025n

.meas tran vdout1_11ck1790 FIND v(dout1_11) AT=900.025n

.meas tran vdout1_12ck1790 FIND v(dout1_12) AT=900.025n

.meas tran vdout1_13ck1790 FIND v(dout1_13) AT=900.025n

.meas tran vdout1_14ck1790 FIND v(dout1_14) AT=900.025n

.meas tran vdout1_15ck1790 FIND v(dout1_15) AT=900.025n

.meas tran vdout1_16ck1790 FIND v(dout1_16) AT=900.025n

.meas tran vdout1_0ck1810 FIND v(dout1_0) AT=910.025n

.meas tran vdout1_1ck1810 FIND v(dout1_1) AT=910.025n

.meas tran vdout1_2ck1810 FIND v(dout1_2) AT=910.025n

.meas tran vdout1_3ck1810 FIND v(dout1_3) AT=910.025n

.meas tran vdout1_4ck1810 FIND v(dout1_4) AT=910.025n

.meas tran vdout1_5ck1810 FIND v(dout1_5) AT=910.025n

.meas tran vdout1_6ck1810 FIND v(dout1_6) AT=910.025n

.meas tran vdout1_7ck1810 FIND v(dout1_7) AT=910.025n

.meas tran vdout1_8ck1810 FIND v(dout1_8) AT=910.025n

.meas tran vdout1_9ck1810 FIND v(dout1_9) AT=910.025n

.meas tran vdout1_10ck1810 FIND v(dout1_10) AT=910.025n

.meas tran vdout1_11ck1810 FIND v(dout1_11) AT=910.025n

.meas tran vdout1_12ck1810 FIND v(dout1_12) AT=910.025n

.meas tran vdout1_13ck1810 FIND v(dout1_13) AT=910.025n

.meas tran vdout1_14ck1810 FIND v(dout1_14) AT=910.025n

.meas tran vdout1_15ck1810 FIND v(dout1_15) AT=910.025n

.meas tran vdout1_16ck1810 FIND v(dout1_16) AT=910.025n

.meas tran vdout1_0ck1820 FIND v(dout1_0) AT=915.025n

.meas tran vdout1_1ck1820 FIND v(dout1_1) AT=915.025n

.meas tran vdout1_2ck1820 FIND v(dout1_2) AT=915.025n

.meas tran vdout1_3ck1820 FIND v(dout1_3) AT=915.025n

.meas tran vdout1_4ck1820 FIND v(dout1_4) AT=915.025n

.meas tran vdout1_5ck1820 FIND v(dout1_5) AT=915.025n

.meas tran vdout1_6ck1820 FIND v(dout1_6) AT=915.025n

.meas tran vdout1_7ck1820 FIND v(dout1_7) AT=915.025n

.meas tran vdout1_8ck1820 FIND v(dout1_8) AT=915.025n

.meas tran vdout1_9ck1820 FIND v(dout1_9) AT=915.025n

.meas tran vdout1_10ck1820 FIND v(dout1_10) AT=915.025n

.meas tran vdout1_11ck1820 FIND v(dout1_11) AT=915.025n

.meas tran vdout1_12ck1820 FIND v(dout1_12) AT=915.025n

.meas tran vdout1_13ck1820 FIND v(dout1_13) AT=915.025n

.meas tran vdout1_14ck1820 FIND v(dout1_14) AT=915.025n

.meas tran vdout1_15ck1820 FIND v(dout1_15) AT=915.025n

.meas tran vdout1_16ck1820 FIND v(dout1_16) AT=915.025n

.meas tran vdout1_0ck1890 FIND v(dout1_0) AT=950.025n

.meas tran vdout1_1ck1890 FIND v(dout1_1) AT=950.025n

.meas tran vdout1_2ck1890 FIND v(dout1_2) AT=950.025n

.meas tran vdout1_3ck1890 FIND v(dout1_3) AT=950.025n

.meas tran vdout1_4ck1890 FIND v(dout1_4) AT=950.025n

.meas tran vdout1_5ck1890 FIND v(dout1_5) AT=950.025n

.meas tran vdout1_6ck1890 FIND v(dout1_6) AT=950.025n

.meas tran vdout1_7ck1890 FIND v(dout1_7) AT=950.025n

.meas tran vdout1_8ck1890 FIND v(dout1_8) AT=950.025n

.meas tran vdout1_9ck1890 FIND v(dout1_9) AT=950.025n

.meas tran vdout1_10ck1890 FIND v(dout1_10) AT=950.025n

.meas tran vdout1_11ck1890 FIND v(dout1_11) AT=950.025n

.meas tran vdout1_12ck1890 FIND v(dout1_12) AT=950.025n

.meas tran vdout1_13ck1890 FIND v(dout1_13) AT=950.025n

.meas tran vdout1_14ck1890 FIND v(dout1_14) AT=950.025n

.meas tran vdout1_15ck1890 FIND v(dout1_15) AT=950.025n

.meas tran vdout1_16ck1890 FIND v(dout1_16) AT=950.025n

.meas tran vdout1_0ck1900 FIND v(dout1_0) AT=955.025n

.meas tran vdout1_1ck1900 FIND v(dout1_1) AT=955.025n

.meas tran vdout1_2ck1900 FIND v(dout1_2) AT=955.025n

.meas tran vdout1_3ck1900 FIND v(dout1_3) AT=955.025n

.meas tran vdout1_4ck1900 FIND v(dout1_4) AT=955.025n

.meas tran vdout1_5ck1900 FIND v(dout1_5) AT=955.025n

.meas tran vdout1_6ck1900 FIND v(dout1_6) AT=955.025n

.meas tran vdout1_7ck1900 FIND v(dout1_7) AT=955.025n

.meas tran vdout1_8ck1900 FIND v(dout1_8) AT=955.025n

.meas tran vdout1_9ck1900 FIND v(dout1_9) AT=955.025n

.meas tran vdout1_10ck1900 FIND v(dout1_10) AT=955.025n

.meas tran vdout1_11ck1900 FIND v(dout1_11) AT=955.025n

.meas tran vdout1_12ck1900 FIND v(dout1_12) AT=955.025n

.meas tran vdout1_13ck1900 FIND v(dout1_13) AT=955.025n

.meas tran vdout1_14ck1900 FIND v(dout1_14) AT=955.025n

.meas tran vdout1_15ck1900 FIND v(dout1_15) AT=955.025n

.meas tran vdout1_16ck1900 FIND v(dout1_16) AT=955.025n

.meas tran vdout1_0ck1930 FIND v(dout1_0) AT=970.025n

.meas tran vdout1_1ck1930 FIND v(dout1_1) AT=970.025n

.meas tran vdout1_2ck1930 FIND v(dout1_2) AT=970.025n

.meas tran vdout1_3ck1930 FIND v(dout1_3) AT=970.025n

.meas tran vdout1_4ck1930 FIND v(dout1_4) AT=970.025n

.meas tran vdout1_5ck1930 FIND v(dout1_5) AT=970.025n

.meas tran vdout1_6ck1930 FIND v(dout1_6) AT=970.025n

.meas tran vdout1_7ck1930 FIND v(dout1_7) AT=970.025n

.meas tran vdout1_8ck1930 FIND v(dout1_8) AT=970.025n

.meas tran vdout1_9ck1930 FIND v(dout1_9) AT=970.025n

.meas tran vdout1_10ck1930 FIND v(dout1_10) AT=970.025n

.meas tran vdout1_11ck1930 FIND v(dout1_11) AT=970.025n

.meas tran vdout1_12ck1930 FIND v(dout1_12) AT=970.025n

.meas tran vdout1_13ck1930 FIND v(dout1_13) AT=970.025n

.meas tran vdout1_14ck1930 FIND v(dout1_14) AT=970.025n

.meas tran vdout1_15ck1930 FIND v(dout1_15) AT=970.025n

.meas tran vdout1_16ck1930 FIND v(dout1_16) AT=970.025n

.meas tran vdout1_0ck1950 FIND v(dout1_0) AT=980.025n

.meas tran vdout1_1ck1950 FIND v(dout1_1) AT=980.025n

.meas tran vdout1_2ck1950 FIND v(dout1_2) AT=980.025n

.meas tran vdout1_3ck1950 FIND v(dout1_3) AT=980.025n

.meas tran vdout1_4ck1950 FIND v(dout1_4) AT=980.025n

.meas tran vdout1_5ck1950 FIND v(dout1_5) AT=980.025n

.meas tran vdout1_6ck1950 FIND v(dout1_6) AT=980.025n

.meas tran vdout1_7ck1950 FIND v(dout1_7) AT=980.025n

.meas tran vdout1_8ck1950 FIND v(dout1_8) AT=980.025n

.meas tran vdout1_9ck1950 FIND v(dout1_9) AT=980.025n

.meas tran vdout1_10ck1950 FIND v(dout1_10) AT=980.025n

.meas tran vdout1_11ck1950 FIND v(dout1_11) AT=980.025n

.meas tran vdout1_12ck1950 FIND v(dout1_12) AT=980.025n

.meas tran vdout1_13ck1950 FIND v(dout1_13) AT=980.025n

.meas tran vdout1_14ck1950 FIND v(dout1_14) AT=980.025n

.meas tran vdout1_15ck1950 FIND v(dout1_15) AT=980.025n

.meas tran vdout1_16ck1950 FIND v(dout1_16) AT=980.025n

.meas tran vdout1_0ck1980 FIND v(dout1_0) AT=995.025n

.meas tran vdout1_1ck1980 FIND v(dout1_1) AT=995.025n

.meas tran vdout1_2ck1980 FIND v(dout1_2) AT=995.025n

.meas tran vdout1_3ck1980 FIND v(dout1_3) AT=995.025n

.meas tran vdout1_4ck1980 FIND v(dout1_4) AT=995.025n

.meas tran vdout1_5ck1980 FIND v(dout1_5) AT=995.025n

.meas tran vdout1_6ck1980 FIND v(dout1_6) AT=995.025n

.meas tran vdout1_7ck1980 FIND v(dout1_7) AT=995.025n

.meas tran vdout1_8ck1980 FIND v(dout1_8) AT=995.025n

.meas tran vdout1_9ck1980 FIND v(dout1_9) AT=995.025n

.meas tran vdout1_10ck1980 FIND v(dout1_10) AT=995.025n

.meas tran vdout1_11ck1980 FIND v(dout1_11) AT=995.025n

.meas tran vdout1_12ck1980 FIND v(dout1_12) AT=995.025n

.meas tran vdout1_13ck1980 FIND v(dout1_13) AT=995.025n

.meas tran vdout1_14ck1980 FIND v(dout1_14) AT=995.025n

.meas tran vdout1_15ck1980 FIND v(dout1_15) AT=995.025n

.meas tran vdout1_16ck1980 FIND v(dout1_16) AT=995.025n

.meas tran vdout1_0ck1990 FIND v(dout1_0) AT=1000.025n

.meas tran vdout1_1ck1990 FIND v(dout1_1) AT=1000.025n

.meas tran vdout1_2ck1990 FIND v(dout1_2) AT=1000.025n

.meas tran vdout1_3ck1990 FIND v(dout1_3) AT=1000.025n

.meas tran vdout1_4ck1990 FIND v(dout1_4) AT=1000.025n

.meas tran vdout1_5ck1990 FIND v(dout1_5) AT=1000.025n

.meas tran vdout1_6ck1990 FIND v(dout1_6) AT=1000.025n

.meas tran vdout1_7ck1990 FIND v(dout1_7) AT=1000.025n

.meas tran vdout1_8ck1990 FIND v(dout1_8) AT=1000.025n

.meas tran vdout1_9ck1990 FIND v(dout1_9) AT=1000.025n

.meas tran vdout1_10ck1990 FIND v(dout1_10) AT=1000.025n

.meas tran vdout1_11ck1990 FIND v(dout1_11) AT=1000.025n

.meas tran vdout1_12ck1990 FIND v(dout1_12) AT=1000.025n

.meas tran vdout1_13ck1990 FIND v(dout1_13) AT=1000.025n

.meas tran vdout1_14ck1990 FIND v(dout1_14) AT=1000.025n

.meas tran vdout1_15ck1990 FIND v(dout1_15) AT=1000.025n

.meas tran vdout1_16ck1990 FIND v(dout1_16) AT=1000.025n

.meas tran vdout1_0ck2010 FIND v(dout1_0) AT=1010.025n

.meas tran vdout1_1ck2010 FIND v(dout1_1) AT=1010.025n

.meas tran vdout1_2ck2010 FIND v(dout1_2) AT=1010.025n

.meas tran vdout1_3ck2010 FIND v(dout1_3) AT=1010.025n

.meas tran vdout1_4ck2010 FIND v(dout1_4) AT=1010.025n

.meas tran vdout1_5ck2010 FIND v(dout1_5) AT=1010.025n

.meas tran vdout1_6ck2010 FIND v(dout1_6) AT=1010.025n

.meas tran vdout1_7ck2010 FIND v(dout1_7) AT=1010.025n

.meas tran vdout1_8ck2010 FIND v(dout1_8) AT=1010.025n

.meas tran vdout1_9ck2010 FIND v(dout1_9) AT=1010.025n

.meas tran vdout1_10ck2010 FIND v(dout1_10) AT=1010.025n

.meas tran vdout1_11ck2010 FIND v(dout1_11) AT=1010.025n

.meas tran vdout1_12ck2010 FIND v(dout1_12) AT=1010.025n

.meas tran vdout1_13ck2010 FIND v(dout1_13) AT=1010.025n

.meas tran vdout1_14ck2010 FIND v(dout1_14) AT=1010.025n

.meas tran vdout1_15ck2010 FIND v(dout1_15) AT=1010.025n

.meas tran vdout1_16ck2010 FIND v(dout1_16) AT=1010.025n

.meas tran vdout1_0ck2020 FIND v(dout1_0) AT=1015.025n

.meas tran vdout1_1ck2020 FIND v(dout1_1) AT=1015.025n

.meas tran vdout1_2ck2020 FIND v(dout1_2) AT=1015.025n

.meas tran vdout1_3ck2020 FIND v(dout1_3) AT=1015.025n

.meas tran vdout1_4ck2020 FIND v(dout1_4) AT=1015.025n

.meas tran vdout1_5ck2020 FIND v(dout1_5) AT=1015.025n

.meas tran vdout1_6ck2020 FIND v(dout1_6) AT=1015.025n

.meas tran vdout1_7ck2020 FIND v(dout1_7) AT=1015.025n

.meas tran vdout1_8ck2020 FIND v(dout1_8) AT=1015.025n

.meas tran vdout1_9ck2020 FIND v(dout1_9) AT=1015.025n

.meas tran vdout1_10ck2020 FIND v(dout1_10) AT=1015.025n

.meas tran vdout1_11ck2020 FIND v(dout1_11) AT=1015.025n

.meas tran vdout1_12ck2020 FIND v(dout1_12) AT=1015.025n

.meas tran vdout1_13ck2020 FIND v(dout1_13) AT=1015.025n

.meas tran vdout1_14ck2020 FIND v(dout1_14) AT=1015.025n

.meas tran vdout1_15ck2020 FIND v(dout1_15) AT=1015.025n

.meas tran vdout1_16ck2020 FIND v(dout1_16) AT=1015.025n

.meas tran vdout1_0ck2040 FIND v(dout1_0) AT=1025.025n

.meas tran vdout1_1ck2040 FIND v(dout1_1) AT=1025.025n

.meas tran vdout1_2ck2040 FIND v(dout1_2) AT=1025.025n

.meas tran vdout1_3ck2040 FIND v(dout1_3) AT=1025.025n

.meas tran vdout1_4ck2040 FIND v(dout1_4) AT=1025.025n

.meas tran vdout1_5ck2040 FIND v(dout1_5) AT=1025.025n

.meas tran vdout1_6ck2040 FIND v(dout1_6) AT=1025.025n

.meas tran vdout1_7ck2040 FIND v(dout1_7) AT=1025.025n

.meas tran vdout1_8ck2040 FIND v(dout1_8) AT=1025.025n

.meas tran vdout1_9ck2040 FIND v(dout1_9) AT=1025.025n

.meas tran vdout1_10ck2040 FIND v(dout1_10) AT=1025.025n

.meas tran vdout1_11ck2040 FIND v(dout1_11) AT=1025.025n

.meas tran vdout1_12ck2040 FIND v(dout1_12) AT=1025.025n

.meas tran vdout1_13ck2040 FIND v(dout1_13) AT=1025.025n

.meas tran vdout1_14ck2040 FIND v(dout1_14) AT=1025.025n

.meas tran vdout1_15ck2040 FIND v(dout1_15) AT=1025.025n

.meas tran vdout1_16ck2040 FIND v(dout1_16) AT=1025.025n
